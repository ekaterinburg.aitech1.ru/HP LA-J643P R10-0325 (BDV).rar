# Allegro board LAJ643PR10-0325.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FBA_CMD18: length 37.6
  TOP w0.102: 190.97,120.08 190.87,120.19 190.87,126.48 v2(189.95,127.4) ; v2(202.76,97.84) 203.17,98.26 203.17,100.53 203.37,100.72 203.37,103.32 202.67,104.01
  TOP w0.196: 202.67,104.01 202.67,106.64 196.98,112.33 196.98,113.57 195.58,114.98 193.73,114.98 190.97,117.74 190.97,120.08
  BOTTOM w0.102: UG5.K11 v2(189.95,127.4)
  BOTTOM w0.196: v2(202.76,97.84) 202.78,97.84 UG1.AA28
FBA_CMD19: length 32.1
  TOP w0.102: 191.57,119.78 191.57,119.99 191.21,120.35 191.21,127.73 v2(190.95,127.98)
  TOP w0.196: v2(198.63,111.74) 198.42,111.74 197.59,112.58 197.59,113.82 195.83,115.58 193.98,115.58 191.57,117.99 191.57,119.78
  BOTTOM w0.102: UG5.H11 189.71,128.6 190.14,128.16 190.83,128.16 190.95,128.04 v2(190.95,127.98)
  BOTTOM w0.196: UG1.AC34 201.48,104.74 198.63,107.59 v2(198.63,111.74)
FBA_CMD20: length 33.5
  TOP w0.102: v2(190.91,128.6) 190.91,128.6 191.5,128.01 191.5,120.46 192.18,119.78 192.18,119.71
  TOP w0.196: 192.18,119.71 192.18,118.24 194.23,116.18 196.08,116.18 198.94,113.32 v2(199.16,113.32)
  BOTTOM w0.102: UG5.H10 v2(190.91,128.6)
  BOTTOM w0.196: v2(199.16,113.32) 198.96,113.32 198.02,112.38 198.02,107.32 201.08,104.26 201.08,102.74 UG1.AC33
FBA_CMD21: length 37.1
  TOP w0.102: v2(189.15,129) 191.08,129 191.77,128.3 191.77,120.6 192.78,119.6
  TOP w0.196: 192.78,119.6 192.78,118.49 194.48,116.78 196.33,116.78 198.68,114.43 199.57,114.43 199.76,114.24 199.76,111.72 v2(200.4,111.08)
  BOTTOM w0.102: UG5.G12 v2(189.15,129)
  BOTTOM w0.196: v2(200.4,111.08) 200.35,111.08 199.75,110.48 199.75,107.32 202.37,104.7 202.37,102.9 202.78,102.49 202.78,101.94 UG1.AA32
FBA_CMD22: length 34.8
  TOP w0.102: 193.62,119.72 192.53,120.81 192.53,127.32 193.41,128.2 v2(194.75,128.2)
  TOP w0.196: v2(201.01,113.09) 201.32,113.09 201.46,113.23 201.46,114.49 200.31,115.64 199.18,115.64 196.83,117.99 194.98,117.99 193.98,118.99 193.98,119.36 193.62,119.72
  BOTTOM w0.102: v2(194.75,128.2) 195.15,128.6 UG5.H4
  BOTTOM w0.196: v2(201.01,113.09) 201.01,106.99 201.83,106.17 202.77,105.23 202.77,102.95 203.18,102.54 UG1.AA33
FBA_CMD23: length 41
  IN1 w0.102: v2(193.75,128.6) 194.53,127.82 198.25,127.82 198.59,128.16 199.21,128.16
  IN1 w0.203: 199.21,128.16 199.76,128.16 202.92,125 202.92,121.57 205.41,119.08 205.41,112.41 203.93,110.94 203.93,106.19 204.91,105.21 204.91,104.07 205.28,103.71 205.28,102.01 204.73,101.47 204.73,98.99 v2(204.37,98.63)
  BOTTOM w0.196: v2(204.37,98.63) UG1.Y28 ; UG5.H5 v2(193.75,128.6)
FBA_CMD24: length 37.6
  IN1 w0.102: v2(195.55,127.4) 195.93,127.02 197.67,127.02 197.96,127.31 198.56,127.31 198.57,127.33 198.93,127.33 199.18,127.08 199.21,127.08
  IN1 w0.203: 199.21,127.08 199.9,127.08 202.31,124.67 202.31,121.32 204.8,118.83 204.8,112.68 203.3,111.18 203.3,106 203.88,105.41 203.88,101.25 204.26,100.87 204.26,99.35 v2(203.58,98.67)
  BOTTOM w0.102: v2(195.55,127.4) 195.15,127.8 UG5.J4
  BOTTOM w0.196: v2(203.58,98.67) 203.58,98.69 UG1.Y29
FBA_CMD25: length 36.4
  TOP w0.102: v2(203.58,100.34) 203.62,100.38 203.62,103.43 203.25,103.8 ; v2(193.75,127.8) 193.72,127.8 192.78,126.86 192.78,120.99 194.42,119.35
  TOP w0.196: 194.42,119.35 195.18,118.59 197.08,118.59 199.43,116.24 200.57,116.24 202.06,114.75 202.06,110.1 202.16,110 202.16,109.96 203.48,108.64 203.48,108.21 203.48,107.71 203.39,107.61 203.39,107.56 203.25,107.42 203.25,103.8
  BOTTOM w0.102: v2(193.75,127.8) 193.75,127.8 UG5.J5
  BOTTOM w0.196: UG1.W31 204.53,100.74 204.13,100.34 v2(203.58,100.34)
FBA_CMD26: length 37.3
  TOP w0.102: v2(203.58,99.52) 203.96,99.9 203.96,104.24 203.86,104.34 ; v2(194.75,127.4) 194.73,127.38 193.66,127.38 193.04,126.76 193.04,121.22 194.61,119.64
  TOP w0.196: 203.86,104.34 203.86,107.18 203.99,107.31 203.99,107.36 204.15,107.52 204.15,108.86 202.66,110.35 202.66,115.03 200.85,116.84 199.68,116.84 197.33,119.19 195.87,119.19 195.43,119.64 194.61,119.64
  BOTTOM w0.102: UG5.K4 v2(194.75,127.4)
  BOTTOM w0.196: UG1.Y30 203.98,99.91 v2(203.58,99.52)
FBA_CMD27: length 32.6
  TOP w0.102: v2(193.75,126.9) 193.29,126.44 193.29,121.42 194.66,120.05
  TOP w0.196: 194.66,120.05 195.78,120.05 196.03,119.79 197.58,119.79 199.93,117.44 201.14,117.44 203.6,114.97 v2(203.6,114.17)
  BOTTOM w0.102: UG5.K5 193.85,127 v2(193.75,126.9)
  BOTTOM w0.196: v2(203.6,114.17) 201.62,112.18 201.62,107.24 202.08,106.77 203.18,105.68 UG1.AA34
FBA_CMD28: length 36.6
  TOP w0.102: v2(195.55,126.6) 194.18,126.6 193.54,125.96 193.54,121.63 194.67,120.5
  TOP w0.196: v2(203.62,112.95) 203.66,112.95 204.21,113.5 204.21,115.22 201.39,118.04 200.18,118.04 197.85,120.37 196.1,120.37 195.96,120.5 194.67,120.5
  BOTTOM w0.102: UG5.L3 v2(195.55,126.6)
  BOTTOM w0.196: UG1.Y31 203.58,101.14 203.58,106.13 202.22,107.49 202.22,111.54 v2(203.62,112.95)
FBA_CMD29: length 30
  TOP w0.152: RG90.2 199.25,127.34 197.57,127.34 197.51,127.4 v2(197.15,127.4)
  TOP w0.196: v2(204.41,104.94) 204.41,106.43 204.59,106.62 204.59,107.12 204.75,107.27 204.75,108.76 204.81,108.83 204.81,122.21 RG90.2
  BOTTOM w0.102: UG5.J2 196.75,127.8 v2(197.15,127.4)
  BOTTOM w0.196: v2(204.41,104.94) 203.93,104.47 203.93,103.19 UG1.Y34
FBA_CMD30: length 33.4
  TOP w0.102: RG88.2 199.15,128.2 197.76,128.2 197.39,128.58 197.27,128.58 197.27,128.58 196.72,128.58 196.35,128.21 v2(196.35,128.2)
  TOP w0.196: v2(204.41,103.54) 204.89,104.02 204.89,106.56 205.35,107.02 205.35,108.52 205.42,108.58 205.42,122.58 RG88.2
  BOTTOM w0.102: v2(196.35,128.2) 195.95,127.8 UG5.J3
  BOTTOM w0.196: UG1.Y33 203.98,102.53 204.37,102.92 204.37,103.5 v2(204.41,103.54)
FBA_CMD31: length 38.7
  TOP w0.102: v2(195.55,129) 193.51,129 192.27,127.76 192.27,120.6 193.38,119.5
  TOP w0.196: v2(202.84,107.96) 202.62,107.96 201.22,109.36 201.22,111.12 200.36,111.97 200.36,114.49 199.82,115.03 198.93,115.03 196.58,117.39 194.73,117.39 193.38,118.74 193.38,119.5
  BOTTOM w0.102: UG5.G3 195.95,129.4 v2(195.55,129)
  BOTTOM w0.196: UG1.V31 205.68,100.98 205.26,101.41 205.26,105.54 v2(202.84,107.96)
FBA_D0: length 27
  IN1 w0.102: v2(211.91,97.84) 211.11,98.64 211.11,104.42
  IN1 w0.147: 211.02,105.29 211.02,104.51 211.11,104.42
  IN1 w0.152: v2(216.6,121) 216.6,120.48 216.44,120.33 216.44,116.61 215.14,115.3 215.14,112.12 211.02,108 211.02,105.29
  BOTTOM w0.102: UG4.A4 v2(216.6,121)
  BOTTOM w0.152: v2(211.91,97.84) 211.51,98.24 UG1.L28
FBA_D1: length 26
  IN1 w0.102: v2(210.26,98.67) 210.64,99.05 210.64,102.1 210.38,102.36 210.05,102.36 209.82,102.58 209.82,104.58 209.9,104.66
  IN1 w0.152: 209.9,104.66 209.9,108.46 213.59,112.15 213.59,115.53 214.2,116.14 v2(214.2,121)
  BOTTOM w0.102: UG4.A2 214.59,121.39 v2(214.2,121)
  BOTTOM w0.152: UG1.M29 v2(210.26,98.67)
FBA_D2: length 26.9
  IN1 w0.102: v2(211.91,98.67) 211.48,99.09 211.48,103.96
  IN1 w0.147: 211.48,105.24 211.48,103.96
  IN1 w0.152: 211.48,105.24 211.48,106.92 211.91,107.36 211.91,108.1 211.97,108.16 212.12,108.32 215.69,111.89 215.69,112.35 215.69,114.94 217,116.25 217,121.39 v2(216.6,121.8)
  BOTTOM w0.102: UG4.B4 v2(216.6,121.8)
  BOTTOM w0.152: UG1.L29 v2(211.91,98.67)
FBA_D3: length 27.7
  IN1 w0.102: 214.6,120.69 214.6,121.39 v2(214.2,121.8) ; v2(210.26,97.84) 210.84,98.42 210.84,104.25 210.46,104.63 210.46,105.25
  IN1 w0.152: 210.46,105.25 210.46,108.23 214.14,111.92 214.14,115.3 214.93,116.09 214.93,120.35 214.6,120.69
  BOTTOM w0.102: UG4.B2 214.59,122.19 v2(214.2,121.8)
  BOTTOM w0.152: UG1.M28 210.66,98.24 v2(210.26,97.84)
FBA_D4: length 31.1
  IN1 w0.102: v2(215.8,124.2) 215.38,123.78 214.04,123.78 213.66,123.4 212,123.4 ; 208.06,102.61 208.15,102.52 208.15,101.84 208.53,101.45 208.53,101.19 209.38,100.34 v2(209.41,100.34)
  IN1 w0.152: 208.06,102.61 208.02,102.64 208.02,106.33 207.51,106.84 207.51,109.45 211.1,113.04 211.1,122.73 211.76,123.4 212,123.4
  BOTTOM w0.102: UG4.E4 216.19,124.6 v2(215.8,124.2)
  BOTTOM w0.152: UG1.N31 209.43,100.34 v2(209.41,100.34)
FBA_D5: length 32.4
  IN1 w0.102: 207.69,102.37 207.69,101.8 208.18,101.31 208.18,100.2 208.43,99.95 208.68,99.95 208.97,99.67 209,99.63 209,99.07 v2(209.41,98.67) ; 212.13,124.2 v2(214.2,124.2)
  IN1 w0.152: 207.69,102.37 207.54,102.52 207.54,106 206.95,106.59 206.95,109.68 210.54,113.27 210.54,123.21 211.53,124.2 212.13,124.2
  BOTTOM w0.102: v2(214.2,124.2) 214.59,124.6 UG4.E2
  BOTTOM w0.152: v2(209.41,98.67) UG1.P29
FBA_D6: length 35.2
  IN1 w0.102: v2(215.8,125) 215.41,124.62 214.04,124.62 213.68,124.98 212.2,124.98 ; 207.11,105.57 207.11,102.37 207.29,102.19 207.29,100.27 207.62,99.94 207.87,99.94 208.14,99.67 208.14,99.05 v2(207.76,98.67)
  IN1 w0.152: 212.2,124.98 211.52,124.98 209.98,123.44 209.98,116.54 208.91,115.48 208.91,112.43 206.39,109.91 206.39,106.28 207.11,105.57
  BOTTOM w0.102: v2(215.8,125) 216.19,125.4 UG4.F4
  BOTTOM w0.152: UG1.R29 v2(207.76,98.67)
FBA_D7: length 36
  IN1 w0.102: v2(208.58,98.67) 208.2,98.28 207.6,98.28 207.59,98.29 207.37,98.51 207.37,98.74 207.06,99.05 206.84,99.05 206.52,99.36 206.52,105.43 ; 211.78,125.78 213.41,125.78 v2(214.2,125)
  IN1 w0.152: 211.78,125.78 211.56,125.78 211.32,125.54 211.29,125.54 209.42,123.67 209.42,116.77 208.35,115.71 208.35,112.67 205.83,110.15 205.83,106.12 206.52,105.43
  BOTTOM w0.102: v2(214.2,125) 214.59,125.4 UG4.F2
  BOTTOM w0.152: UG1.P28 208.58,98.64 v2(208.58,98.67)
FBA_D8: length 29.3
  IN1 w0.102: 214.65,105.85 214.65,105.49 213.75,104.59 213.75,103.88 213,103.13 213,101.69 213.34,101.34 213.34,99.25 v2(212.76,98.67)
  IN1 w0.152: v2(221.92,120.67) 221.98,120.62 221.98,120.22 224.11,118.08 224.11,116.17 223.43,115.49 223.43,114.62 214.65,105.85
  BOTTOM w0.102: UG4.A11 221.8,120.8 v2(221.92,120.67)
  BOTTOM w0.152: UG1.J28 v2(212.76,98.67)
FBA_D9: length 28.2
  IN1 w0.102: 216.42,106.03 216.1,105.71 215.96,105.71 214.6,104.35 214.6,102.74 214.02,102.17 214.02,100.05 214.41,99.67 v2(214.41,99.52)
  IN1 w0.147: v2(223.8,121) 223.68,120.88 223.68,120.25
  IN1 w0.152: 223.68,120.25 223.68,120.11 225.23,118.57 225.23,115.71 224.55,115.02 224.55,114.16 216.42,106.03
  BOTTOM w0.102: UG4.A13 v2(223.8,121)
  BOTTOM w0.152: v2(214.41,99.52) UG1.H29
FBA_D10: length 29.4
  IN1 w0.102: v2(212.78,99.47) 213.14,99.82 213.14,101.26 212.79,101.6 212.79,103.28 213.13,103.61 213.13,104.61 214.04,105.52 214.04,105.8 214.23,105.99 214.23,106.03
  IN1 w0.152: 214.23,106.03 214.23,106.22 222.87,114.85 222.87,115.72 223.55,116.4 223.55,117.85 221.42,119.98 221.42,121.02 v2(222.2,121.8)
  BOTTOM w0.102: UG4.B11 v2(222.2,121.8)
  BOTTOM w0.152: v2(212.78,99.47) 213.16,99.09 UG1.J29
FBA_D11: length 30.6
  IN1 w0.102: v2(214.5,98.64) 214.02,99.11 214.02,99.76 213.77,100.01 213.77,101.21 213.2,101.78 213.2,102.98 214.17,103.95 214.17,104.57 215.62,106.03
  IN1 w0.152: 215.62,106.03 223.99,114.39 223.99,115.25 224.67,115.94 224.67,118.31 223.12,119.86 223.12,121.12 v2(223.8,121.8)
  BOTTOM w0.102: UG4.B13 223.4,122.19 v2(223.8,121.8)
  BOTTOM w0.152: UG1.H28 214.38,98.64 v2(214.5,98.64)
FBA_D12: length 35.8
  IN1 w0.102: 218.53,105.12 218.13,104.72 216.72,104.72 216.46,104.46 216.46,102.57 215.95,102.06 215.95,101.66 215.68,101.39 215.68,99.94 v2(215.26,99.52) ; v2(222.2,124.2) 222.61,123.78 224.13,123.78 224.51,123.41 225.68,123.41
  IN1 w0.147: 218.53,105.12 218.93,105.12
  IN1 w0.152: 218.93,105.12 226.83,113.02 226.83,114.08 227.52,114.76 227.52,121.57 225.68,123.41
  BOTTOM w0.102: UG4.E11 v2(222.2,124.2)
  BOTTOM w0.152: UG1.G29 v2(215.26,99.52)
FBA_D13: length 36.2
  IN1 w0.102: v2(216.91,101.14) 216.91,101.63 218.4,103.12 219.5,103.12 220.5,104.12 220.5,104.19 ; 226.03,125.78 224.49,125.78 224.11,125.41 223.4,125.41 v2(223,125)
  IN1 w0.152: 220.5,104.19 228.51,112.2 228.51,113.38 229.19,114.06 229.19,122.62 226.03,125.78
  BOTTOM w0.102: UG4.E13 v2(223,125)
  BOTTOM w0.152: v2(216.91,101.14) 216.51,100.74 UG1.E31
FBA_D14: length 34.6
  IN1 w0.102: v2(222.2,125) 222.61,124.58 224.16,124.58 224.54,124.2 225.81,124.2 ; v2(216.08,101.14) 216.23,101.29 216.23,102.05 216.83,102.65 216.83,103.03 217.17,103.37 217.56,103.37 218.95,104.76 219.49,104.76 220.05,105.32
  IN1 w0.152: 225.81,124.2 228.07,121.93 228.07,114.53 227.39,113.84 227.39,112.66 220.05,105.32
  BOTTOM w0.102: v2(222.2,125) 221.8,125.39 UG4.F11
  BOTTOM w0.152: UG1.E32 v2(216.08,101.14)
FBA_D15: length 34.8
  IN1 w0.102: 220.2,104.68 220.08,104.68 219.81,104.41 218.91,104.41 218.16,103.66 218.16,103.21 216.48,101.53 216.48,100.74 v2(216.08,100.34) ; v2(223.8,125) 225.93,125
  IN1 w0.152: 220.2,104.68 227.95,112.43 227.95,113.61 228.63,114.3 228.63,122.29 225.93,125
  BOTTOM w0.102: v2(223.8,125) 223.4,125.39 UG4.F13
  BOTTOM w0.152: UG1.F30 v2(216.08,100.34)
FBA_D16: length 40.9
  IN3 w0.102: 225.65,134.58 222.98,134.58 v2(222.2,133.8)
  IN3 w0.155: v2(218.58,103.54) 219.06,104.02 219.06,106.44 228.13,115.51 228.13,132.1 225.65,134.58
  BOTTOM w0.102: v2(222.2,133.8) 221.8,134.2 UG4.U11
  BOTTOM w0.152: UG1.C34 v2(218.58,103.54)
FBA_D17: length 39.2
  IN3 w0.102: v2(223.8,133.8) 224.61,132.98 226.01,132.98
  IN3 w0.155: v2(217.76,101.94) 217.76,103.3 218.49,104.03 218.49,106.68 227.26,115.45 227.26,131.77 226.04,132.98 226.01,132.98
  BOTTOM w0.102: v2(223.8,133.8) 223.4,134.2 UG4.U13
  BOTTOM w0.152: v2(217.76,101.94) 217.73,101.94 UG1.D32
FBA_D18: length 43.9
  IN3 w0.155: v2(221.4,133.8) 223.01,135.41 225.61,135.41 228.69,132.33 228.69,115.26 219.63,106.2 219.63,104.72 219.35,104.44 219.35,103.59 v2(219.39,103.55)
  BOTTOM w0.102: UG4.T11 v2(221.4,133.8)
  BOTTOM w0.152: v2(219.39,103.55) 219.39,102.75 219.23,102.59 UG1.B33
FBA_D19: length 37.4
  IN3 w0.102: v2(223.8,133) 224.58,132.22 225.83,132.22
  IN3 w0.155: 225.83,132.22 226.68,131.36 226.68,115.72 217.44,106.48 217.44,104.69 v2(217.89,104.24)
  BOTTOM w0.102: v2(223.8,133) 223.4,133.39 UG4.T13
  BOTTOM w0.152: v2(217.89,104.24) 217.89,103.42 217.76,103.28 217.76,102.77 217.93,102.59 UG1.C33
FBA_D20: length 36.4
  IN3 w0.102: 220.22,131.78 221.01,131.78 v2(221.4,131.4)
  IN3 w0.155: v2(215.26,101.94) 213.12,104.07 213.12,108.24 218.59,113.7 218.59,128.66 218.43,128.82 218.43,130.15 218.77,130.49 219.1,130.82 220.06,131.78 220.22,131.78
  BOTTOM w0.102: UG4.N11 v2(221.4,131.4)
  BOTTOM w0.152: v2(215.26,101.94) 215.66,102.34 UG1.F33
FBA_D21: length 33.4
  IN3 w0.102: 215.12,104.27 215.7,103.69 215.7,103.23 216.08,102.85 v2(216.08,102.74) ; 222.23,129.15 222.61,129.53 222.61,130.22 v2(223,130.6)
  IN3 w0.155: 222.23,129.15 220.71,127.63 220.71,113.14 215.14,107.56 215.14,104.48 215.12,104.46 215.12,104.27
  BOTTOM w0.102: UG4.N13 v2(223,130.6)
  BOTTOM w0.152: UG1.F32 216.08,101.94 v2(216.08,102.74)
FBA_D22: length 34
  IN3 w0.102: 220.72,130.21 221.81,130.21 v2(222.2,130.6)
  IN3 w0.155: 220.72,130.21 220.11,130.21 219.58,129.68 219.58,129.31 219.76,129.13 219.76,113.19 214.58,108.01 214.58,104.22 v2(215.26,103.54)
  BOTTOM w0.102: v2(222.2,130.6) 221.8,130.2 UG4.M11
  BOTTOM w0.152: v2(215.26,103.54) 215.08,103.37 215.01,103.37 UG1.H33
FBA_D23: length 40.1
  IN3 w0.102: 214.85,103.16 215.38,103.16 215.64,102.9 215.64,101.78 215.38,101.52 214.79,101.52 v2(214.41,101.14) ; 220.22,131.02 223.12,131.02 223.41,130.72 223.41,130.18 v2(223.8,129.8)
  IN3 w0.155: 220.22,131.02 220.11,131.02 219.34,130.25 219.01,129.91 219.01,129.06 219.19,128.88 219.19,113.41 214.02,108.24 214.02,107.98 214.01,107.97 214.01,104 214.85,103.16
  BOTTOM w0.102: UG4.M13 223.4,130.2 v2(223.8,129.8)
  BOTTOM w0.152: v2(214.41,101.14) 214.38,101.14 UG1.H32
FBA_D24: length 39.6
  IN3 w0.102: v2(216.6,134.6) 216.21,134.22 216.21,133.68 215.92,133.38 213.91,133.38 213.54,133 212.42,133 212.24,133.18 212.04,133.18
  IN3 w0.155: 212.04,133.18 211.62,133.18 210.99,132.55 209.72,131.28 209.72,119.13 209.98,118.87 209.98,112.27 207.89,110.18 207.89,105.6 208.75,104.74 v2(209.41,104.74)
  BOTTOM w0.102: UG4.U4 v2(216.6,134.6)
  BOTTOM w0.152: v2(209.41,104.74) 208.98,104.32 UG1.P34
FBA_D25: length 42.1
  IN3 w0.155: v2(215,134.6) 214.2,135.4 210.66,135.4 208.13,132.87 208.13,132.85 208.1,132.82 208.1,132.81 208.03,132.75 208.03,116.68 207.76,116.41 207.76,112.58 206.16,110.98 206.16,104.36 v2(208.58,101.94)
  BOTTOM w0.102: UG4.U2 v2(215,134.6)
  BOTTOM w0.152: UG1.P32 v2(208.58,101.94)
FBA_D26: length 42.8
  IN3 w0.102: v2(209.41,101.14) 209.01,101.53 209.01,102.37 ; v2(215.8,133.8) 215.41,134.18 213.96,134.18 213.54,134.6 212.04,134.6
  IN3 w0.155: 212.04,134.6 210.67,134.6 208.66,132.59 208.66,132.58 208.59,132.51 208.59,116.45 208.33,116.18 208.33,112.35 206.74,110.76 206.74,104.65 209.01,102.37
  BOTTOM w0.102: UG4.T4 v2(215.8,133.8)
  BOTTOM w0.152: v2(209.41,101.14) 209.38,101.14 UG1.P31
FBA_D27: length 38.3
  IN3 w0.102: 212.32,133.8 v2(214.2,133.8)
  IN3 w0.155: v2(209.41,103.54) 209.14,103.54 207.31,105.37 207.31,110.39 208.89,111.97 208.89,115.94 209.16,116.21 209.16,132.28 210.84,133.97 212.14,133.97 212.32,133.8
  BOTTOM w0.102: UG4.T2 v2(214.2,133.8)
  BOTTOM w0.152: UG1.P33 209.41,102.77 v2(209.41,103.54)
FBA_D28: length 34.1
  IN3 w0.102: 216.78,128.59 216.76,128.61 216.41,128.61 216.18,128.84 216.18,130.22 v2(215.8,130.6)
  IN3 w0.155: 216.78,128.59 217,128.37 217,115.88 215.41,114.29 215.41,112.26 211.43,108.27 211.43,106.01 v2(211.91,105.53)
  BOTTOM w0.102: UG4.N4 v2(215.8,130.6)
  BOTTOM w0.152: v2(211.91,105.53) 211.53,105.16 211.53,105.16 211.08,104.71 211.08,101.14 UG1.L31
FBA_D29: length 30.3
  IN3 w0.102: v2(214.2,130.6) 214.2,130.46 214.58,130.08 214.58,129.14 213.74,128.3
  IN3 w0.155: v2(211.91,104.14) 211.47,104.58 211.47,105.23 210.87,105.83 210.87,108.97 213.74,111.84 213.74,128.3
  BOTTOM w0.102: UG4.N2 v2(214.2,130.6)
  BOTTOM w0.152: UG1.L34 211.48,103.72 211.55,103.78 v2(211.91,104.14)
FBA_D30: length 33.5
  IN3 w0.102: 217.52,128.76 217.1,128.76 216.98,128.88 216.98,129.42 v2(216.6,129.8)
  IN3 w0.155: 217.52,128.76 217.54,128.76 217.92,128.39 217.92,113.97 212.01,108.06 v2(212.01,106.71)
  BOTTOM w0.102: UG4.M4 v2(216.6,129.8)
  BOTTOM w0.152: UG1.L32 211.88,101.94 212.54,101.94 212.78,102.18 212.78,104.95 212.46,105.27 212.46,106.59 212.33,106.71 v2(212.01,106.71)
FBA_D31: length 34.5
  IN3 w0.102: v2(215,129.8) 215,130.02 214.61,130.4 214.61,130.72 214.35,130.98 213.97,130.98 213.71,130.72 213.71,128.66 213.3,128.25 212.87,128.25
  IN3 w0.155: v2(211.91,102.74) 211.2,103.45 211.2,104.93 210.29,105.84 210.29,109.19 213.08,111.98 213.08,119.44 212.11,120.4 212.11,127.49 212.87,128.25
  BOTTOM w0.102: UG4.M2 v2(215,129.8)
  BOTTOM w0.152: v2(211.91,102.74) 211.51,102.34 UG1.L33
FBA_D32: length 26.3
  IN1 w0.102: v2(197.72,97.91) 197.72,98.04 198.14,98.45 198.14,98.76 198.34,98.96 198.34,101.74 197.99,102.08 197.99,103.87 197.66,104.2 197.66,105.31 197.23,105.74
  IN1 w0.152: 197.23,105.74 196.7,106.27 196.7,108.5 197.08,108.89 197.08,116.31 194.76,118.63 v2(194.76,120.99)
  BOTTOM w0.102: v2(194.76,120.99) 195.15,121.39 UG5.U4
  BOTTOM w0.152: v2(197.72,97.91) 198.08,98.17 UG1.AG28
FBA_D33: length 24.7
  IN1 w0.102: 198.22,106.41 198.22,105.8 198.32,105.7 198.32,105.04 199,104.36 199,99.07 v2(199.41,98.67)
  IN1 w0.152: 198.22,106.41 198.19,106.43 198.19,116.77 196.87,118.09 196.87,120.71 v2(197.15,120.99)
  BOTTOM w0.102: UG5.U2 196.75,121.39 v2(197.15,120.99)
  BOTTOM w0.152: v2(199.41,98.67) UG1.AF29
FBA_D34: length 26.8
  IN1 w0.102: 196.93,105.54 197.31,105.16 197.31,104.05 197.61,103.74 197.61,101.88 198.14,101.35 198.14,99.05 v2(197.76,98.67)
  IN1 w0.152: 196.93,105.54 196.71,105.54 196.14,106.11 196.14,108.74 196.52,109.12 196.52,116.05 194.18,118.39 194.18,121.23 v2(194.75,121.8)
  BOTTOM w0.102: v2(194.75,121.8) 195.15,122.19 UG5.T4
  BOTTOM w0.152: v2(197.76,98.67) UG1.AG29
FBA_D35: length 26.7
  IN1 w0.102: v2(199.41,97.84) 198.68,98.56 198.68,102.07 198.41,102.34 198.41,104.34 197.99,104.76 197.99,105.36 197.66,105.69 197.66,106.51 ; 195.96,120.55 195.96,121.4 v2(196.35,121.8)
  IN1 w0.152: 197.66,106.51 197.63,106.54 197.63,116.54 195.96,118.21 195.96,120.55
  BOTTOM w0.102: v2(196.35,121.8) 196.75,122.19 UG5.T2
  BOTTOM w0.152: UG1.AF28 199.38,97.84 v2(199.41,97.84)
FBA_D36: length 31.6
  IN1 w0.102: 198.91,123.41 197.89,123.41 197.51,123.8 195.95,123.8 v2(195.55,124.2) ; 201.46,104.53 201.46,100.18 201.21,99.93 200.67,99.93 v2(200.26,99.52)
  IN1 w0.152: 198.91,123.41 199.47,123.41 199.89,122.99 199.89,118.49 201.5,116.89 201.5,112.73 200.94,112.17 200.94,110.08 200.68,109.82 200.68,105.31 201.46,104.53
  BOTTOM w0.102: UG5.N4 v2(195.55,124.2)
  BOTTOM w0.152: UG1.AD30 v2(200.26,99.52)
FBA_D37: length 32.9
  IN1 w0.102: 202.3,104.58 202.3,100.19 202.04,99.94 201.79,99.94 201.47,99.62 201.47,99.33 201.08,98.94 v2(201.08,98.67) ; 199.21,124.2 197.73,124.2 197.32,124.6 196.74,124.6 v2(196.35,125)
  IN1 w0.152: 202.3,104.58 201.24,105.64 201.24,109.59 201.5,109.84 201.5,111.93 202.05,112.49 202.05,117.12 200.45,118.72 200.45,123.58 199.84,124.2 199.21,124.2
  BOTTOM w0.102: UG5.N2 v2(196.35,125)
  BOTTOM w0.152: v2(201.08,98.67) 201.08,98.69 UG1.AD29
FBA_D38: length 36.1
  IN1 w0.102: 199.21,125.74 199.17,125.78 197.99,125.78 197.61,125.39 195.94,125.39 v2(195.55,125) ; v2(201.91,98.67) 202.33,99.09 202.87,99.09 203.15,99.37 203.15,100.52 203.26,100.63
  IN1 w0.147: 203.42,104.4 203.42,103.57
  IN1 w0.152: 203.42,104.4 203.42,105.16 202.36,106.22 202.36,109.13 202.61,109.38 202.61,111.47 203.17,112.03 203.17,117.66 201.62,119.21 201.62,124.26 200.15,125.74 199.21,125.74 ; 203.42,103.57 203.42,100.79 203.26,100.63
  BOTTOM w0.102: UG5.M4 195.15,125.39 v2(195.55,125)
  BOTTOM w0.152: UG1.AC29 v2(201.91,98.67)
FBA_D39: length 34.1
  IN1 w0.102: 199.21,125 v2(197.15,125) ; 203.06,100.83 202.83,100.6 202.83,100.22 202.33,99.72 202.33,99.4 202.01,99.08 201.78,99.08 201.48,98.78 201.48,98.24 v2(201.08,97.84)
  IN1 w0.152: 199.21,125 199.9,125 201.01,123.89 201.01,118.95 202.61,117.35 202.61,112.26 202.05,111.7 202.05,109.61 201.8,109.36 201.8,105.81 202.9,104.71 202.9,101.77 203.16,101.51 203.16,100.94 203.06,100.83
  BOTTOM w0.102: v2(197.15,125) 196.75,125.39 UG5.M2
  BOTTOM w0.152: UG1.AD28 v2(201.08,97.84)
FBA_D40: length 27
  IN1 w0.102: 194.78,105.88 195.61,105.05 195.61,103.96 196.52,103.05 196.52,102.58 196.75,102.36 197.05,102.36 197.31,102.1 197.31,99.95 v2(196.9,99.53)
  IN1 w0.152: 194.78,105.88 194.52,106.14 194.52,110.59 188.82,116.29 188.82,119.87 v2(189.95,121)
  BOTTOM w0.102: UG5.U11 v2(189.95,121)
  BOTTOM w0.152: v2(196.9,99.53) 196.87,99.53 196.79,99.45 UG1.AJ29
FBA_D41: length 27.4
  IN1 w0.102: 194.12,105.32 194.56,105.32 194.89,104.99 194.89,103.44 195.46,102.88 195.46,101 195.69,100.77 195.69,100.03 195.62,99.96 195.62,99 v2(196.01,98.62)
  IN1 w0.152: v2(187.55,121) 187.7,120.84 187.7,115.83 193.41,110.13 193.41,106.04 194.12,105.32
  BOTTOM w0.102: UG5.U13 187.95,121.39 v2(187.55,121)
  BOTTOM w0.152: UG1.AK29 v2(196.01,98.62)
FBA_D42: length 26.8
  IN1 w0.102: 194.75,105.58 195.25,105.09 195.25,103.74 195.69,103.3 195.69,101.8 195.95,101.53 196.23,101.53 196.46,101.3 196.46,100.71 v2(196.11,100.36) ; 188.78,120.58 188.78,121.42 v2(189.15,121.8)
  IN1 w0.152: 188.78,120.58 188.26,120.07 188.26,116.06 193.96,110.36 193.96,106.13 194.51,105.58 194.75,105.58
  BOTTOM w0.102: UG5.T11 189.55,122.19 v2(189.15,121.8)
  BOTTOM w0.152: v2(196.11,100.36) 196.47,99.95 UG1.AJ30
FBA_D43: length 28.6
  IN1 w0.102: 193.65,104.74 194,104.39 194,103.41 194.25,103.15 194.53,103.15 195.23,102.45 195.23,100.94 195.49,100.69 195.49,100.15 195.15,99.82 195.02,99.82 194.8,99.6 194.8,99 v2(195.18,98.62)
  IN1 w0.152: v2(187.55,121.8) 187.14,121.39 187.14,115.6 192.85,109.89 192.85,105.54 193.65,104.74
  BOTTOM w0.102: UG5.T13 187.95,122.19 v2(187.55,121.8)
  BOTTOM w0.152: v2(195.18,98.62) 195.18,98.59 UG1.AK28
FBA_D44: length 34.2
  IN1 w0.102: 185.45,123.37 185.46,123.38 186.99,123.38 187.41,123.8 188.75,123.8 v2(189.15,124.2) ; v2(193.58,99.44) 193.96,99.82 193.96,101.27 193.74,101.5 193.49,101.5 193.2,101.78 193.2,102.06 192.9,102.36 191.83,102.36
  IN1 w0.152: 185.45,123.37 184.62,122.54 184.62,114.74 190.56,108.8 190.56,103.63 191.83,102.36
  BOTTOM w0.102: UG5.N11 189.55,124.6 v2(189.15,124.2)
  BOTTOM w0.152: v2(193.58,99.44) UG1.AM29
FBA_D45: length 32.9
  IN1 w0.102: v2(193.58,101.12) 193.32,101.12 192.91,101.53 191.67,101.53 191.62,101.58 ; 185.35,124.21 186.93,124.21 187.3,124.58 187.97,124.58 188.35,124.2 v2(188.35,124.2)
  IN1 w0.152: 191.62,101.58 191.58,101.58 190,103.16 190,108.57 184.06,114.51 184.06,122.92 185.35,124.21
  BOTTOM w0.102: UG5.N13 v2(188.35,124.2)
  BOTTOM w0.152: v2(193.58,101.12) 193.58,101.09 UG1.AM31
FBA_D46: length 38.1
  IN1 w0.102: v2(189.15,125) 188.75,125.4 187.32,125.4 186.93,125.79 184.9,125.79
  IN1 w0.152: 184.9,125.79 182.94,123.84 182.94,114.05 188.88,108.11 188.88,101.96 192.23,98.62 v2(192.78,98.62)
  BOTTOM w0.102: UG5.M11 189.55,125.4 v2(189.15,125)
  BOTTOM w0.152: UG1.AN29 192.78,98.64 v2(192.78,98.62)
FBA_D47: length 34.7
  IN1 w0.102: v2(187.55,125) 185.32,125 ; v2(193.58,100.27) 193.18,99.86 191.77,99.86
  IN1 w0.152: 191.77,99.86 189.44,102.19 189.44,108.34 183.5,114.28 183.5,123.18 185.32,125
  BOTTOM w0.102: v2(187.55,125) 187.95,125.4 UG5.M13
  BOTTOM w0.152: UG1.AM30 193.58,100.24 v2(193.58,100.27)
FBA_D48: length 45.8
  IN3 w0.102: v2(189.15,133.8) 187.97,134.98 187.34,134.98 186.98,134.62 185.35,134.62
  IN3 w0.155: v2(191.34,101.06) 190.62,101.78 190.62,104.01 190.16,104.47 190.16,107.22 189.46,107.93 189.46,113.08 182.39,120.15 182.39,132.17 184.84,134.62 185.35,134.62
  BOTTOM w0.102: UG5.A11 v2(189.15,133.8)
  BOTTOM w0.152: UG1.AN31 191.71,100.69 v2(191.34,101.06)
FBA_D49: length 42.1
  IN3 w0.102: v2(187.55,134.6) 187.52,134.6 186.71,133.79 185.42,133.79
  IN3 w0.155: v2(192.78,101.12) 192.36,101.54 191.72,101.54 191.18,102.08 191.18,104.24 190.73,104.7 190.73,107.46 190.02,108.16 190.02,113.31 182.95,120.38 182.95,131.94 184.8,133.79 185.42,133.79
  BOTTOM w0.102: UG5.A13 187.95,134.2 v2(187.55,134.6)
  BOTTOM w0.152: UG1.AN32 192.78,101.14 v2(192.78,101.12)
FBA_D50: length 48.3
  IN3 w0.155: v2(189.95,133.8) 188.34,135.4 184.83,135.4 181.83,132.41 181.83,119.91 188.89,112.85 188.89,107.7 189.6,106.99 189.6,104.24 190.06,103.78 190.06,101.39 v2(191.98,99.47)
  BOTTOM w0.102: UG5.B11 v2(189.95,133.8)
  BOTTOM w0.152: v2(191.98,99.47) 192.35,99.84 UG1.AP30
FBA_D51: length 40.1
  IN3 w0.102: v2(187.55,133.8) 186.77,133.02 185.49,133.02
  IN3 w0.155: v2(191.98,104.24) 191.29,104.93 191.29,107.69 190.64,108.34 190.64,113.57 183.57,120.63 183.57,131.77 184.82,133.02 185.49,133.02
  BOTTOM w0.102: v2(187.55,133.8) 187.95,133.4 UG5.B13
  BOTTOM w0.152: v2(191.98,104.24) 191.43,103.69 191.43,101.79 191.68,101.54 UG1.AP32
FBA_D52: length 34.2
  IN3 w0.102: v2(189.15,131.4) 188.96,131.4 188.54,130.98 187.22,130.98
  IN3 w0.155: 187.22,130.98 187.05,130.81 187.05,120.69 192.95,114.8 192.95,109.27 193.58,108.64 v2(193.58,104.24)
  BOTTOM w0.102: UG5.E11 v2(189.15,131.4)
  BOTTOM w0.152: UG1.AM33 193.58,102.74 v2(193.58,104.24)
FBA_D53: length 36.9
  IN3 w0.102: 191.33,130.98 188.9,130.98 188.52,130.6 v2(188.35,130.6)
  IN3 w0.155: v2(194.38,101.14) 195.25,102.01 195.25,103.15 195.91,103.81 195.91,108.69 194.94,109.66 194.94,116.98 191.73,120.19 191.73,126.27 192.03,126.58 192.03,130.27 191.33,130.98
  BOTTOM w0.102: UG5.E13 v2(188.35,130.6)
  BOTTOM w0.152: UG1.AL31 v2(194.38,101.14)
FBA_D54: length 30.4
  IN3 w0.155: v2(194.41,104.94) 194.41,108.61 193.51,109.5 193.51,116.82 190.61,119.73 190.61,127.48 189.95,128.14 v2(189.95,129.8)
  BOTTOM w0.102: UG5.F11 v2(189.95,129.8)
  BOTTOM w0.152: v2(194.41,104.94) 195.23,104.12 195.23,103.04 195.68,102.59 UG1.AK33
FBA_D55: length 35.6
  IN3 w0.102: 190.95,130.22 187.97,130.22 v2(187.55,129.8)
  IN3 w0.155: 190.95,130.22 191.44,129.73 191.44,129.6 191.46,129.57 191.46,127.59 191.17,127.3 191.17,119.96 194.07,117.06 194.07,109.74 195.07,108.74 195.07,104.2 v2(194.41,103.54)
  BOTTOM w0.102: v2(187.55,129.8) 187.95,130.2 UG5.F13
  BOTTOM w0.152: UG1.AK32 195.23,101.99 195.23,102.54 194.83,102.94 194.83,103.12 v2(194.41,103.54)
FBA_D56: length 39.7
  IN3 w0.102: 198.51,132.98 197.74,132.98 197.34,133.38 196.23,133.38 195.96,133.65 195.96,134.19 v2(195.55,134.6)
  IN3 w0.155: v2(200.22,104.28) 200.45,104.28 203.38,107.21 203.38,111.52 204.77,112.91 204.77,113.74 202.16,116.36 202.16,130.19 200.4,131.96 199.78,131.96 198.76,132.98 198.51,132.98
  BOTTOM w0.102: v2(195.55,134.6) 195.15,134.2 UG5.A4
  BOTTOM w0.152: UG1.AD34 200.68,103.82 v2(200.22,104.28)
FBA_D57: length 41.9
  IN3 w0.102: 200.78,101.86 200.26,101.33 v2(200.26,101.14)
  IN3 w0.155: v2(197.15,134.6) 198.29,134.6 200.04,132.85 201.09,132.85 203.28,130.66 203.28,116.82 205.9,114.2 205.9,112.45 204.5,111.05 204.5,106.56 200.78,102.84 200.78,101.86
  BOTTOM w0.102: v2(197.15,134.6) 197.15,134.6 UG5.A2
  BOTTOM w0.152: v2(200.26,101.14) 200.66,101.54 UG1.AD32
FBA_D58: length 48.1
  IN3 w0.102: 201.19,101.91 200.7,101.42 200.7,99.92 v2(201.08,99.54)
  IN3 w0.155: v2(194.75,133.8) 194.75,134.38 195.41,135.03 198.6,135.03 200.26,133.37 201.52,133.37 203.84,131.05 203.84,117.05 206.46,114.44 206.46,112.21 205.06,110.82 205.06,106.31 202.82,104.07 202.78,104.07 202.54,103.82 202.21,103.82 201.19,102.8 201.19,101.91
  BOTTOM w0.102: v2(194.75,133.8) 195.15,133.4 UG5.B4
  BOTTOM w0.152: UG1.AC30 v2(201.08,99.54)
FBA_D59: length 40.1
  IN3 w0.102: v2(196.35,133.8) 196.73,134.18 198.06,134.18
  IN3 w0.155: 198.06,134.18 199.8,132.44 200.71,132.44 202.72,130.43 202.72,116.59 205.33,113.97 205.33,112.68 203.94,111.28 203.94,106.79 201.77,104.62 201.77,104.47 200.26,102.96 v2(200.26,102.74)
  BOTTOM w0.102: v2(196.35,133.8) 196.75,133.4 UG5.B2
  BOTTOM w0.152: UG1.AD33 200.28,102.74 v2(200.26,102.74)
FBA_D60: length 39.7
  IN3 w0.102: 197.65,130.64 197.27,131.02 195.93,131.02 v2(195.55,131.4) ; 198.79,104.69 198.79,100.13 v2(199.41,99.52)
  IN3 w0.155: 197.65,130.64 197.65,130.26 198.07,129.84 198.97,129.84 199.76,129.05 199.76,118.64 199.49,118.37 199.49,117.44 198.19,116.14 198.19,111.25 199.87,109.57 199.87,106.05 199.26,105.44 199.26,105.16 198.79,104.69
  BOTTOM w0.102: v2(195.55,131.4) 195.15,131 UG5.E4
  BOTTOM w0.152: v2(199.41,99.52) 198.76,99.52 198.58,99.69 198.58,100.34 UG1.AF31
FBA_D61: length 33.8
  IN3 w0.102: 193.27,130.21 195.96,130.21 v2(196.35,130.6)
  IN3 w0.155: 193.27,130.21 192.76,129.7 192.76,126.23 192.29,125.77 192.29,121.61 192.33,121.58 192.33,120.39 195.51,117.21 195.51,109.89 196.6,108.8 196.6,107.22 197.04,106.77 v2(197.16,106.77)
  BOTTOM w0.102: v2(196.35,130.6) 196.75,131 UG5.E2
  BOTTOM w0.152: v2(197.16,106.77) 197.16,106.2 198.18,105.18 UG1.AG34
FBA_D62: length 32.5
  IN3 w0.155: v2(194.75,129.8) 194.13,129.18 193.69,129.18 193.3,128.8 193.3,125.76 192.89,125.35 192.89,120.62 196.07,117.44 196.07,110.12 197.16,109.03 v2(197.16,108.1)
  BOTTOM w0.102: UG5.F4 195.15,130.2 v2(194.75,129.8)
  BOTTOM w0.152: UG1.AG32 197.73,101.99 197.73,104.84 196.6,105.97 196.6,107.54 v2(197.16,108.1)
FBA_D63: length 31.5
  IN3 w0.102: 199.1,128.8 198.92,128.97 197.97,128.97 v2(197.15,129.8)
  IN3 w0.155: v2(198.81,105.88) 198.81,106.95 199.31,107.45 199.31,109.34 197.63,111.02 197.63,116.38 198.93,117.68 198.93,118.61 199.2,118.88 199.2,128.69 199.1,128.8
  BOTTOM w0.102: UG5.F2 196.75,130.2 v2(197.15,129.8)
  BOTTOM w0.152: v2(198.81,105.88) 199.16,105.53 199.16,105.14 199.16,105.13 199.16,105.09 198.58,104.51 198.58,102.74 UG1.AG33
FBA_DBI0: length 29.1
  IN1 w0.102: 212.16,120.2 212.16,122.36 212.39,122.59 213.39,122.59 v2(214.2,123.4) ; 208.43,104.98 208.43,102.91 208.96,102.38 208.96,101.05 209.27,100.74 209.54,100.74 209.79,100.5 209.79,99.9 v2(209.41,99.52)
  IN1 w0.152: 212.16,120.2 212.16,116.88 211.76,116.47 211.76,112.76 208.17,109.18 208.17,106.87 208.43,106.61 208.43,104.98
  BOTTOM w0.102: v2(214.2,123.4) 214.59,123.8 UG4.D2
  BOTTOM w0.152: v2(209.41,99.52) 209.11,99.81 UG1.P30
FBA_DBI1: length 30.8
  IN1 w0.102: v2(223.8,123.4) 224.59,122.6 225.56,122.6 225.96,122.21 ; 218.58,105.75 218.46,105.63 218.14,105.63 217.57,105.06 216.78,105.06 216.09,104.38 216.09,104.17 215.65,103.73 215.65,101.8 215.26,101.4 v2(215.26,101.14)
  IN1 w0.152: 218.58,105.75 226.27,113.44 226.27,114.31 226.96,114.99 226.96,121.2 225.96,122.2 225.96,122.21
  BOTTOM w0.102: UG4.D13 v2(223.8,123.4)
  BOTTOM w0.152: UG1.F31 215.66,100.74 v2(215.26,101.14)
FBA_DBI2: length 32.6
  IN3 w0.155: v2(223.8,131.4) 224.28,130.91 224.28,115.77 215.71,107.2 215.71,104.39 v2(215.68,104.36)
  BOTTOM w0.102: v2(223.8,131.4) 223.4,131.8 UG4.P13 ; UG1.F34 215.68,103.14 215.68,104.02
  BOTTOM w0.152: 215.68,104.02 v2(215.68,104.36)
FBA_DBI3: length 34.8
  IN3 w0.102: v2(214.2,132.2) 213.4,131.4 212.29,131.4
  IN3 w0.155: v2(210.26,101.94) 210.67,102.35 210.67,104.83 209.62,105.88 209.62,109.46 211.71,111.55 211.71,119.59 211.45,119.85 211.45,130.56 212.29,131.4
  BOTTOM w0.102: UG4.P2 v2(214.2,132.2)
  BOTTOM w0.152: UG1.M32 210.66,101.54 v2(210.26,101.94)
FBA_DBI4: length 27.9
  IN1 w0.102: 200.83,104.4 200.83,101.82 200.68,101.67 200.68,100.77 v2(200.26,100.34) ; 199.06,122.62 197.99,122.62 197.59,123.02 196.73,123.02 v2(196.35,123.4)
  IN1 w0.152: 199.06,122.62 199.2,122.47 199.2,118.2 200.56,116.85 200.56,112.73 199.95,112.12 199.95,105.29 200.83,104.4
  BOTTOM w0.102: UG5.P2 196.75,123.8 v2(196.35,123.4)
  BOTTOM w0.152: UG1.AD31 200.28,100.34 v2(200.26,100.34)
FBA_DBI5: length 31.4
  IN1 w0.102: 191.37,103.68 191.84,103.21 192.35,103.21 192.48,103.08 192.97,103.08 194.01,102.05 194.01,101.79 194.29,101.52 194.54,101.52 194.76,101.3 194.76,100.98 194.72,100.94 194.72,100.02 194.38,99.67 v2(194.38,99.44) ; 185.35,122.2 185.76,122.6 186.76,122.6 v2(187.55,123.4)
  IN1 w0.152: 185.35,122.2 185.28,122.13 185.28,115.02 191.12,109.18 191.12,103.93 191.37,103.68
  BOTTOM w0.102: v2(187.55,123.4) 187.95,123.8 UG5.P13
  BOTTOM w0.152: UG1.AL29 v2(194.38,99.44)
FBA_DBI6: length 36.3
  IN3 w0.102: 187.49,132.2 186.67,131.38 185.64,131.38 ; v2(193.58,101.94) 193.16,102.36 193.16,104.43
  IN3 w0.155: 185.64,131.38 185.38,131.12 185.38,121.57 192.39,114.56 192.39,109.04 193.02,108.41 193.02,104.58 193.16,104.43 ; v2(187.55,132.2) 187.49,132.2
  BOTTOM w0.102: UG5.D13 v2(187.55,132.2)
  BOTTOM w0.152: v2(193.58,101.94) UG1.AM32
FBA_DBI7: length 33.4
  IN3 w0.102: v2(199.41,103.54) 199.02,103.92 199.02,104.47 ; v2(197.15,131.4) 198.93,131.4
  IN3 w0.155: 198.93,131.4 199.37,130.95 199.37,130.24 200.42,129.18 200.42,118.37 200.15,118.1 200.15,115.58 201.65,114.08 201.65,109.49 201.37,109.21 201.37,106.81 199.02,104.47
  BOTTOM w0.102: UG5.D2 196.75,131.8 v2(197.15,131.4)
  BOTTOM w0.152: UG1.AF34 199.16,103.32 199.18,103.32 v2(199.41,103.54)
FBA_DEBUG0: length 5.6
  BOTTOM w0.127: TG1.1 208.74,106.29
  BOTTOM w0.152: UG1.R32 207.81,101.91 207.81,105.36 208.74,106.29
FBA_DEBUG1: length 1.2
  TOP w0.102: TG3.1 201.55,102.3 v2(201.91,101.94)
  BOTTOM w0.109: UG1.AC32 201.88,101.94 v2(201.91,101.94)
FBA_EDC0: length 26.1
  IN1 w0.102: 213.61,120.89 213.61,122.01 v2(214.2,122.6) ; v2(210.26,100.34) 209.84,100.76 209.84,102.21 208.94,103.11 208.94,105.37
  IN1 w0.152: 208.94,105.37 209.04,105.47 209.04,108.82 212.72,112.51 212.72,116.22 213.33,116.83 213.33,120.31 213.6,120.58 213.6,120.88 213.61,120.89
  BOTTOM w0.102: v2(214.2,122.6) 214.59,122.99 UG4.C2
  BOTTOM w0.152: v2(210.26,100.34) 210.66,100.74 UG1.M31
FBA_EDC1: length 30.3
  IN1 w0.102: v2(214.41,100.34) 214.87,100.8 214.87,104.08 216.23,105.44 217.05,105.44 217.64,106.03 ; 224.29,121.8 224.29,121.84 223.94,122.19 223.41,122.19 v2(223,122.6)
  IN1 w0.152: 224.29,121.8 224.29,120.73 226.09,118.92 226.09,115.35 225.41,114.66 225.41,113.8 217.64,106.03
  BOTTOM w0.102: UG4.C13 223.39,122.99 v2(223,122.6)
  BOTTOM w0.152: UG1.G31 214.43,100.34 v2(214.41,100.34)
FBA_EDC2: length 36.8
  IN3 w0.102: v2(223,132.2) 223.38,131.81 224.03,131.81 224.46,131.38 225.55,131.38 225.78,131.15 225.78,131.04 225.81,131.01
  IN3 w0.155: 225.81,131.01 225.81,116.07 216.58,106.84 216.58,105.61 216.46,105.49 216.46,104.11 v2(216.88,103.69)
  BOTTOM w0.102: UG4.R13 v2(223,132.2)
  BOTTOM w0.152: v2(216.88,103.69) 216.88,102.74 UG1.E33
FBA_EDC3: length 36.2
  IN3 w0.102: v2(210.26,102.74) 209.83,103.17 209.83,104.63 ; 212.06,132.19 213.6,132.19 214.02,132.62 214.61,132.62 v2(215,133)
  IN3 w0.155: 212.06,132.19 211.85,132.19 211.35,131.68 210.58,130.92 210.58,119.49 210.85,119.23 210.85,111.91 208.76,109.82 208.76,105.96 209.45,105.26 209.46,105.26 209.83,104.89 209.83,104.63
  BOTTOM w0.102: UG4.R2 v2(215,133)
  BOTTOM w0.152: v2(210.26,102.74) 210.66,102.34 UG1.M33
FBA_EDC4: length 24.4
  IN1 w0.102: v2(199.41,101.14) 199.81,101.55 199.81,104.48
  IN1 w0.152: 199.81,104.48 199.28,105.01 199.28,106.03 199.08,106.23 199.08,112.48 199.69,113.09 199.69,114.3 199.15,114.84 199.15,117.04 197.74,118.45 197.74,119.99 197.56,120.17 197.56,122.19 v2(197.15,122.6)
  BOTTOM w0.102: UG5.R2 v2(197.15,122.6)
  BOTTOM w0.152: v2(199.41,101.14) 199.81,100.74 UG1.AE31
FBA_EDC5: length 29
  IN1 w0.102: v2(188.35,122.6) 187.96,122.21 187.1,122.21 186.7,121.8 186.35,121.8 186.14,121.6 ; v2(195.11,100.31) 195.03,100.39 195.03,101.86 194.54,102.34 194.27,102.34 193.17,103.43 193.17,104.39 192.9,104.66
  IN1 w0.152: 186.14,121.6 186.14,115.37 191.98,109.54 191.98,105.58 192.9,104.66
  BOTTOM w0.102: UG5.R13 v2(188.35,122.6)
  BOTTOM w0.152: v2(195.11,100.31) 195.12,100.3 195.14,100.3 195.14,100.3 195.2,100.3 195.56,99.94 UG1.AK30
FBA_EDC6: length 38.6
  IN3 w0.102: v2(191.98,102.79) 192.01,102.79 192.38,103.16 192.38,104.61 ; 185.23,132.2 186.84,132.2 187.26,132.62 187.97,132.62 v2(188.35,133)
  IN3 w0.155: 185.23,132.2 184.46,131.42 184.46,120.98 191.52,113.91 191.52,108.68 192.15,108.05 192.15,104.83 192.38,104.61
  BOTTOM w0.102: UG5.C13 v2(188.35,133)
  BOTTOM w0.152: UG1.AN33 192.73,102.79 v2(191.98,102.79)
FBA_EDC7: length 36.5
  IN3 w0.102: v2(197.15,133) 197.93,132.22 198.91,132.22 ; 199.84,104.58 199.84,102.37 v2(199.41,101.94)
  IN3 w0.155: 199.84,104.58 202.23,106.98 202.23,108.85 202.51,109.14 202.51,114.44 201.02,115.94 201.02,117.74 201.29,118.01 201.29,129.54 200.24,130.6 200.24,130.89 198.91,132.22
  BOTTOM w0.102: v2(197.15,133) 196.75,132.6 UG5.C2
  BOTTOM w0.152: UG1.AF33 199.38,101.94 v2(199.41,101.94)
FBA_VREFC_R: length 65.9
  TOP w0.127: v2(181.27,129.88) 181.64,129.88 v1(182.08,129.44)
  IN1 w0.508: v2(181.27,129.88) 181.96,129.88 183.21,131.13 183.21,133.41 185.93,136.14 196.57,136.14 199.53,133.18 203.38,133.18 205.1,134.9 210.14,134.9 211.62,136.39 v2(212.41,136.39)
  BOTTOM w0.508: v2(181.27,129.88) 183.15,129.88 QG3.1 182.89,129.24 182.48,129.24 182.07,128.83 RG54.1 ; v2(212.41,136.39) 227.41,136.39 228.38,135.42 228.38,129.19 228.17,128.98 RG51.1
FBA_WCK01: length 27.3
  IN1 w0.102: v2(211.88,101.07) 212.04,101.07 212.16,101.2 212.16,101.77 212.32,101.92 212.32,103.8 212.42,103.9 212.42,105.22 212.61,105.42 212.61,105.96 212.57,106 212.57,106.03
  IN1 w0.152: v2(216.6,123.4) 216.6,123.12 216.72,122.99 217.41,122.99 217.69,122.71 217.69,112.95 215.15,110.41 212.57,107.83 212.57,106.03
  BOTTOM w0.102: v2(211.88,101.07) 211.95,101.14 212.21,101.14 212.33,101.02 UG1.K31 ; v2(216.6,123.4) 216.6,123.69 216.49,123.8 UG4.D4
FBA_WCK01#: length 27
  IN1 w0.102: v2(211.91,100.34) 212.37,100.8 212.37,101.68 212.52,101.84 212.52,103.72 212.62,103.82 212.62,105.14 212.82,105.34 212.82,105.96 212.86,106 212.86,106.03
  IN1 w0.152: 212.86,106.03 212.86,107.71 215.44,110.29 217.99,112.83 217.99,122.83 v2(217.42,123.4)
  BOTTOM w0.102: v2(211.91,100.34) 211.51,99.94 UG1.L30 ; UG4.D5 217.02,123.8 v2(217.42,123.4)
FBA_WCK23: length 33.9
  IN1 w0.102: 217.57,131 216.72,131 216.6,131.12 v2(216.6,131.4)
  IN1 w0.152: v2(213.57,107.18) 213.82,107.18 218.65,112.01 218.65,130.04 217.69,131 217.57,131
  BOTTOM w0.102: UG4.P4 v2(216.6,131.4)
  BOTTOM w0.132: UG1.H34 213.78,103.14 213.72,103.2 213.72,104.69 214.82,105.79 214.82,106.37 214.19,107.01 213.74,107.01 v2(213.57,107.18)
FBA_WCK23#: length 33.8
  IN1 w0.102: 217.4,131.4 v2(217.4,131.4)
  IN1 w0.152: 217.4,131.4 217.71,131.4 218.94,130.17 218.94,111.89 213.57,106.52 v2(213.57,106.45)
  BOTTOM w0.102: UG4.P5 v2(217.4,131.4)
  BOTTOM w0.132: v2(213.57,106.45) 213.57,106.63 213.7,106.76 214.08,106.76 214.58,106.27 214.58,105.89 213.48,104.79 213.48,103.24 213.38,103.14 UG1.J34
FBA_WCK45: length 27.5
  IN3 w0.102: v2(197.76,100.34) 197.93,100.52 198.12,100.52 198.52,100.92 198.52,101.59 198.04,102.07 198.04,102.24 198.04,102.24 198.04,102.3 198.07,102.33 198.07,102.37 ; v2(194.75,123.4) 194.33,122.98 193.79,122.98 193.57,122.75 193.57,121.64 194.07,121.14 194.07,121.13 194.19,121.02 194.19,120.61 194.34,120.45
  IN3 w0.14: 198.07,102.37 198.07,109.4 196.98,110.5 196.98,117.82 194.34,120.45
  BOTTOM w0.102: UG1.AG30 198.16,99.94 v2(197.76,100.34) ; UG5.P4 195.15,123.8 v2(194.75,123.4)
FBA_WCK45#: length 27.5
  IN3 w0.102: 197.82,102.37 197.82,102.37 197.82,102.34 197.84,102.33 197.84,102.16 197.84,101.99 198.32,101.51 198.32,101.01 198.03,100.72 197.78,100.72 197.63,100.87 197.63,101.02 v2(197.76,101.14) ; 193.98,120.45 193.98,120.93 193.36,121.56 193.36,122.84 193.71,123.19 193.75,123.19 v2(193.95,123.4)
  IN3 w0.14: 197.82,102.37 197.82,109.3 196.72,110.4 196.72,117.72 193.98,120.45
  BOTTOM w0.102: v2(193.95,123.4) 194.23,123.4 194.35,123.52 UG5.P5 ; UG1.AG31 198.17,100.73 197.79,100.73 197.67,100.85 197.67,101.05 v2(197.76,101.14)
FBA_WCK67: length 35.6
  IN1 w0.102: 195.18,107.17 195.21,107.14 195.21,107.13 195.24,107.1 195.24,106.11 195.93,105.42 195.93,104.17 196.43,103.67 196.78,103.67 v2(196.91,103.54)
  IN1 w0.152: v2(194.75,131.4) 194.42,131.73 194.42,131.91 194.11,132.22 192.64,132.22 191.97,131.55 191.97,118.23 195.56,114.63 195.56,109.51 195.18,109.13 195.18,107.17
  BOTTOM w0.102: UG5.D4 195.15,131.8 v2(194.75,131.4) ; UG1.AJ34 196.48,103.55 196.6,103.67 196.78,103.67 196.91,103.54 v2(196.91,103.54)
FBA_WCK67#: length 35.6
  IN1 w0.102: 195.48,107.16 195.48,107.13 195.44,107.1 195.44,106.18 196.14,105.49 196.14,104.25 196.52,103.87 196.7,103.87 196.91,104.08 v2(196.91,104.27)
  IN1 w0.152: 195.48,107.16 195.48,109.01 195.86,109.39 195.86,114.75 192.26,118.35 192.26,131.43 192.76,131.92 193.99,131.92 194.13,131.79 194.13,131.57 v2(193.95,131.4)
  BOTTOM w0.102: v2(196.91,104.27) 196.91,104.09 196.68,103.87 196.52,103.87 196.28,103.63 196.28,103.43 195.99,103.14 UG1.AK34 ; v2(193.95,131.4) 194.23,131.4 194.4,131.56 194.4,131.75 UG5.D5
FBB0_VREFC: length 5.5
  BOTTOM w0.406: UG6.J14 241.84,68.44 242.27,68.01 CG123.1
  BOTTOM w0.508: RG65.2 241.79,65.05 RG64.2 241.51,65.43 241.89,65.81 RG66.1 CG123.1
FBB0_ZQ1: length 3.1
  TOP w0.127: RG74.1 241.17,68.6 v2(241.04,68.47) 241,68.47 v1(240.64,68.83)
  BOTTOM w0.109: UG6.J13 241.84,69.72 241.44,69.32 241.44,68.77 241.15,68.47 v2(241.04,68.47)
FBB1_VREFC: length 63.7
  IN1 w0.508: v2(250.83,81.45) 250.83,83.08 250.45,83.46 250.45,99.18 251.31,100.05 251.31,103.06 249.08,105.29 243.32,105.29 v2(242.03,106.58)
  IN3 w0.508: v2(250.83,81.45) 250.83,68.22 246.72,64.11 244.63,64.11 244.12,63.6 v2(243.43,63.6)
  BOTTOM w0.305: 241.63,104.12 241.84,103.91 UG7.J14
  BOTTOM w0.381: 241.63,104.12 241.32,104.43 CG122.1
  BOTTOM w0.508: CG122.1 241.32,105.88 v2(242.03,106.58) ; v2(243.43,63.6) 244.02,63.6 245.06,64.65 RG70.1 245.06,66.03 245.09,66.05 RG67.2 245.62,66.19 RG68.2
FBB1_ZQ3: length 4.6
  BOTTOM w0.127: v1(240.49,106.53) RG72.1 240.49,105.12 240.81,104.8 240.81,104.17 241.42,103.57 241.42,102.91 UG7.J13
FBB_CLKA0: length 35.6
  TOP w0.102: v2(217.78,85.27) 218,85.04 218.06,85.04 218.68,84.43 221.3,84.43 222.05,83.67 222.09,83.67
  TOP w0.132: 222.09,83.67 222.7,83.06 222.7,82.48 224.12,81.06 224.12,76.96 228.66,72.42 229.23,72.42 v2(229.41,72.6)
  IN1 w0.102: v2(242.21,71.05) 241.81,71.46 241.29,71.46 240.06,72.69 239.7,72.69 239.65,72.74 239.62,72.74
  IN1 w0.152: 239.62,72.74 230.48,72.74 230.21,72.47 229.54,72.47 v2(229.41,72.6)
  BOTTOM w0.102: UG6.J12 241.84,70.68 v2(242.21,71.05)
  BOTTOM w0.132: RG76.1 229.97,72.41 229.59,72.41 v2(229.41,72.6) ; UG1.D12 217.38,84.86 v2(217.78,85.27)
FBB_CLKA0#: length 35.9
  TOP w0.102: v2(216.98,85.27) 217.76,84.84 217.98,84.84 218.58,84.23 221.22,84.23 221.92,83.53 221.92,83.5
  TOP w0.132: v2(229.4,71.98) 229.19,72.18 228.56,72.18 223.87,76.86 223.87,80.96 222.46,82.37 222.46,82.96 221.92,83.5
  IN1 w0.102: v2(241.44,71.07) 241.4,71.07 239.98,72.5 239.7,72.5 239.65,72.45 239.62,72.45
  IN1 w0.152: v2(229.4,71.98) 229.6,72.18 230.34,72.18 230.61,72.45 239.62,72.45
  BOTTOM w0.102: UG6.J11 241.86,71.45 241.86,71.2 241.74,71.07 v2(241.44,71.07)
  BOTTOM w0.132: v2(216.98,85.27) 216.58,84.87 UG1.E12 ; RG77.1 230.04,72.17 229.59,72.17 v2(229.4,71.98)
FBB_CLKA1: length 37.2
  TOP w0.102: v2(216.16,91.12) 216.16,91.37 216.41,91.63 216.75,91.63 217.25,92.13 221.64,92.13 222.18,92.67 222.18,92.74
  TOP w0.119: 222.74,94 222.67,93.92 222.67,93.38 222.18,92.89 222.18,92.74
  TOP w0.132: v2(232.04,102.23) 232.28,102.46 232.28,102.58 232.14,102.71 229.68,102.71 222.74,95.78 222.74,94
  IN3 w0.102: 240.44,100.02 240.45,100.03 240.45,100.04 240.43,100.06 240.48,100.1 240.48,100.13 241.23,100.89 241.79,100.89 v2(242.21,101.31)
  IN3 w0.14: v2(232.04,102.23) 232.27,102 232.27,101.71 234.22,99.76 240.18,99.76 240.44,100.02
  BOTTOM w0.102: UG7.J12 v2(242.21,101.31)
  BOTTOM w0.132: v2(232.04,102.23) 232.28,101.99 232.28,101.84 RG97.1 ; UG1.E20 v2(216.16,91.12)
FBB_CLKA1#: length 37.4
  TOP w0.102: 221.96,92.74 221.96,92.73 221.56,92.33 217.17,92.33 216.67,91.83 216.33,91.83 215.62,91.12 v2(215.31,91.12)
  TOP w0.119: 222.5,94.1 222.45,94.05 222.45,93.47 221.96,92.98 221.96,92.74
  TOP w0.132: 222.5,94.1 222.5,95.88 229.58,102.96 232.24,102.96 232.52,102.68 232.52,102.46 v2(232.75,102.23)
  IN3 w0.102: v2(241.44,101.29) 241.35,101.29 240.26,100.2
  IN3 w0.14: 240.26,100.2 240.07,100.01 234.32,100.01 232.52,101.81 232.52,102 v2(232.75,102.23)
  BOTTOM w0.102: v2(241.44,101.29) 241.61,101.29 241.84,101.05 UG7.J11
  BOTTOM w0.132: RG98.1 232.52,101.88 232.52,101.99 v2(232.75,102.23) ; UG1.F20 215.73,91.24 215.61,91.12 v2(215.31,91.12)
FBB_CMD0: length 33.3
  TOP w0.102: 234.56,71.49 240.23,71.49 v2(240.64,71.07) ; v2(216.98,86.12) 217.41,85.68 221.03,85.68
  TOP w0.196: 221.03,85.68 223.48,83.23 223.48,82.65 224.79,81.34 224.79,78.17 231.47,71.49 234.56,71.49
  BOTTOM w0.102: v2(240.64,71.07) UG6.G12
  BOTTOM w0.196: v2(216.98,86.12) 216.98,86.09 UG1.D13
FBB_CMD1: length 33.8
  TOP w0.102: 221.88,86.54 218.39,86.54 217.99,86.94 v2(216.16,86.94) ; 234.82,72.69 240.63,72.69 v2(240.69,72.63)
  TOP w0.196: 234.82,72.69 231.98,72.69 225.99,78.68 225.99,81.84 224.69,83.15 224.69,83.73 221.88,86.54
  BOTTOM w0.102: UG6.H10 241.04,72.28 v2(240.69,72.63)
  BOTTOM w0.196: UG1.E14 216.18,86.94 v2(216.16,86.94)
FBB_CMD2: length 35.9
  TOP w0.102: v2(215.31,86.94) 215.71,86.53 217.94,86.53 218.36,86.11 221.46,86.11 ; v2(241.44,71.87) 240.88,71.87 240.5,72.26 234.82,72.26
  TOP w0.196: 221.46,86.11 224.03,83.54 224.09,83.48 224.09,82.9 225.39,81.59 225.39,78.42 231.72,72.09 234.65,72.09 234.82,72.26
  BOTTOM w0.102: UG6.H11 241.04,71.47 v2(241.44,71.87)
  BOTTOM w0.196: v2(215.31,86.94) 215.33,86.94 UG1.F14
FBB_CMD3: length 31.2
  TOP w0.102: v2(242.25,71.86) 242.25,72.76 241.87,73.14 234.99,73.14 234.83,73.29
  TOP w0.196: v2(225.35,83.46) 225.35,83.34 226.6,82.09 226.6,78.93 232.23,73.29 234.83,73.29
  BOTTOM w0.102: UG6.K11 v2(242.25,71.86)
  BOTTOM w0.196: v2(225.35,83.46) 224.95,83.07 223,83.07 221.23,84.84 UG1.A12
FBB_CMD4: length 31.9
  TOP w0.102: v2(242.64,72.83) 242.64,73.15 242.24,73.55 235.02,73.55 234.68,73.9
  TOP w0.196: v2(226.48,83.16) 226.48,83.09 227.2,82.37 227.2,79.18 232.48,73.9 234.68,73.9
  BOTTOM w0.102: UG6.K10 v2(242.64,72.83)
  BOTTOM w0.196: v2(226.48,83.16) 225.71,82.39 222.95,82.39 220.89,84.44 219.38,84.44 UG1.B12
FBB_CMD5: length 35.5
  TOP w0.102: 234.1,74.5 234.49,74.5 235.16,73.83 242.58,73.83 243.04,73.37 v2(243.04,71.07)
  TOP w0.196: v2(227.8,82.97) 227.8,79.43 232.73,74.5 234.1,74.5
  BOTTOM w0.102: v2(243.04,71.07) 243.44,70.67 UG6.L12
  BOTTOM w0.196: v2(227.8,82.97) 227.8,83.31 227.51,83.6 227,83.6 226.2,84.4 222.52,84.4 221.6,85.32 219.97,85.32 219.15,86.14 218.58,86.14 UG1.C14
FBB_CMD6: length 33
  TOP w0.102: v2(242.24,76.67) 242.24,75.16 241.49,74.41 235.35,74.41 234.44,75.32
  TOP w0.196: v2(228.07,84.18) 228.45,84.18 229.03,83.6 229.03,79.9 233.23,75.7 234.07,75.7 234.44,75.32
  BOTTOM w0.102: UG6.K4 v2(242.24,76.67)
  BOTTOM w0.196: UG1.B14 219.18,86.54 219.93,85.79 221.93,85.79 222.72,85 227.61,85 228.07,84.54 v2(228.07,84.18)
FBB_CMD7: length 37.5
  TOP w0.102: 222.19,87.09 219.09,87.09 218.81,87.36 215.71,87.36 v2(215.31,87.77) ; 234.2,75.1 235.19,74.11 242.04,74.11 242.64,74.71 v2(242.64,75.67)
  TOP w0.196: 222.19,87.09 224.87,84.4 226.11,84.4 226.79,83.72 227.67,83.72 227.82,83.58 228.05,83.58 228.4,83.22 228.4,79.68 232.98,75.1 234.2,75.1
  BOTTOM w0.102: UG6.K5 v2(242.64,75.67)
  BOTTOM w0.196: v2(215.31,87.77) UG1.G15
FBB_CMD8: length 36.4
  TOP w0.102: 234.92,75.99 236.01,74.9 240.8,74.9 241.34,75.44 241.34,76.58 v2(241.44,76.67) ; 219.99,87.81 219.23,87.81 219.1,87.94 217.38,87.94 217.13,88.19 v2(215.73,88.19)
  TOP w0.196: 234.92,75.99 234.08,76.83 233.8,76.83 230.31,80.33 230.31,84.02 228.95,85.38 228.42,85.38 228.18,85.61 225.36,85.61 222.95,88.03 220.2,88.03 219.99,87.81
  BOTTOM w0.102: UG6.J4 v2(241.44,76.67)
  BOTTOM w0.196: v2(215.73,88.19) 215.75,88.17 215.75,87.36 UG1.F15
FBB_CMD9: length 34.3
  TOP w0.102: 222.66,87.43 219.19,87.43 218.99,87.63 217.11,87.63 v2(216.98,87.77) ; 234.83,75.54 235.68,74.69 241.25,74.69 241.74,75.19 v2(241.74,75.67)
  TOP w0.196: 222.66,87.43 222.69,87.43 225.11,85.01 227.94,85.01 228.17,84.78 228.7,84.78 229.65,83.83 229.65,80.14 233.46,76.32 234.05,76.32 234.83,75.54
  BOTTOM w0.102: UG6.J5 241.84,75.77 v2(241.74,75.67)
  BOTTOM w0.196: UG1.E15 216.98,87.74 v2(216.98,87.77)
FBB_CMD10: length 32.6
  TOP w0.102: v2(240.64,76.67) 240.64,76.4 240.41,76.17 240.41,75.72 239.99,75.3 236.61,75.3 235.27,76.64
  TOP w0.196: v2(229.38,86.62) 229.41,86.62 231.7,84.33 231.7,80.85 234.58,77.97 234.58,77.33 235.27,76.64
  BOTTOM w0.102: v2(240.64,76.67) 241.04,77.07 UG6.H4
  BOTTOM w0.196: v2(229.38,86.62) 229.2,86.8 229.2,86.81 228.17,87.83 220.27,87.83 220.18,87.74 217.78,87.74 UG1.D15
