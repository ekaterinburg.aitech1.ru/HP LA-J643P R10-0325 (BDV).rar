# Allegro board LAJ643PR10-0325.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USB_OC1#: length 12.1
  TOP w0.127: RH215.1 v1(186.57,30.88) 186.76,30.88 189.32,28.33 189.32,27.82 190.4,26.74 194,26.74 v2(194.68,26.07)
  BOTTOM w0.127: v2(194.68,26.07) 195.09,26.07 UH1.AL40
USB_OC2#: length 10.2
  TOP w0.127: RH214.1 186.36,29.36 v1(186.64,29.09) 188.03,27.69 188.03,27.55 189.32,26.26 193.08,26.26 v2(193.49,25.86)
  BOTTOM w0.127: v2(193.49,25.86) 193.1,26.24 UH1.AJ44
USB_OC3#: length 10.7
  TOP w0.127: RH216.1 185.67,27.84 185.99,27.52 186.8,27.52 188.7,25.62 v1(189.68,25.62) 190.87,25.62 191.32,25.17 194.42,25.17 v2(194.57,25.02)
  BOTTOM w0.127: UH1.AL41 194.57,25.59 v2(194.57,25.02)
USB_OC4#: length 7.9
  TOP w0.127: v2(188.75,23.68) v1(187.36,25.06) 186.49,25.93 186.13,25.93 185.76,26.31 RH218.1
  BOTTOM w0.127: v2(188.75,23.68) 189.33,23.09 189.89,23.09 190.64,22.34 UH1.AV47
USB_OC5#: length 13.9
  TOP w0.127: RH219.1 186.27,25.55 188.72,23.09 191.64,23.09 192.52,23.97 192.79,23.97 193,23.75 v1(193.9,23.75) 195.91,23.75 v2(196.55,23.11)
  BOTTOM w0.127: UH1.AR35 197.04,23.11 v2(196.55,23.11)
USB_OC6#: length 12.8
  TOP w0.127: RH220.1 186.23,27.07 v1(186.91,26.39) 188.58,24.72 194.31,24.72 194.41,24.62 196.16,24.62 v2(196.65,24.13)
  BOTTOM w0.127: v2(196.65,24.13) 196.65,23.82 UH1.AR37
USB_OC7#: length 10.3
  TOP w0.127: v2(193.64,23.13) 193.64,22.74 193.49,22.6 192.91,22.6 192.64,22.86 v1(192.36,22.86) 188.44,22.86 186.51,24.79 RH221.1
  BOTTOM w0.127: UH1.AV43 193.9,22.87 v2(193.64,23.13)
USB_ON#: length 228.7
  TOP w0.127: v2(152.49,5.12) 152.49,5.77 155.19,8.47 155.19,9.11 156.6,10.52 167.07,10.52 168.63,8.96 v3(168.63,7.88) 169.61,6.91 169.61,6.15 170.02,5.74 172.27,5.74 172.47,5.54 172.91,5.54 173.16,5.29 174,5.29 174.66,4.63 219.19,4.63 222.56,8 v2(223.6,8) ; UK1.121 134.53,12.62 134.12,12.2 131.17,12.2 130.48,11.51 v2(130.48,10.18)
  IN2 w0.127: v2(152.49,5.12) 152.49,5.61 149.97,8.14 133.36,8.14 131.74,9.76 130.89,9.76 v2(130.48,10.18)
  IN3 w0.142: v2(223.6,8) 222.91,8.69 222.91,10.45 225.03,12.57 225.48,12.57 226.95,14.04 231.49,14.04 231.82,14.36 236.19,14.36 238.26,16.43 257.6,16.43 257.97,16.06 263.81,16.06 264.64,16.9 270.79,16.9 272.7,18.81 275.58,18.81 276.68,17.7 276.68,16.91 277.61,15.98 281.54,15.98 285.87,11.65 290.83,11.65 292.47,13.29 302.18,13.29 304.02,15.13 306.92,15.13 308.29,16.5 308.29,18.83 310.37,20.9 310.37,22.97 311.98,24.58 311.98,26.15 311.38,26.74 311.38,32.14 v2(309.99,33.54)
  BOTTOM w0.135: JIO1.27 309.2,32.75 v2(309.99,33.54)
VCIN0_PH: length 136.2
  TOP w0.254: UK1.109 134.69,17.42 134.18,17.93 PR9.2 132.74,17.41 131.41,17.41 130.29,18.53 130.29,19.06 129.75,19.61 126.18,19.61 125.48,20.31 124.83,20.31 v1(121.92,23.21) 119.27,25.86 119.27,26.32 118.32,27.26 117.6,27.26 117.35,27.52 v2(117.35,27.79) ; PH1.1 v2(134.24,96.61)
  IN1 w0.254: v2(117.35,27.79) 117.33,27.81 116.56,27.81 116.28,27.53 113.72,27.53 113.56,27.37 104.96,27.37 104.07,28.26 102,28.26 97.66,32.6 97.66,41.77 95.02,44.4 95.02,46.94 96.15,48.07 96.15,52.49 99.1,55.44 99.1,63.8 104.81,69.5 104.81,73.4 108.22,76.81 108.22,79.99 arc(108.88,83.32) 110.76,86.13 113.44,88.81 114.64,88.81 122.49,96.66 122.91,96.66 124.21,97.97 128.78,97.97 129.37,97.38 132.86,97.38 133.64,96.61 v2(134.24,96.61)
VCIN1_AC_IN: length 2.4
  TOP w0.127: UK1.27 147.64,7.28 147.45,7.1 146.96,7.1 146.56,6.7 R4960.1
VCIN1_AC_IN_R: length 23.5
  TOP w0.127: v2(146.56,5.07) R4960.2 146.56,5.65 R5094.2 ; UK1.110 134.09,17.02 v2(133.94,16.86)
  BOTTOM w0.127: v2(146.56,5.07) 146.17,5.45 142.49,5.45 v1(140.31,7.63) 137.47,10.47 137.47,15.12 137.07,15.52 136.09,15.52 134.62,16.99 134.07,16.99 v2(133.94,16.86)
VCIN1_ACOK: length 107.2
  TOP w0.127: R5094.1 145.5,6.56 145.31,6.37 145.31,5.31 v2(145.59,5.03) ; v2(225.08,13.4) 225.8,14.12 v1(229.72,14.12) 230.02,14.12 230.68,13.46 234.3,13.46 234.55,13.21 PRB23.2 PRB25.1 234.78,12.23 235.58,11.43 PUB01.2
  IN2 w0.127: v2(145.59,5.03) 145.98,4.63 152.6,4.63 152.91,4.94 152.91,6.72 153.62,7.42 153.62,10.09 156.05,12.52 167.92,12.52 171.35,9.1 179.8,9.1 181.67,7.23 198.62,7.23 199.37,7.98 202.61,7.98 203.12,7.47 205.3,7.47 205.65,7.11 220.53,7.11 222.91,9.49 222.91,11 224.81,12.91 224.81,13.13 v2(225.08,13.4)
VCIN1_PH: length 192.8
  TOP w0.254: v2(261.51,39.84) 261.38,39.71 261.38,39.24 261.7,38.93 261.7,37.51 263.05,36.16 PH2.1 ; UK1.102 134.49,20.22 134.19,20.52 134.19,23.51 v1(133.08,24.62) 132.14,24.62 PR10.2 131.98,24.58 131.53,25.04 130.45,25.04 129.72,24.32 129.71,24.34 129.02,24.34 128.74,24.62 128.74,24.65 128.54,24.85 128.54,25.49 129.34,26.28 134.73,26.28 v2(135.15,26.69)
  IN2 w0.254: v2(261.51,39.84) 261.51,40.01 261.08,40.45 260.68,40.45 260.42,40.19 257.98,40.19 257.56,40.61 248.27,40.61 247.81,40.16 245.14,40.16 244.46,39.48 244.46,39.34 244.18,39.06 244.04,39.06 243.95,38.96 239.96,38.96 239.2,39.73 236.33,39.73 235.95,39.34 235.62,39.34 235.39,39.11 234.99,39.11 234.76,39.34 234.31,39.34 233.54,40.11 232.39,40.11 231.88,39.6 224.73,39.6 216.43,47.9 195.69,47.9 195.58,48.01 194.58,48.01 190.62,51.97 189.37,51.97 187.47,53.87 187.47,56.98 186.2,58.25 181.25,58.25 v2(180.8,58.7)
  BOTTOM w0.254: v2(180.8,58.7) 180.8,55.52 179.47,54.19 179.47,52.03 180.04,51.46 180.04,50 179.47,49.43 177.69,49.43 177.69,49.42 177.46,49.19 176.53,49.19 175.66,50.06 174.83,50.06 174.11,49.34 174.11,45 174.11,44.99 174.11,43.18 172.86,41.94 172.86,39.33 172.64,39.1 172.64,39.1 172.45,38.91 172.45,37.55 172.97,37.03 172.97,35.95 172.93,35.91 172.93,35.55 172.93,33.42 172.7,33.2 171.29,31.78 171.29,31.45 170.97,31.13 170.97,29.64 169.18,27.86 168.86,27.86 160.85,27.86 160.04,27.04 160.04,27 157.4,27 157.08,27 156.76,27.33 151.92,27.33 151.46,27.79 151.46,27.84 151.44,27.86 149.46,27.86 149.12,27.52 148.9,27.52 141.74,27.52 141.48,27.77 136.03,27.77 135.15,26.88 v2(135.15,26.69)
VGA_ALERT: length 36
  TOP w0.127: v2(234.39,57.28) 234.39,58.13 233.55,58.97 233.55,59.47 231.93,61.08 v1(231.13,61.08) 229.63,61.08 226.8,63.92 226.8,67.29 223.08,71.01 219.37,71.01 218.95,71.42 216.59,71.42 216.34,71.67 v2(216.34,72.33)
  BOTTOM w0.102: 211.07,75.71 211.07,76.13 UG1.M2
  BOTTOM w0.127: v2(216.34,72.33) 216.09,72.58 215.19,72.58 214.47,73.31 213.34,73.31 212.6,74.04 212.6,74.12 211.07,75.65 211.07,75.71 ; v2(234.39,57.28) 234.23,57.44 RG397.2
VGA_CORE_EN: length 32.9
  TOP w0.127: v2(221.31,54.61) v3(221.31,55.38)
  IN1 w0.254: v2(233.58,51.38) 233.58,51.27 235.89,48.96 v2(235.89,48.54)
  IN2 w0.254: v2(221.31,54.61) 221.31,53.09 224.63,49.77 230.2,49.77 231.81,51.38 v2(233.58,51.38)
  BOTTOM w0.254: v2(221.31,54.61) 221.52,54.4 PRV14.2 ; RG105.2 CG197.2 235.53,40.96 235.29,41.21 DG4.1 234.7,42.26 234.7,43.35 234.93,43.58 236.04,43.58 236.25,43.79 236.25,44.45 237.45,45.66 237.45,47.11 236.02,48.54 v2(235.89,48.54)
VGA_GATE: length 3.5
  BOTTOM w0.127: QG1.5 184.12,80.66 UG8.4 183.76,80.65 183.75,80.65 183.55,80.65 183.18,80.27 CG46.1 182.86,80.27 182.35,80.78 v1(182.35,81.14)
VGA_I2CS_SCL: length 23
  BOTTOM w0.102: UG1.T4 207.84,77.63 207.84,75.6 208,75.43
  BOTTOM w0.127: 208,75.43 208.49,74.95 209.66,74.95 210.14,74.47 210.31,74.47 211.23,73.55 211.23,73.38 213.78,70.83 214.89,70.83 216.92,68.81 216.92,65.95 v1(217.56,65.3) 218.37,64.49 RG36.1 219.58,64.49 220.31,63.76 221.14,63.76 221.2,63.82 QG2.4
VGA_I2CS_SDA: length 24.3
  BOTTOM w0.102: UG1.T3 206.91,76.92 206.91,76.09 207.03,75.97 207.03,75.68 208.11,74.6 208.54,74.6
  BOTTOM w0.127: 208.54,74.6 209.69,74.6 210.04,74.24 210.21,74.24 211,73.45 211,73.28 213.24,71.05 213.24,70.89 213.76,70.36 214.75,70.36 216.48,68.63 216.48,65.77 217.89,64.37 217.89,63.76 v1(217.59,63.46) 217.59,62.31 RG35.1 219.44,62.35 QG2.1
VGA_OVERT#: length 128.7
  TOP w0.127: v2(235.03,57.29) 235.03,57.86 233.81,59.08 233.81,59.7 232.06,61.45 229.63,61.45 227.06,64.03 227.06,67.4 223.19,71.27 219.48,71.27 219.06,71.68 216.97,71.68 v2(216.76,71.89) ; v1(189.34,82.42) 189.57,82.19 190.16,82.19 v2(190.16,82.19)
  IN2 w0.127: v2(235.25,48.55) 235.25,48.32 234.13,47.21 232.81,47.21 232.4,47.62 231.44,47.62 231.28,47.77 223.8,47.77 220.84,50.73 196.78,50.73 196.73,50.78 195.72,50.78 193.79,52.71 192.33,54.17 191.24,55.26 191.24,69.4 190.92,69.72 190.92,70.6 191.51,71.19 191.51,73.94 190.06,75.4 190.06,77.15 190.57,77.66 190.57,79 190.82,79.25 190.82,80.38 190.21,80.99 189.88,80.99 189.69,81.18 189.69,81.93 189.94,82.19 v2(190.16,82.19)
  IN3 w0.127: v2(235.25,48.55) 235.25,49.82 235.64,50.22 235.64,52.36 235.03,52.97 v2(235.03,57.29)
  BOTTOM w0.127: v2(190.16,82.19) 188.8,82.19 188.69,82.08 188.08,82.08 187.88,82.28 186.64,82.28 186.26,81.9 186.26,81.77 186.1,81.61 QG1.4 ; UG1.M1 210.68,75.71 212.37,74.02 212.37,73.9 213.23,73.04 214.36,73.04 215.08,72.32 215.76,72.32 216.19,71.89 v2(216.76,71.89) ; v2(235.03,57.29) 235.02,57.3 RG396.2
VR_HOT#: length 232.6
  TOP w0.127: PRZ5.2 v2(174.52,133.31) ; v2(118.52,27.8) 118.58,27.74 118.58,27.71 119.41,26.88 120.1,26.88 121.5,25.48 122.9,25.48 124.58,23.81 124.58,22.26 125,21.84 126.88,21.84 127.42,21.3 CK11.2 128.83,21.3 129.26,20.88 RK8.1 ; v2(190.31,83.36) 190.12,83.55 188.29,83.55 187.85,83.12 187.34,82.6 187.34,80.97 183.77,77.4 183.77,75.81 177.02,69.05 177.02,67.74 v2(177.25,67.51)
  IN1 w0.127: v2(190.31,83.36) 190.31,84.84 187.64,87.51 185.99,87.51 178.47,95.03 178.47,103.18 177.03,104.62 177.03,106.6 175.81,107.83 175.81,108.12 172.06,111.86 v2(172.06,112.51)
  IN2 w0.127: v2(174.52,133.31) 174.52,133.18 175.37,132.33 175.37,131.93 177.73,129.56 177.73,124.15 171.96,118.39 171.96,112.61 v2(172.06,112.51)
  IN3 w0.127: v2(99.86,26.54) 99.86,26.43 102.17,24.12 111.94,24.12 112.41,24.59 113.92,24.59 115.02,25.69 116.97,25.69 117.71,26.43 117.71,26.87 118.33,27.49 118.33,27.61 v2(118.52,27.8)
  BOTTOM w0.127: v2(177.25,67.51) 168.83,67.51 162.37,61.05 114.62,61.05 106.32,52.75 102.24,52.75 100.8,51.31 100.8,37.58 98.92,35.7 98.92,30.96 99.86,30.01 v2(99.86,26.54) ; PRZ5.2 v2(174.52,133.31)
VR_ON: length 161.5
  TOP w0.127: v2(179.69,69.17) 179.69,69.46 184.02,73.8 v1(184.95,73.8) 186.09,73.8 189.47,77.17 189.47,79.55 190.15,80.24 v2(190.27,80.24) ; v2(141.64,22.53) UK1.85
  IN1 w0.127: v2(190.27,80.24) 190.27,80.63 189.67,81.22 189.67,83.83 186.43,87.08 185.81,87.08 178.03,94.86 178.03,99.94 178.03,99.94 178.03,103.01 176.6,104.44 176.6,106.42 175.38,107.65 175.38,107.94 171.4,111.91 v2(171.4,112.04)
  IN2 w0.142: v2(175.45,130.93) 175.31,130.93 174.22,129.84 174.22,123.12 171.51,120.4 171.51,112.14 v2(171.4,112.04)
  IN3 w0.127: v2(179.69,69.17) 179.54,69.03 177.53,69.03 175.9,67.4 175.9,52.44 175.37,51.91 175.37,49.81 174.16,48.6 174.16,44.59 174.57,44.18 174.57,43.68 176.08,42.17 v2(176.3,42.17)
  BOTTOM w0.127: v2(176.3,42.17) 176.04,42.17 175.84,41.97 175.84,41.73 174.92,40.81 174.92,36.59 175.69,35.82 175.69,32.65 174.92,31.88 174.92,29.14 171.76,25.98 166.53,25.98 165.33,24.78 165.2,24.78 165.19,24.76 165.18,24.76 165.17,24.75 165.08,24.75 165.04,24.74 164.42,24.74 163.2,23.52 163.11,23.52 148.13,23.52 147.52,22.92 147.2,22.92 142.03,22.92 v2(141.64,22.53)
  BOTTOM w0.137: v2(175.45,130.93) PRZ26.2
VR_PWRGD: length 157.6
  TOP w0.127: UK1.71 147.24,22.9 147.42,22.72 v2(147.42,22.44) ; v2(190.25,79.63) 189.81,79.19 v1(189.81,78.45) 189.81,78.35 189.73,78.27 189.73,77.06 186.06,73.39 183.98,73.39 180.37,69.78 v2(180.37,69.34)
  TOP w0.203: PRZ18.2 172.98,129.66 v2(172.95,129.64)
  IN1 w0.127: v2(170.77,112.04) 170.77,111.95 171.12,111.61 171.34,111.61 175.11,107.83 175.11,107.54 176.34,106.32 176.34,104.33 177.77,102.9 177.77,100.05 177.77,100.04 177.77,94.75 185.7,86.82 186.32,86.82 189.41,83.73 189.41,81.12 189.83,80.7 189.83,80.05 v2(190.25,79.63)
  IN2 w0.142: v2(172.95,129.64) 173.33,129.64 173.87,129.11 173.87,123.16 171.23,120.52 171.23,112.49 v2(170.77,112.04)
  IN3 w0.127: v2(180.37,69.34) 180.37,69.39 180.15,69.61 177.74,69.61 175.43,67.31 175.43,52.34 175.1,52.02 175.1,49.92 173.89,48.71 173.89,44.47 174.3,44.06 174.3,43.57 v2(176.28,41.59)
  BOTTOM w0.127: v2(147.42,22.44) 147.72,22.74 147.73,22.74 148.25,23.26 162.43,23.26 162.43,23.26 163.22,23.26 163.22,23.26 163.31,23.26 164.51,24.47 164.97,24.47 165.26,24.47 165.29,24.5 165.29,24.5 165.31,24.52 165.44,24.52 166.64,25.72 171.65,25.72 171.65,25.71 171.86,25.71 175.18,29.03 175.18,29.06 175.18,31.77 175.95,32.54 175.95,35.93 175.18,36.7 175.18,40.49 v2(176.28,41.59)
  BOTTOM w0.203: PUZ1.45 172.13,130.03 172.37,129.79 172.8,129.79 v2(172.95,129.64)
VRAM_VDD_CTL: length 45.6
  TOP w0.102: 215.28,74.38 214.82,74.84 214.82,75.03 213.88,75.97 212.72,75.97 211.78,76.9 211.78,77.09 211.14,77.74 v2(211.06,77.74)
  TOP w0.127: v2(236.93,54.17) 236.71,54.39 235.72,54.39 235.29,54.83 235.29,55.78 235.74,56.23 235.74,58.05 234.59,59.21 v1(234.59,60.25) 234.59,60.82 233.39,62.01 229.81,62.01 227.58,64.24 227.58,67.62 223.41,71.79 219.69,71.79 219.25,72.23 218.25,72.23 216.7,73.78 215.88,73.78 215.28,74.38
  BOTTOM w0.109: UG1.L3 211.46,77.34 v2(211.06,77.74)
  BOTTOM w0.127: PRW14.1 236.92,52.3 236.62,52 PRW12.1 236.19,52.25 236.93,52.99 v2(236.93,54.17)
VRAM_VREF_CTL: length 126.2
  TOP w0.127: v2(224.57,64.63) 225.08,64.63 RG401.2 225.49,65.04 225.49,66.49 223.45,68.53 223.16,68.53 221.98,69.7 216.42,69.7 213.54,72.58 v2(213.54,73.7) ; v2(181.31,130.52) 181.66,130.52 v1(182.07,130.93)
  IN1 w0.127: v2(242.63,62.55) 240.24,64.94 235.08,64.94 234.16,64.02 233.56,64.02 233.31,63.77 228.26,63.77 227.31,64.71 224.65,64.71 v2(224.57,64.63)
  IN3 w0.127: v2(213.54,73.7) 213.3,73.7 211.48,75.52 211.48,83.04 212.59,84.15 212.59,88.03 212.89,88.33 212.89,93.27 211.03,95.13 200.1,95.13 198.31,96.92 197.64,96.92 197.06,97.51 195.68,97.51 195,98.19 191.81,98.19 189.21,100.78 189.21,103.07 188.35,103.93 188.35,110.79 180.78,118.36 180.78,130.19 181.11,130.52 v2(181.31,130.52)
  BOTTOM w0.109: v2(213.54,73.7) 213.31,73.7 212.82,74.19 212.82,74.4 UG1.L1
  BOTTOM w0.127: v2(242.63,62.55) 243.05,62.13 QG4.2 ; v2(181.31,130.52) 181.62,130.52 QG3.2
VREF: length 3.6
  TOP w0.203: UA1.38 291.56,23.03 291.15,23.44 v2(291.15,23.6)
  BOTTOM w0.127: v1(291.94,23.18) 291.57,23.18 v2(291.15,23.6)
  BOTTOM w0.356: CA19.1 CA20.1 291.37,23.6 v2(291.15,23.6)
VSN_1PH: length 3
  BOTTOM w0.203: PUZ1.51 171.58,127.63 171.94,127.27 171.94,127.12 172.55,126.52 PCZ1.2 PRZ10.2
VSN_2PH: length 4.8
  BOTTOM w0.127: PRZ32.1 171.45,135.95 171.04,136.37 v1(170.98,136.37)
  BOTTOM w0.203: PUZ1.37 169.83,133.04 170.67,133.88 170.96,133.88 171.45,134.38 PCZ15.1 PRZ32.1
VSN_4PH: length 5.2
  BOTTOM w0.203: PUZ1.2 170.23,125.91 170.83,125.31 v1(170.83,125.19) 170.83,124.93 171.84,123.92 PRZ28.2 PCZ13.2
VSP_1PH: length 5.5
  TOP w0.127: v1(173.28,123.86) 172.72,124.42 PCZ7.2
  TOP w0.203: v2(172.04,124.99) 172.17,124.86 PCZ7.2 PRZ12.2
  BOTTOM w0.203: PUZ1.52 171.35,127.23 172.04,126.54 v2(172.04,124.99)
VSP_2PH: length 6.1
  BOTTOM w0.127: v1(175.18,134.9) 174.73,134.9 174.27,134.44 PRZ31.1
  BOTTOM w0.203: PRZ31.1 PCZ14.1 172.81,133.94 171.59,133.94 171.02,133.37 170.64,133.37 170.23,132.96 PUZ1.38
VSP_4PH: length 7.8
  BOTTOM w0.127: v1(176.53,124.25) 176.1,124.69 PRZ25.2
  BOTTOM w0.203: PUZ1.1 170.63,126.02 171.51,125.14 171.51,124.76 171.79,124.48 172.29,124.48 172.61,124.8 174.46,124.8 PCZ12.2 PRZ25.2
VTTREF_DDR: length 1.8
  BOTTOM w0.203: PCM15.1 94.4,26.57 v2(94.18,26.35) 93.94,26.35 93.75,26.55 PUM1.4
WAKE#: length 343.4
  TOP w0.127: v2(48.72,13.51) 48.8,13.58 v1(49.4,13.58) 49.48,13.58 49.49,13.59 52.74,13.59 53.09,13.24 53.66,13.24 54.48,12.42 57.06,12.42 60.74,16.1 61.76,16.1 65,19.34 65,20.01 65.02,20.03 v2(66.03,21.03) ; RH171.1 187.76,13.26 187.76,14.45 187.94,14.63 187.94,15.72 v2(187.72,15.94) ; v2(311.53,13.68) 311.27,13.41 309.16,13.41 ; v2(276.58,9.66) 276.74,9.82 276.74,20.1 273.12,23.72 273.12,27.01 274.97,28.87 v2(276.14,28.87)
  TOP w0.135: 309.16,13.41 307.7,13.41 305.28,15.83 305.2,15.83 304.51,16.52 303.56,16.52 303.2,16.16 302.34,16.16 302.09,15.91 QWL1.1
  IN2 w0.127: v2(276.14,28.87) 275.9,28.64 265.47,28.64 263.98,30.13 258.99,30.13 255.68,33.44 253.1,33.44 252.9,33.25 252.9,32.37 252.55,32.02 248.79,32.02 248.57,32.02 247.86,32.73 239.73,32.73 238.84,32.73 238.65,32.92 227.72,32.92 220.39,25.59 220.39,24.28 219.92,23.81 218.72,23.81 217.53,22.63 216.73,22.63 215.77,21.66 214.8,21.66 214.59,21.87 211.02,21.87 210.56,21.41 210.56,20.85 208.25,18.54 202.82,18.54 201.13,16.85 200.74,16.85 199.98,16.09 197.45,16.09 197.24,15.87 194.21,15.87 193.61,16.47 192.21,16.47 192.06,16.62 189.85,16.62 188.84,15.61 188.05,15.61 v2(187.72,15.94) 187.51,15.94 187.21,16.24 184.14,16.24 180.97,19.4 169.18,19.4 167.75,17.97 151.75,17.97 149.32,15.54 143.95,15.54 142.64,14.24 135.79,14.24 134.12,15.91 131.99,15.91 131.42,15.34 128.15,15.34 128,15.49 125.61,15.49 125.01,14.89 119.02,14.89 117.6,13.46 115.95,13.46 115.27,14.15 113.02,14.15 111.18,15.98 108.01,15.98 106.63,17.36 101.88,17.36 101.27,17.98 86.65,17.98 83.76,20.88 79.36,20.88 78.07,19.59 66.05,19.59 65.59,20.04 65.59,20.58 66.03,21.01 v2(66.03,21.03)
  IN3 w0.127: v2(276.58,9.66) 278.05,9.66 282.81,4.9 300.23,4.9 301.1,5.77 304.43,5.77 311.53,12.87 v2(311.53,13.68)
  BOTTOM w0.102: 189.81,18.92 189.81,19.25 190.48,19.92 190.93,19.92 191.07,19.79 UH1.BB47
  BOTTOM w0.127: 189.81,18.92 188.91,18.02 188.91,16.75 188.61,16.44 188.23,16.44 v2(187.72,15.94) ; v2(48.72,13.51) 48.85,13.64 QR2.1
WL_OFF#: length 127.7
  TOP w0.127: RH180.2 203.53,23.39 204.22,23.39 204.43,23.18 204.43,22.62 204.22,22.41 203.66,22.41 v2(203.44,22.19)
  IN1 w0.127: v2(306.87,10.89) 306.43,10.45 306.43,8.35 304.48,6.4 300.99,6.4 299.75,5.16 283.54,5.16 275.1,13.6 275.1,14.18 274.48,14.81 267.94,14.81 267.55,14.41 265.14,14.41 264.42,13.69 257.39,13.69 256.8,14.28 248.19,14.28 247.52,13.6 234.57,13.6 234.24,13.27 230.96,13.27 230.18,12.49 228.68,12.49 228.1,13.08 225.36,13.08 224.57,12.29 222.07,12.29 221.65,11.87 215.67,11.87 215.05,12.5 213.58,12.5 213.2,12.12 210.08,12.12 205.69,16.51 205.69,17.6 204.17,19.12 204.17,21.36 203.44,22.09 v2(203.44,22.19)
  BOTTOM w0.127: JWLAN1.48 309.65,10.85 309.26,10.46 307.31,10.46 v2(306.87,10.89) ; UH1.AW24 203.44,22.11 v2(203.44,22.19)
WL_PWREN_EC#: length 201.8
  TOP w0.127: v2(141.66,19.26) 141.01,19.91 138.58,19.91 136.67,21.82 UK1.98 ; v2(301.28,11.63) v1(300.91,11.26)
  TOP w0.135: v2(301.28,11.63) 301.44,11.48 RWL30.2
  IN2 w0.127: v2(154.64,4.8) 154.63,4.81 154.63,5.4 154.48,5.55 154.48,6.18 154.7,6.4 154.7,9.26 156.58,11.15 167.77,11.15 171.54,7.38 171.54,7.37 172.87,6.04 174.85,6.04 175.01,6.2 175.01,6.9 175.49,7.38 177.12,7.38 178.47,6.04 220.98,6.04 224.11,9.18 224.65,9.18 225.39,9.92 225.39,11.86 228.52,14.99 230.95,14.99 232,13.95 236.67,13.95 238.14,15.41 256.45,15.41 257.46,14.41 264.5,14.41 265.48,15.38 275.01,15.38 275.41,14.98 v2(278.94,14.98)
  IN3 w0.142: v2(301.28,11.63) 301.21,11.56 298.44,11.56 297.99,11.11 292.18,11.11 291.03,9.96 286.2,9.96 282.14,14.03 279.9,14.03 v2(278.94,14.98)
  BOTTOM w0.127: v2(141.66,19.26) 141.66,18.69 139.09,16.12 139.09,10.88 143.47,6.5 153.69,6.5 154.63,5.56 154.63,4.81 v2(154.64,4.8)
WL_WAKE#: length 7.6
  TOP w0.127: QWL1.3 304.44,14.56 RWL4.2 304.44,15.78 v1(304.06,16.16)
  TOP w0.135: v2(301.65,12.13) 302.01,12.13 QWL1.3
  BOTTOM w0.127: v2(301.65,12.13) 301.73,12.05 301.73,11.29 301.92,11.1 JWLAN1.47
XCLK_BIASREF: length 3.6
  TOP w0.127: RH20.2 214.3,34.66 215.13,34.66 v1(215.65,34.14)
  TOP w0.508: RH20.2 214.27,34.16 214.14,34.03 v2(214.14,33.72)
  BOTTOM w0.152: UH1.T3 213.83,33.72 v2(214.14,33.72)
XDP_BPM#0: length 3.2
  BOTTOM w0.102: UC1.BR27 127.64,101.86 127.1,101.86 127.06,101.82 125.32,101.82 TC295.1
XDP_BPM#1: length 2.4
  BOTTOM w0.102: UC1.BT27 127.24,101.52 125.71,101.52 125.35,101.17 TC296.1
XDP_BPM#2: length 1.3
  TOP w0.127: v2(129.56,105.12) 129.87,105.12 TC101.1
  BOTTOM w0.135: UC1.BM31 v2(129.56,105.12)
XDP_BPM#3: length 2.6
  BOTTOM w0.102: UC1.BT30 127.18,104.04 125.87,104.04
  BOTTOM w0.127: 125.87,104.04 125.72,104.04 125.24,103.55 TC100.1
XDP_ITP_PMODE: length 4.9
  TOP w0.127: v2(216.08,25.71) 216.08,25.67 v1(216.45,25.31) 216.84,24.92 RC383.2
  BOTTOM w0.102: UH1.AL3 213.41,25.94 213.82,25.94 214.06,25.7 215.07,25.7 215.35,25.99 215.81,25.99 v2(216.08,25.71)
XDP_PRDY#: length 233.8
  IN2 w0.127: v2(215.51,25.62) 215.81,25.32 216.33,25.32 217.51,26.49 217.51,33.5 217.84,33.83 217.84,35.76 218.86,36.78 218.86,38.54 218.24,39.16 218.24,40.3 216.09,42.45 214.59,42.45 212.65,44.39 212.42,44.39 212.21,44.6 211.89,44.6 211.86,44.63 211.72,44.77 197.94,44.77 197.84,44.86 197.34,45.36 196.19,45.36 194.17,43.34 190.26,43.34 187.7,40.78 187.7,40.44 186.74,39.49 182.44,39.49 180.12,37.17 178.59,37.17 172.38,30.95 171.53,30.95 169.31,28.73 163.39,28.73 163.17,28.94 150.24,28.94 149.83,28.54 145.18,28.54 144.7,28.05 143.23,28.05 142.63,28.65 141.73,28.65 141.07,27.99 134.12,27.99 133.33,27.2 125.95,27.2 125.22,26.47 119.08,26.47 118.78,26.17 117.18,26.17 115.3,28.05 v2(115.29,28.05)
  IN3 w0.127: v2(125.94,101.09) 125.94,100.38 126.15,100.17 126.15,95.47 123.46,92.78 123.46,88.32 121.57,86.44 120.71,85.57 118.75,85.57 118.19,85.02 115.08,85.02 114.74,84.68 113.54,83.48 arc(112.42,81.8) 112.03,79.83 112.03,77.91 106.15,72.03 106.15,71.36 105.67,70.88 105.67,69.56 104.25,68.14 104.25,67.04 102.28,65.07 102.28,56.43 100.67,54.82 100.67,48.15 101.88,46.94 101.88,45.69 103.88,43.69 103.88,39.39 105.87,37.4 105.87,31.84 107.22,30.49 107.86,30.49 109.25,29.11 114.23,29.11 v2(115.29,28.05)
  BOTTOM w0.102: 213.83,25.47 213.72,25.47 213.52,25.28 213.08,25.28 212.96,25.32 212.38,25.32 UH1.AM5 ; UC1.BP27 128.19,101.17 126.12,101.17 126.04,101.09 v2(125.94,101.09)
  BOTTOM w0.127: v2(215.51,25.62) 215.39,25.5 213.86,25.5 213.83,25.47
XDP_PREQ#: length 232.1
  TOP w0.127: v1(109.86,28.42) 109.56,28.42 v2(109.21,28.07)
  IN2 w0.127: v2(109.21,28.07) 109.21,27.37 114.14,22.44 115.75,22.44 116.44,23.13 125.07,23.13 125.71,23.76 128.37,23.76 128.78,23.34 131.37,23.34 132.41,24.38 135.96,24.38 136.33,24.74 142.46,24.74 142.82,24.38 150.65,24.38 151.51,25.25 163.48,25.25 163.63,25.4 171.1,25.4 176.07,30.37 176.58,30.37 177.04,30.82 177.04,31.51 177.77,32.24 178.54,32.24 179.38,33.08 180.63,33.08 184.45,36.9 188.31,36.9 191.84,40.43 192.72,40.43 193.52,39.62 199.62,39.62 200.25,40.25 205.77,40.25 206.21,39.81 206.51,39.81 206.85,39.47 210.48,39.47 211.19,38.76 211.19,37.97 211.78,37.37 212.74,37.37 213.03,37.08 213.03,35.79 212.18,34.94 212.18,32.38 213.81,30.75 213.81,28.88 212.72,27.8 212.72,25.88 v2(212.55,25.7)
  IN3 w0.127: v2(131.14,104.07) 131.13,104.05 129.55,104.05 129.21,103.71 125.43,103.71 125.1,103.38 125.1,102.28 125.5,101.88 125.5,95.46 123.03,92.98 123.03,88.5 120.53,86 118.57,86 118.02,85.45 114.9,85.45 114.43,84.98 113.17,83.72 arc(112.01,81.98) 111.6,79.92 111.6,78.09 105.72,72.21 105.72,71.54 105.24,71.06 105.24,69.74 103.82,68.32 103.82,67.22 101.94,65.33 100.62,62.94 100.62,61.06 100.96,60.72 100.96,55.84 100.24,55.12 100.24,47.97 101.45,46.76 101.45,45.51 103.45,43.51 103.45,39.21 105.44,37.22 105.44,31.66 107.04,30.06 107.59,30.06 108.69,28.96 108.69,28.6 v2(109.21,28.07)
  BOTTOM w0.102: v2(212.55,25.7) 212.81,25.7 213,25.51 213.11,25.47 213.45,25.47 UH1.AL2
  BOTTOM w0.127: v2(131.14,104.07) 130.84,104.09 UC1.BL30
XGND: length 3.4
  TOP w0.127: v1(43.94,35.08) v2(43.45,35.58)
  TOP w0.508: RL55.1 42.99,36.04 v2(43.45,35.58)
  BOTTOM w0.508: v2(43.45,35.58) 42.66,36.37 TSL1.25
XTAL_24M_PCH_IN: length 2.8
  BOTTOM w0.127: RH18.1 218.11,33.32 RH16.2 218.18,32.43 CH5.1 218.8,32.42 YH1.1
XTAL_24M_PCH_IN_R: length 7.4
  BOTTOM w0.127: RH18.2 215.8,33.32 214.7,32.22 212.92,32.22 212.85,32.16 212.23,32.16 212.22,32.14 210.77,32.14 210.67,32.24 210.18,32.24 210.06,32.36 UH1.U10
XTAL_24M_PCH_OUT: length 5.5
  BOTTOM w0.127: YH1.3 220.21,33.71 220.01,33.5 218.85,33.5 218.67,33.68 218.67,34.8 218.5,34.97 CH4.1 218.19,34.17 RH16.1 218.13,34.11 RH17.1
XTAL_24M_PCH_OUT_R: length 7.5
  BOTTOM w0.127: RH17.2 215.83,34.11 214.45,32.73 213.33,32.73 213.32,32.74 212.89,32.74 212.63,32.49 212.02,32.49 212.01,32.47 211.01,32.47 210.8,32.69 210.8,32.79 210.69,32.9 210.35,32.9 210.26,32.82 210.26,32.67 210.33,32.6 UH1.U9
XTAL_OUTBUFF: length 1.8
  TOP w0.127: RG9.1 212.72,77.79 v2(212.76,77.79)
  BOTTOM w0.102: v2(212.76,77.79) 212.85,77.8 212.87,77.82 UG1.J4
XTAL_SSIN: length 11
  BOTTOM w0.102: UG1.H1 213.98,74.93 215.54,73.37 216.33,73.37
  BOTTOM w0.127: 216.33,73.37 216.69,73.37 v1(218.85,71.21) 218.91,71.14 221.05,71.14 221.85,70.35 RG11.1
XTALIN: length 19.1
  BOTTOM w0.109: 216.07,74.18 215.55,74.7 215.34,74.7 214.95,75.09 214.95,75.76 214.43,76.28 214.43,76.58 213.98,77.04 UG1.H3
  BOTTOM w0.127: 216.07,74.18 217.05,74.18 219.22,72.01 221.28,72.01 223.23,70.06 v1(223.23,69.64) CG2.1 223.59,68.62 223.75,68.47 223.75,65.32 223.49,65.06 YG1.3
XTALOUT: length 13.9
  BOTTOM w0.109: UG1.H2 214.18,76.34 214.18,76.16 214.69,75.65 214.69,75.01 215.88,73.82
  BOTTOM w0.127: RG80.2 222.72,68.72 222.72,70.03 v1(221.84,70.91) 221.12,71.63 219.06,71.63 216.89,73.8 215.9,73.8 215.88,73.82
XTALOUT_R: length 2.3
  BOTTOM w0.127: YG1.1 221.57,67.08 CG1.1 RG80.1
XTLI: length 7.5
  BOTTOM w0.127: UL1.28 53.08,19.74 52.86,19.96 52.48,19.96 52.24,19.71 52.24,19.07 51.77,18.59 CL25.2 50.46,18.59 50.38,18.67 RL7.2 49.47,19.19 48.17,19.19 47.96,18.98 YL1.1
XTLO: length 3
  BOTTOM w0.127: RL57.2 CL24.2 50.14,19.43 RL7.1 49.29,19.58 YL1.3
XTLO_R: length 2
  BOTTOM w0.127: UL1.29 53.07,20.14 52.94,20.28 52.64,20.28 52.63,20.28 51.83,20.28 RL57.1
N15156561: length 2
  BOTTOM w0.127: v1(222.29,62.33) 222.01,62.33 220.79,61.1 PRV27.2
N15160747: length 3
  BOTTOM w0.254: PRV16.1 225.53,60.52 PCV18.1 227.2,59.81 PRV18.2
N16789346: length 7.5
  BOTTOM w0.137: TC55.1 124.07,79.19 126.76,81.88 128.2,81.88 128.58,82.26 UC1.BP1
N16789364: length 3.4
  BOTTOM w0.127: TC57.1 167.36,111.55 UC1.B38
N16789382: length 4.1
  BOTTOM w0.135: TC59.1 170.72,82.8 170.64,82.72 169.5,82.72 169.05,83.18 UC1.B2
N16789430: length 7.1
  BOTTOM w0.127: UC1.E2 165.44,82.73 165.53,82.64 165.53,82.32 165.94,81.91 166.3,81.91
  BOTTOM w0.135: 166.3,81.91 168.36,81.91 170.05,80.21 170.52,80.21 170.54,80.22 TC25.1
N16789448: length 11.2
  BOTTOM w0.135: UC1.E1 165.14,82.33 165.83,81.63 167.98,81.63 169.74,79.86 171.13,79.86 173.7,82.44 TC26.1
N16789466: length 5.7
  BOTTOM w0.135: UC1.D1 166.3,82.14 168.71,82.14 169.58,81.27 170.74,81.27 TC24.1
N16789484: length 6.7
  BOTTOM w0.137: UC1.BR1 127.66,82.32 126.39,82.32 122.85,78.78 TC27.1
N16865170: length 1.2
  TOP w0.127: TC94.1 140.68,89.58 v2(141.04,89.93)
  BOTTOM w0.137: v2(141.04,89.93) 140.64,90.33 UC1.AU13
N16865242: length 1.1
  TOP w0.127: v2(139.18,89.98) 139.09,89.98 TC95.1
  BOTTOM w0.137: v2(139.18,89.98) 138.84,90.33 UC1.AY13
N16884472: length 3
  BOTTOM w0.127: UC1.C38 166.58,112.16 TC51.1
N16884473: length 6
  BOTTOM w0.127: 172.15,81.75 TC52.1
  BOTTOM w0.135: UC1.C1 168.9,82.52 169.38,82.03 171.87,82.03 172.15,81.75
N16884474: length 6.7
  BOTTOM w0.137: TC53.1 122.86,80.29 123.98,80.29 126.27,82.57 127.31,82.57 127.97,83.23 UC1.BR2
N16884482: length 4.6
  BOTTOM w0.137: TC29.1 124.11,80.92 126.19,83 127.2,83 UC1.BT2
N16886077: length 1.4
  TOP w0.135: v2(208.23,31.8) 208.45,31.58 208.45,31.46 208.59,31.32 TH1.1
  BOTTOM w0.127: UH1.Y14 208.23,31.28 v2(208.23,31.8)
N16886097: length 1.4
  TOP w0.135: TH2.1 207.78,31.99 v2(207.6,31.81)
  BOTTOM w0.254: v2(207.6,31.81) 207.6,31.43 UH1.Y15
N16889098: length 10.9
  TOP w0.127: TH4.1 191.39,37.75 192.25,36.89 193.09,36.89 194.13,35.86 194.7,35.86 195.92,34.64 196.13,34.64 196.66,34.11 196.66,33.41 197.14,32.93 v2(198.06,32.93)
  BOTTOM w0.127: v2(198.06,32.93) 197.61,32.47 UH1.U35
N16889099: length 1.3
  TOP w0.127: v2(198.8,33.99) 198.8,34.43 TH5.1
  BOTTOM w0.127: v2(198.8,33.99) 198.98,33.99 UH1.N32
N16889100: length 1.4
  TOP w0.127: v2(198.71,33.41) 199.16,33.41 TH6.1
  BOTTOM w0.127: v2(198.71,33.41) 198.79,33.49 UH1.R32
N16889101: length 1.1
  TOP w0.127: TH7.1 206.88,26.95 v2(207.28,26.55)
  BOTTOM w0.127: UH1.AH15 207.28,27.07 v2(207.28,26.55)
N16889102: length 1.8
  TOP w0.127: v2(207.96,27.64) 208.13,27.47 TH8.1
  BOTTOM w0.127: UH1.AH14 207.96,27.19 v2(207.96,27.64)
N16889103: length 8.9
  TOP w0.127: TH3.1 193.03,36.58 194.02,35.59 194.57,35.59 195.75,34.41 195.92,34.41 196.33,34.01 196.33,33.29 197.19,32.43 v2(197.19,31.86)
  BOTTOM w0.127: UH1.U37 197.19,32.02 v2(197.19,31.86)
N16892256: length 1.4
  TOP w0.127: v2(197.24,24.13) 197.52,24.41 197.52,24.44 197.69,24.61 TH11.1
  BOTTOM w0.127: UH1.AN35 197.58,24.47 v2(197.24,24.13)
N16892639: length 4
  BOTTOM w0.102: 189.38,22.88 189.82,22.88 190.56,22.14 191.24,22.14 UH1.AW48
  BOTTOM w0.127: 189.38,22.88 188.34,22.88 TH19.1
N16925558: length 3.2
  BOTTOM w0.102: TH74.1 198.03,15.81 198.03,17.2 198.2,17.37 198.2,18.59 UH1.BE33
N16937432: length 4.2
  TOP w0.305: RWL3.1 308.45,22.31 308.6,22.46 v2(309.08,22.46) 309.3,22.46 309.95,21.82 CWL1.1
  BOTTOM w0.305: v2(309.08,22.46) 309.08,22.79 309.64,23.35 JWLAN1.6
N16940119: length 1.1
  TOP w0.127: v2(207.2,25.32) 207.16,25.32 TH122.1
  BOTTOM w0.127: v2(207.2,25.32) 207.2,25.65 UH1.AL15
N16957386: length 2.6
  TOP w0.127: v1(176.61,28.67) C407.1
  TOP w0.254: U11.6 177.79,29.29 177.63,29.13 C407.1
N16983076: length 3
  TOP w0.254: DH4.1 204.62,6.27 RC82.2 203.47,6.64 203.52,6.69 RH260.1 203.08,6.98 202.87,7.19 RC81.2
N16995670: length 6.9
  BOTTOM w0.127: PCV16.1 223.44,61.65 v1(224.38,62.59)
  BOTTOM w0.254: PCV16.1 223.44,60.99 223.81,60.62 224.26,60.62 PRV7.2 224.06,60.05 223.89,60.05 223.61,59.77 PRV10.2 223.61,59.58 223.08,59.05 223.08,58.37 PRV11.1
N16995962: length 2.4
  BOTTOM w0.254: PUV1.16 v1(230.43,55.79) 230.66,55.79 231.14,55.31 PRV29.2
N17092107: length 1.9
  TOP w0.127: PRV15.1 v1(221.45,57.05)
  TOP w0.254: PRV15.1 222.49,57.05 PRV13.2
N17105073: length 1.5
  TOP w0.127: TH101.1 197.06,25.64 197.06,25.27 v2(197.05,25.26)
  BOTTOM w0.127: UH1.AL35 197.61,25.82 v2(197.05,25.26)
N17435076: length 3.2
  TOP w0.196: v1(207.27,13.21) 208.16,14.09 RH117.2 208.23,13.49 QH2.1
N17571862: length 4.1
  BOTTOM w0.127: v1(237.61,50.62) 237.75,50.62 237.98,50.85 237.98,50.99 238.2,51.21 PRW14.2 238.7,52.8 PCW5.1 238.31,53.1 238.1,53.31 PQW3.2
N17571879: length 7.5
  BOTTOM w0.127: PQW3.1 237.02,55.16 237.02,55.81 237.28,56.07 237.28,57 v1(237.59,57.31) 237.59,57.7 238.27,58.38 238.27,58.68 238.7,59.11 239.2,59.11 239.29,59.21 240.83,59.21 241.04,59 PRW8.2
N17571903: length 2.9
  BOTTOM w0.254: PRW9.2 242.13,60.08 PRW15.1 242.3,59.36 PRW7.2 242.3,58.23 PRW10.1
N17572010: length 1.3
  BOTTOM w0.127: PCW2.1 239.99,48.26 240.09,48.17 v1(240.09,48.04)
N17572050: length 0.8
  BOTTOM w0.254: PCW4.2 243.17,58.65 243.21,58.69 PRW7.1
N17572133: length 9.3
  TOP w0.127: v2(243.66,55.44) v1(243.66,54.93)
  IN1 w0.254: v2(238.18,54.86) 238.7,54.86 238.89,55.05 243.27,55.05 v2(243.66,55.44)
  BOTTOM w0.254: v2(243.66,55.44) PRW3.1 242.87,56.1 242.45,55.68 PUW1.5 ; v2(238.18,54.86) 237.98,55.06 PRW16.1
N17825974: length 7.1
  BOTTOM w0.102: UH1.AH47 191.47,26.98 190.3,26.98 190.1,27.18 190.1,27.43
  BOTTOM w0.135: 190.1,27.43 190.1,28.52 188.75,29.87 188.08,29.87 187.44,30.5 TH4942.1
N17825990: length 5.2
  BOTTOM w0.102: 190.4,27.89 190.4,27.32 190.55,27.17 191.13,27.17 UH1.AH48
  BOTTOM w0.135: 190.4,27.89 190.4,28.78 188.73,30.45 TH4943.1
N18049479: length 1.8
  TOP w0.127: v2(203.5,20.48) 203.42,20.48 203.21,20.7 203.21,21.39 TH4954.1
  BOTTOM w0.127: UH1.BB24 203.24,20.23 v2(203.5,20.48)
N18049493: length 2.5
  TOP w0.135: v2(201.43,23.43) 201.47,23.39 TH4956.1
  BOTTOM w0.102: UH1.AP24 202.39,24.04 202.01,23.65 201.65,23.65 v2(201.43,23.43)
N18049500: length 2.1
  TOP w0.127: v2(203.64,21.05) 204.49,21.91 TH4957.1
  BOTTOM w0.127: UH1.BA24 203.57,20.99 v2(203.64,21.05)
N18051110: length 1.2
  TOP w0.127: v2(212.1,21.45) 212.1,21.67 TH4968.1
  BOTTOM w0.127: UH1.AV6 212.1,21.7 v2(212.1,21.45)
N19357453: length 5.3
  TOP w0.127: QWL3.1 302.72,9.28 302.04,8.6 301.17,8.6 v1(300.96,8.81)
  TOP w0.135: RWL7.1 302.85,10.59 RWL31.2 RWL30.1 302.09,9.93 QWL3.1
N19377972: length 3
  TOP w0.127: QWL2.2 304.59,13.18 303.76,12.35 RWL7.2
N20648577:
  vias: v2(235.83,25.73)
N20648709: length 0.9
  BOTTOM w0.254: PC1008.2 238.72,22.11 PR1020.1
N21429485: length 2.2
  BOTTOM w0.127: v1(179.12,104.5) 179.24,104.38 PCH6.2
  BOTTOM w0.254: PCH6.2 180.25,104.13 180.55,103.83 PRH6.1
N21761451: length 1.9
  TOP w0.127: CV49.1 v1(68.67,39.52)
  TOP w0.508: RV48.2 CV49.1
N21819668: length 2.8
  TOP w0.127: RV52.2 v1(70.53,28.99)
  TOP w0.254: QV7.6 71.3,29.6 RV52.2
N21917236: length 2.6
  BOTTOM w0.203: PCZ1.1 PRZ10.1 PCZ4.2
  BOTTOM w0.254: PCZ4.2 PRZ9.2
N21917296: length 5.1
  TOP w0.203: PRZ16.1 174.4,125.75 PRZ12.1
  TOP w0.254: v2(176.55,124.89) 176.55,125.25 176.09,125.7 v1(175.67,125.7) PRZ16.1
  BOTTOM w0.203: PRZ11.2 176.15,125.63 PCZ4.1
  BOTTOM w0.254: PRZ11.2 176.55,125.23 v2(176.55,124.89)
N21981722: length 2.6
  BOTTOM w0.127: v1(227.04,13.64) 227.24,13.44 PRB17.2 228.53,13.44 PDB02.2
N21981818: length 2.8
  BOTTOM w0.127: PRB43.2 232.73,13.46 v1(232.99,13.71)
  BOTTOM w0.254: PDB02.3 231.24,13.46 PRB43.2
N22086953: length 100.4
  TOP w0.254: v2(115.99,96.84) 115.34,96.84 114.15,98.03 108.17,98.03 v1(107.99,98.21) 107.64,98.56 107.64,103.72 109.84,105.92 112.23,105.92 115.89,109.58 119.34,109.58 121.3,111.54 121.3,111.55 126.74,116.99 126.74,121.69 123.38,125.05 123.38,132.84 124.57,134.03 128.66,134.03 129.21,133.47 131.4,133.47 132.08,134.15 136.21,134.15 136.94,133.42 138.64,133.42 139.43,134.21 143.62,134.21 144.36,133.47 146.36,133.47 147.08,134.19 151.15,134.19 151.89,133.45 153.45,133.45 154.26,134.26 157.21,134.26 158.24,133.24 160.98,133.24 161.37,133.63 v2(161.75,133.63)
  BOTTOM w0.203: PRZ75.2 162.39,132.94 PRZ78.1 v2(161.75,133.63)
  BOTTOM w0.254: v2(115.99,96.84) 115.82,96.67 PHZ5.1
N22096717: length 21.6
  TOP w0.127: v2(162.9,124.1) 162.9,124.32 163.3,124.72 v1(163.3,124.78)
  IN1 w0.254: v2(162.9,124.1) 162.9,125.12 165.05,127.28 165.05,131.32 163.68,132.69 161.14,132.69 160.84,132.99 157.89,132.99 v2(156.11,131.21)
  BOTTOM w0.203: PRZ77.1 163.02,124.91 PRZ74.2
  BOTTOM w0.254: v2(162.9,124.1) 162.97,124.18 PRZ77.1 ; v2(156.11,131.21) PHZ4.1
N22407346: length 7.7
  BOTTOM w0.254: PLZ2.3 144.48,119.28 144.73,119.53 146.89,119.53 147.78,118.65 PRZ84.1
N22407630: length 7.4
  BOTTOM w0.254: PRZ81.1 148.92,118.38 150.07,119.53 151.85,119.53 152.1,119.28 PLZ1.3
N22480039: length 7.7
  BOTTOM w0.254: PRZ87.1 133.56,118.77 134.32,119.53 136.61,119.53 136.86,119.28 PLZ3.3
N22480324: length 7.6
  BOTTOM w0.254: PRZ90.1 132.42,118.77 131.65,119.53 v2(129.99,119.53) 129.49,119.53 129.24,119.28 PLZ4.3
N22481576: length 4
  TOP w0.127: PRA3.2 157.94,124.09 157,125.03 v1(157,125.59)
  TOP w0.508: PRA3.2 158.99,124.09 159.2,124.31 PCA7.1
N22481729: length 2.9
  TOP w0.127: v1(113.39,99.26) 114.08,99.95 PRG3.1
  TOP w0.254: v2(114.64,100.86) 114.08,100.3 PRG3.1
  BOTTOM w0.135: PLG1.3 v2(114.64,100.86)
N23058063: length 3.4
  BOTTOM w0.127: RG114.1 234.4,61.74 QG55.2 v2(235.79,63.12) 236.27,63.61 UG28.4
N23083473: length 7.5
  TOP w0.127: v3(282.16,14.2) 282.36,13.99 283.61,13.99 283.76,13.84 283.98,13.84 284.18,13.64 PR21.1 284.76,13.49 284.8,13.45 v2(286.16,13.45)
  BOTTOM w0.127: v2(286.16,13.45) 286.16,13.87 287.7,15.4 PJPB1.7
N23083645: length 5.9
  TOP w0.127: v3(283.72,10.68) 284.18,11.14 PR14.1 285.77,11.83 v2(286.73,12.79)
  BOTTOM w0.127: PJPB1.5 287.15,12.9 287.05,12.79 v2(286.73,12.79)
N23083647: length 6.1
  TOP w0.127: v2(285.56,14.31) 285.56,14.62 v3(285.35,14.83) 284.38,14.83 PR17.1
  BOTTOM w0.127: v2(285.56,14.31) 285.56,15.31 286.9,16.65 PJPB1.8
N23083649: length 4.7
  TOP w0.127: v2(286.15,12.84) 286.03,12.72 v3(285.34,12.72) PR15.1
  BOTTOM w0.127: PJPB1.6 287.46,14.15 v2(286.15,12.84)
N23332881: length 1.1
  TOP w0.127: PR18.2 v1(274.35,19.52)
N23332897: length 1.4
  TOP w0.127: 271.7,15.39 v1(271.7,14.03)
N23332925:
  vias: v1(276.28,10.58)
N23572335: length 5
  TOP w0.127: v1(168.36,124.66) PRZ37.2
  TOP w0.203: PRZ37.2 PCZ18.2 169.93,124.99 v2(170.26,124.99)
  BOTTOM w0.203: v2(170.26,124.99) 170.26,125.25 169.83,125.68 PUZ1.3
N23773631: length 1.8
  BOTTOM w0.127: UV2.35 30.07,59.48 30.17,59.58 RV19.1
N24329755: length 3.7
  BOTTOM w0.127: v1(37.53,12.8) 37.8,13.07 RR10.1 38.99,14.93 38.99,15.35 39.1,15.46 UR1.9
N24329881: length 2
  BOTTOM w0.203: UR1.28 44.29,17.06 44.67,17.43 45.03,17.43 RR11.1
N24337743: length 4.6
  TOP w0.127: v1(291.08,27.46) RA20.1 RA19.2 ; 291.8,27.46 292.44,26.82 CA29.1
  TOP w0.135: 291.8,27.46 v1(291.08,27.46)
N24338104: length 2
  TOP w0.127: v1(291.11,11.28) RA25.2
  TOP w0.381: QA2.2 290.15,12.15 RA25.2
N24626028: length 2.2
  TOP w0.127: CD82.2 139.1,29.42 v1(138.6,28.92)
  TOP w0.508: RD29.2 140,29.88 CD82.2
N24676202: length 3
  TOP w0.127: PRB01.2 267.1,37.11 v1(267.2,37.01)
  TOP w0.508: PRB01.2 PRB02.1 265.03,37.11 264.98,37.06 PQB02.2
N25261682: length 3.1
  TOP w0.127: QC11.5 182.49,14.69 182.94,14.25 RH252.1 184.89,14.25 v1(185.12,14.02)
N25355771: length 1.6
  TOP w0.254: R5798.1 178.15,45.05 v2(178.21,45.11) U9.2
N25359800: length 6.1
  TOP w0.127: QS1.6 18.3,81.05 18.19,81.16 18.19,81.62 18.08,81.73 CS108.1 18.47,82.73 18.53,82.73 RS39.1 19.08,82.62 19.33,82.37 v1(19.6,82.37) 20.02,82.37 20.33,82.07 US3.4
N25359816: length 2.7
  BOTTOM w0.127: US2.13 21.93,80.94 22.01,81.02 22.46,81.02 22.55,80.92 RS10.2 22.79,81.76 v1(22.55,82)
N25359920: length 3.5
  BOTTOM w0.127: US2.16 21.85,79.44 RS14.2 22.87,78.5 23.91,77.47 v1(24.02,77.47)
N25359932: length 1.7
  BOTTOM w0.127: RS13.2 22.48,79.39 21.93,79.94 US2.15
N25488166: length 2.6
  BOTTOM w0.127: v1(245.5,45.51) 245.09,45.51 244.48,44.91 CG335.1
  BOTTOM w0.203: CG335.1 244.42,44.78 244.42,43.61 UG27.12
N25488171: length 2.4
  BOTTOM w0.127: v1(243.48,46) 243.6,45.88 CG336.1
  BOTTOM w0.203: CG336.1 243.6,44.27 243.62,44.24 UG27.10
N25488216: length 3.6
  BOTTOM w0.127: QG17.6 237.19,39.06 237.3,38.95 238.07,38.95 238.33,39.21 RG391.1 238.76,39.52 238.95,39.34 v1(238.95,38.6)
N25528173: length 2.6
  BOTTOM w0.127: RG395.1 239.07,61.75 239.08,61.74 UG29.4 239.57,62.19 v2(239.41,62.35) 239.41,62.6 239.71,62.89 QG56.2
N25943161: length 3
  TOP w0.102: v1(132.36,89.66) 132.27,89.75 131,89.75 CD15.2
  TOP w0.508: RD11.2 CD15.2
N26573576: length 1.5
  TOP w0.127: RG404.2 199.92,78.98 v2(200.27,79.33)
  BOTTOM w0.254: UG1.AD6 200.68,79.74 v2(200.27,79.33)
N26746335: length 4.1
  TOP w0.127: v1(68.53,37.58) 68.53,36.57 67.77,35.81 R5807.2
  TOP w0.254: R5807.2 67.29,35.28 66.65,35.28 66.5,35.42 U12.3
N26747017: length 1.4
  TOP w0.508: R5804.1 65.49,39.81 65.55,39.75 U12.5
N26747180: length 2.3
  TOP w0.127: v1(67.43,40.21) R5806.1
  TOP w0.254: U12.4 66.5,38.84 R5806.1
N27182711: length 2.3
  TOP w0.127: PRZ42.2 169.23,136.49 v1(170.3,136.49)
  TOP w0.203: PCZ22.1 PRZ42.2
N27734948: length 2.8
  TOP w0.127: T165.1 46.76,38.12 47.31,38.12 47.49,38.3 47.49,38.71 46.74,39.46 UU4.21
N27734950: length 4.3
  TOP w0.127: T166.1 46.44,36.67 47.72,37.95 47.72,38.81 47.14,39.38 UU4.22
N27734952: length 3.2
  TOP w0.127: T167.1 47.55,37.42 47.95,37.81 47.95,38.9 47.54,39.3 UU4.23
N27734954: length 1.4
  TOP w0.127: T162.1 51.49,41.12 50.95,41.66 UU4.31
N27734984: length 2.6
  TOP w0.127: UU4.42 50.84,46.06 51.03,46.25 51.08,46.25 51.73,46.9 T155.1
N27734986: length 2.5
  TOP w0.127: T156.1 51.43,47.57 49.67,47.57 49.54,47.44 UU4.43
N27734988: length 4.8
  TOP w0.203: UU4.49 47.14,47.43 46.71,47.87 46.71,48.22 44.45,50.48 T158.1
N27734990: length 4.2
  TOP w0.203: UU4.48 47.54,47.46 47.02,47.99 47.02,48.4 45.74,49.68 T161.1
N27735020: length 1.4
  TOP w0.127: T154.1 51.38,46.11 50.92,45.66 UU4.41
N27735022: length 4.2
  TOP w0.127: T153.1 53.41,46.49 52.81,46.49 52.49,46.17 52.26,46.17 51.75,45.67 51.43,45.67 51.02,45.26 UU4.40
N27735038: length 3.5
  TOP w0.127: UU4.54 45.14,47.33 44.06,48.41 44.06,48.85 T159.1
N27735040: length 2.2
  TOP w0.127: T160.1 43.71,48.36 44.74,47.33 UU4.55
N27740851:
  vias: v1(45.08,41.43) v2(44.42,43.02) v2(44.42,41.98) v2(44.42,40.94) v2(45.72,43.02) v2(45.72,41.98) v2(45.72,40.94)
N27779968: length 8.8
  BOTTOM w0.127: JSSD1.10 33.6,2.5 34.19,3.1 34.19,3.58 34.38,3.77 35.66,3.77 36.24,3.19 38.19,3.19 D513.1 v1(40.37,2.56)
N27801570:
  vias: v1(45.06,45.46) v2(44.42,45.97) v2(44.42,44.91) v2(44.42,43.84) v2(45.72,45.97) v2(45.72,44.91) v2(45.72,43.84)
N28152235: length 3.7
  BOTTOM w0.127: v1(172.31,136.43) 172.57,136.17 PRZ33.1
  BOTTOM w0.203: PCZ15.2 PRZ32.2 173.26,135.41 PCZ14.2 173.31,136.09 PRZ33.1
N28152401: length 3.1
  BOTTOM w0.203: PUZ1.15 164.9,127.63 164.69,127.42 164.42,127.15 163.99,127.15 PCZ31.2 PRZ55.2
N28152465: length 4.8
  TOP w0.254: PRZ40.1 PCZ23.1 171,133.28 v1(170.53,133.75) v2(169.83,133.75)
  BOTTOM w0.203: PUZ1.36 169.43,133.12 169.83,133.52 v2(169.83,133.75)
N28152469: length 1.8
  BOTTOM w0.203: PRZ57.1 v2(164.08,131.34)
  BOTTOM w0.254: PUZ1.24 164.19,131.23 v2(164.08,131.34)
N28152784: length 5.3
  TOP w0.127: v1(163.99,126.02) 164.66,126.69 164.91,126.69 165.24,127.02
  TOP w0.254: 165.24,127.02 165.1,127.16 PCZ33.1 164.72,128.2 v2(164.17,127.65)
  BOTTOM w0.203: v2(164.17,127.65) 164.29,127.77 164.56,127.77 164.82,128.03 PUZ1.16
N28152958: length 83.5
  IN1 w0.254: v2(118.37,104.74) 118.56,104.55 118.92,104.55 119.2,104.83 119.2,110.39 121.36,112.55 121.65,112.55 126.35,117.24 126.35,121.21 122.82,124.73 122.82,133.1 124.97,135.26 131.22,135.26 131.88,134.6 133.77,134.6 134.43,135.26 138.12,135.26 138.57,134.8 141.35,134.8 141.92,135.38 145.98,135.38 146.65,134.7 148.54,134.7 149.14,135.31 155.55,135.31 156.69,136.44 162.76,136.44 163.91,135.29 165.62,135.29 v2(166.63,136.29)
  BOTTOM w0.254: v2(166.63,136.29) 166.72,136.2 PRZ50.1 PRZ46.2 ; PHZ1.2 v2(118.37,104.74)
N28153073: length 26.8
  IN1 w0.254: v2(176.66,129.3) 176.83,129.3 177.76,128.37 177.76,127.69 177.4,127.33 176.77,127.33 175.22,125.78 174.78,125.78 174.59,125.59 167.48,125.59 165.95,124.06 165.95,122.72 164.25,121.02 162.29,121.02 161.55,120.28 161.55,119.15 v2(161.7,119)
  BOTTOM w0.127: PHZ2.2 163.19,118.06 v1(163.48,117.76)
  BOTTOM w0.254: PRZ2.1 176.56,129.2 v2(176.66,129.3) ; v2(161.7,119) 161.7,118.74 PHZ2.2
N28153589: length 2.9
  BOTTOM w0.203: PUZ1.43 172.29,130.83 172.61,130.5 173.63,130.5 PRZ26.1
N28153954: length 1.9
  TOP w0.127: PCZ19.1 171.53,121.24 v1(171.26,120.98)
  TOP w0.203: PRZ38.2 PCZ19.1
N28154016: length 3.7
  BOTTOM w0.127: PCZ13.1 173.69,122.45 v1(174.1,122.04)
  BOTTOM w0.254: PCZ12.1 174.58,123.04 PRZ27.2 174.2,122.96 174.15,123.01 PCZ13.1 PRZ28.1
N28154283: length 20.7
  TOP w0.127: v1(169.52,119.9) 170.21,120.58 PRZ49.1
  TOP w0.203: v2(170.34,121.64) 170.21,121.51 PRZ49.1
  IN1 w0.203: v2(157.05,115.12) 157.05,116.1 157.38,116.43 166.4,116.43 169.9,119.92 169.9,121.2 v2(170.34,121.64)
  BOTTOM w0.203: PRZ45.2 v2(170.34,121.64)
  BOTTOM w0.254: v2(157.05,115.12) 157.03,115.14 PHZ3.2
N28180064: length 0.8
  TOP w0.203: PCZ10.1 170.93,125.68 PRZ22.2
N28185893: length 2
  BOTTOM w0.127: v1(169.47,136.4) 169.83,136.04 PCZ20.1
  BOTTOM w0.203: PCZ20.1 170.59,135.41 PRZ39.2
N28185971: length 1.9
  BOTTOM w0.127: v1(171.15,120.33) PRZ35.2
  BOTTOM w0.203: PRZ35.2 PCZ17.1
N28452300: length 3.6
  BOTTOM w0.127: v1(179.11,119.61) 179.11,120.95 178.64,121.42 RV135.1 178.73,121.6 UC3.4
N28452491: length 2.5
  BOTTOM w0.127: v1(180.47,128.83) 179.63,128.83 RV136.2 179.38,128.58 UC3.6
N28587479: length 3.9
  TOP w0.127: UA1.5 294.42,17.69 RA55.1 295.51,16.62 295.93,16.2 295.93,15.67 v1(296.44,15.16)
N28622063: length 3.9
  TOP w0.127: v1(111.35,21.83) 111.71,22.2 D517.2
  TOP w0.254: D517.2 111.54,23.01 110.25,23.01 109.88,22.64 U4019.3
N28622074: length 2.6
  TOP w0.254: R125.1 109.22,26.95 109.57,26.6 109.57,25.89 109.88,25.58 U4019.6
N28622080: length 9.2
  TOP w0.127: Q32.1 107.02,24.04 105.51,25.54 104.41,25.54 v1(104.38,25.57)
  TOP w0.254: Q32.1 107.56,23.11 107.87,23.42 108.77,23.42 109.38,24.03 U4019.7 109.38,25.47 109.03,25.82 R13.1
N28622090: length 2.4
  TOP w0.127: v1(108.37,20.72) R124.1
  TOP w0.254: R124.1 109.44,21.35 109.38,21.41 U4019.2
N28781721: length 3
  BOTTOM w0.127: v1(232.31,39.79) 232.44,39.66 QG16.1
  BOTTOM w0.254: QG16.1 234.06,40.63 RG40.2
N29132963: length 4.9
  BOTTOM w0.127: v1(32.85,60.13) 32.85,59.76 32.71,59.62 RV18.1 32.23,59.11 32.22,59.11 31.96,59.11 31.94,59.08 31.37,59.08 31.35,59.11 29.87,59.11 29.84,59.08 UV2.36
N29227301: length 2.2
  TOP w0.127: v1(175.46,123.94) 174.6,124.79 PRZ16.2
  TOP w0.203: PRZ16.2 174.38,124.86 PCZ7.1
N29270156: length 6.2
  BOTTOM w0.127: v1(237.71,59.05) 237.71,58.82 236.92,58.04 RG407.2 236.61,57.68 236.75,57.54 236.75,57.17 236.42,56.84 235.48,56.84 RG14.2 234.95,56.32 CG2818.1 234.95,54.89 UG2.5
N29645650: length 1.7
  TOP w0.135: RA56.2 294.59,17.07 294.02,17.64 UA1.4
N29662755: length 2.7
  TOP w0.127: QC10.6 207.77,8.04 207.66,7.93 RH261.1 207.66,7.41 207.94,7.14 207.94,6.07 v1(208.02,5.99)
N29662764: length 3.3
  TOP w0.127: RH262.1 210.19,6.98 210.19,7.76 210.46,8.02 v1(210.46,8.05) 210.46,8.99 QC10.3
N29905583: length 4.4
  TOP w0.127: RWL5.1 311.32,12.43 v1(311.59,12.7) ; v2(309.11,12.89) 309.57,12.43 309.97,12.43
  TOP w0.135: 309.97,12.43 RWL5.1
  BOTTOM w0.127: JWLAN1.42 309.36,12.35 309.11,12.6 v2(309.11,12.89)
N30629862: length 2.3
  TOP w0.127: RH272.1 205.69,18.9 v2(204.65,19.94)
  BOTTOM w0.127: UH1.BD21 204.32,19.51 204.65,19.84 v2(204.65,19.94)
N31026763: length 2.2
  BOTTOM w0.127: QG57.1 226.33,42.12 226.46,42.25 RG3019.2
N31140794: length 3.3
  TOP w0.127: v1(252.72,43.32) CC392.1
  TOP w0.203: CC392.1 253.91,42.13 UC4.12
N41203729: length 1.7
  TOP w0.203: UC4.10 254.71,42.22 CC393.1
N52218840: length 4.3
  BOTTOM w0.127: PRZ47.2 164.29,134.38 163.59,135.07 v1(163.31,135.07)
  BOTTOM w0.203: PRZ47.2 164.55,134.06 164.55,132.87 164.81,132.6 PUZ1.27
N64766033: length 4.9
  BOTTOM w0.254: RV11.2 32.02,57.8 31.76,58.06 30.26,58.06 30.01,58.3 v1(29.98,58.3) 29.96,58.32 29.96,58.35 29.77,58.55 29.01,58.55 28.37,57.91 28.19,57.91 28.06,58.03 UV2.37
N65230032: length 3.3
  TOP w0.127: RV33.1 22.1,55.34 22.6,54.85 v1(22.6,54.37)
  TOP w0.254: RV31.2 22.07,55.89 22.1,55.85 RV33.1 22.67,55.45 22.7,55.48 UV3.6
N80922351: length 1.2
  BOTTOM w0.127: 172.22,100.76 v1(171.38,99.92)
N80922387: length 2
  BOTTOM w0.127: v1(174.03,97.28) 174.8,98.05 PCF6.1
  BOTTOM w0.508: PRF3.2 PCF6.1
N99531586: length 7.1
  TOP w0.127: v3(200.64,10.09) 200.11,9.56 v2(200.11,9.21)
  TOP w0.135: R5238.2 v2(200.11,9.21)
  BOTTOM w0.135: v2(200.11,9.21) 201.01,10.11 202.24,10.11 203.35,11.22 JKB1.29
N99531588: length 7.3
  TOP w0.127: v3(198.95,10.06) 199.22,9.79 v2(199.22,9.21)
  TOP w0.135: R5237.2 v2(199.22,9.21)
  BOTTOM w0.135: v2(199.22,9.21) 200.5,10.49 202.24,10.49 202.5,10.75 202.5,11.72 202.35,11.88 JKB1.28
N100118189: length 15
  BOTTOM w0.508: v2(39.59,35) 39.59,35.69 39.03,36.26 36.64,36.26 35.73,37.17 35.73,38.26 35.95,38.48 36.76,38.48 37.19,38.91 37.19,39.63 38.68,41.12 DL1.3 39.37,40.84 39.37,40.55 40.98,38.95 CL2.2
  vias: v1(38.83,33.86)
N108444806: length 2.2
  TOP w0.203: C404.1 263.82,42.5 v1(264.6,43.28) U10.10
N108444906: length 2.2
  TOP w0.203: C403.1 264.74,42.48 v2(264.86,42.48) U10.12
N113120205: length 17.7
  BOTTOM w0.109: 209.97,75.28 209.86,75.39 208.84,75.39 208.63,75.6 208.63,76.09 UG1.R2
  BOTTOM w0.127: 209.97,75.28 210.33,74.93 210.5,74.93 211.69,73.74 211.69,73.57 213.72,71.54 215.28,71.54 v1(215.79,71.03) 217.61,69.21 217.61,68.49 217.98,68.13 217.98,67.94 218.47,67.45 218.47,66.15 219.44,65.18 RG5.1
N113120207: length 17.6
  BOTTOM w0.109: UG1.R3 208.63,76.89 208.63,76.4 208.88,76.15 209.39,76.15
  BOTTOM w0.127: RG6.1 219.29,65.97 218.73,66.53 218.73,67.56 218.24,68.05 218.24,68.23 217.87,68.6 217.87,69.47 215.54,71.8 214.87,71.8 214.72,71.95 v1(214.53,71.95) 213.63,71.95 211.92,73.66 211.92,73.83 210.59,75.16 210.42,75.16 209.43,76.15 209.39,76.15
N113204452: length 3.4
  BOTTOM w0.127: UG4.J1 213.43,127.8 213.19,128.04 RG59.1 v1(210.53,128.04)
N113204609: length 9.6
  TOP w0.127: v2(224.74,127.01) 224.74,127.43 223.57,128.6 221.27,128.6 v2(220.3,127.63)
  BOTTOM w0.127: RG57.1 226.44,127.04 225.95,127.04 225.81,127.18 224.91,127.18 v2(224.74,127.01)
  BOTTOM w0.254: UG4.J10 220.5,127.8 220.46,127.76 220.41,127.76 220.36,127.71 220.36,127.69 v2(220.3,127.63)
N113204711: length 10.3
  TOP w0.127: v1(191.52,134.73) 191.43,134.64 v2(191.02,134.64)
  TOP w0.381: RG60.1 v2(191.02,134.64)
  BOTTOM w0.305: v2(191.02,134.64) 191.84,133.82 191.84,127.71 191.54,127.4 190.75,127.4 UG5.J10
N113205003: length 4.3
  BOTTOM w0.127: v1(201.52,127.05) RG55.2 200.23,127.33 198.51,127.33 198.04,127.8 UG5.J1
N113272266: length 10.3
  BOTTOM w0.127: UG6.J10 241.02,73.1 235.12,73.1 234.74,72.72 RG73.1 v1(233.1,73.73)
N113272493: length 3.5
  BOTTOM w0.127: v1(242.18,82.88) RG75.1 241.84,81.56 UG6.J1
N113273868: length 10.9
  BOTTOM w0.127: v1(233.24,97.32) RG71.1 234.19,98.38 234.64,98.83 241.42,98.83 241.84,99.25 UG7.J10
N113274261: length 3.5
  BOTTOM w0.127: RG69.2 241.84,90.37 v1(241.84,90.65) UG7.J1
N121190088: length 20.5
  TOP w0.127: RG86.1 218.06,66.64 v2(217.94,66.76)
  IN3 w0.127: v2(208.59,80.23) 208.14,79.79 208.14,79.28 207.87,79.02 207.59,79.02 207.38,78.8 207.38,77.12 212.65,71.84 213.92,71.84 217.47,68.29 217.47,67.23 v2(217.94,66.76)
  BOTTOM w0.109: v2(208.59,80.23) UG1.R7
N121190090: length 18.2
  TOP w0.127: v2(217.94,67.38) 217.99,67.44 RG85.1
  IN3 w0.127: v2(208.62,79.4) 208.2,78.98 208.2,76.67 212.76,72.11 214.03,72.11 217.74,68.4 217.74,67.58 v2(217.94,67.38)
  BOTTOM w0.127: v2(208.62,79.4) 208.57,79.4 UG1.R6
N121269248: length 2.7
  BOTTOM w0.127: RG95.2 RG63.2 221.78,114.82 CG190.1 220.92,113.86 v1(220.9,113.84)
N121271262: length 2.9
  BOTTOM w0.127: v1(186.67,116.01) CG191.1 188.44,115.4 RG62.2 RG96.2
N121271857: length 2.8
  BOTTOM w0.127: v1(231.08,99.63) CG192.1 231.53,100.65 231.56,100.62 RG97.2 RG98.2
N121272457: length 2.7
  BOTTOM w0.127: RG76.2 RG77.2 231.18,71.58 231.2,71.55 CG193.1 v1(231.2,70)
N121863790: length 4.4
  TOP w0.127: QG8.6 234.98,53.9 234.98,53.75 235.19,53.53 235.53,53.53 QG8.5 235.97,53.97 236.5,53.97 236.77,53.71 237.01,53.71 v1(237.28,53.44) 237.28,53.04 RG111.2
N125363899: length 17.7
  BOTTOM w0.127: RG381.2 187.94,78.19 v1(189.17,78.19) 189.46,78.19 189.61,78.34 190.78,78.34 191.36,77.77 194.97,77.77 195.17,77.97 195.17,80.96 195.38,81.17 195.81,81.17 196,81.37 196,81.72 196.21,81.93 196.76,81.93 196.88,82.06 196.88,82.51 197.12,82.74 198.31,82.74 198.74,82.31 198.77,82.31 198.98,82.11 UG1.AF8
