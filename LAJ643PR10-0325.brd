# Allegro board LAJ643PR10-0325.brd (continued)
## Nets (continued)
+PD_CC1: CU67.1 DU3.1 DU3.10 JUSBC1.A5 UU4.24
+PD_CC2: CU66.1 DU3.2 DU3.9 JUSBC1.B5 UU4.26
+RTCBATT_R: DH1.2 RH92.1
+USB_VCC2: CS8.1 CS9.1 CS109.1 JUSB3.1 US2.12
+V_DAC: CL1.2 CL4.1 TSL1.1 TSL1.4 TSL1.7 TSL1.10
+VGA_CORE: PCV29.1 PCV30.1 PCV31.1 PCV32.1 PCV33.1 PCV34.1 PCV35.1 PCV36.1 PCV37.1 PCV38.1 PCV39.1 PCV40.1 PCV41.1 PCV42.1 PCV43.1 PCV44.1 PCV45.1 PCV46.1 PCV47.1 PCV48.1 PCV49.1 PCV50.1 PCV51.1 PCV52.1 PCV53.1 PCV54.1 PCV55.1 PCV56.1 PCV57.1 PCV58.1 PCV59.1 PCV60.1 PCV61.1 PCV62.1 PCV63.1 PCV64.1 PCV65.1 PCV66.1 PCV67.1 PCV68.1 PCV69.1 PCV70.1 PCV71.1 PCV72.1 PCV73.1 PCV74.1 PCV75.1 PCV76.1 PCV77.1 PCV78.1 PCV79.1 PCV80.1 PCV81.1 PCV82.1 PCV83.1 PCV84.1 PCV85.1 PCV86.1 PCV87.1 PCV88.1 PCV89.1 PCV90.1 PCV91.1 PLV1.3 PLV1.4 PLV2.3 PLV2.4 PLV3.3 PLV3.4 PRV22.1 RG40.1 UG1.AA1 UG1.AA2 UG1.AA3 UG1.AA4 UG1.AA5 UG1.AA6 UG1.AA7 UG1.AA8 UG1.AA12 UG1.AA14 UG1.AA16 UG1.AA19 UG1.AA21 UG1.AA23 UG1.AB13 UG1.AB15 UG1.AB17 UG1.AB18 UG1.AB20 UG1.AB22 UG1.AC12 UG1.AC14 UG1.AC16 UG1.AC19 UG1.AC21 UG1.AC23 UG1.M12 UG1.M14 UG1.M16 UG1.M19 UG1.M21 UG1.M23 UG1.N13 UG1.N15 UG1.N17 UG1.N18 UG1.N20 UG1.N22 UG1.P12 UG1.P14 UG1.P16 UG1.P19 UG1.P21 UG1.P23 UG1.R13 UG1.R15 UG1.R17 UG1.R18 UG1.R20 UG1.R22 UG1.T12 UG1.T14 UG1.T16 UG1.T19 UG1.T21 UG1.T23 UG1.U4 UG1.U5 UG1.U6 UG1.U7 UG1.U8 UG1.U13 UG1.U15 UG1.U17 UG1.U18 UG1.U20 UG1.U22 UG1.V1 UG1.V2 UG1.V3 UG1.V4 UG1.V5 UG1.V6 UG1.V7 UG1.V8 UG1.V13 UG1.V15 UG1.V17 UG1.V18 UG1.V20 UG1.V22 UG1.W2 UG1.W3 UG1.W4 UG1.W5 UG1.W7 UG1.W8 UG1.W12 UG1.W14 UG1.W16 UG1.W19 UG1.W21 UG1.W23 UG1.Y1 UG1.Y2 UG1.Y3 UG1.Y4 UG1.Y5 UG1.Y6 UG1.Y7 UG1.Y8 UG1.Y13 UG1.Y15 UG1.Y17 UG1.Y18 UG1.Y20 UG1.Y22
+VIO: CR17.1 UR1.18
AC_LED#: PR1.1 PR2.1 UK1.34
AC_PRESENT: RH46.2 UK1.93
AC_PRESENT_R: RH45.1 RH46.1 UH1.BG42
ACCEL_INT#: D516.2 RH181.1 UH1.BF35
ACCEL_INT#_R: D516.1 U9.12
ACDRV: PRB07.2 PUB01.30
ACDRV_R: PCB01.2 PCB02.2 PQB01.4 PQB02.1 PQB03.4 PRB07.1
ACIN_BUF: DG2.2 RG393.2 RG399.2 UG1.N3
ACIN_LED: PD2.3 PJP1.5 PR1.2
ACLIM: PRB27.1 PRB29.1 PUB01.16
ACPVEE: CA23.2 UA1.25
ADP_I: PCB32.1 PRB40.1 UK1.65
ADP_I_R: PRB40.2 PUB01.6
ADP_ID: PC5.1 PC6.1 PD3.1 PR3.2 PR5.1 UK1.75
ADP_SIGNAL: PD1.3 PJP1.6 PR3.1
ALL_GPWRGD: QG1.2 RG83.1 UG11.4
AMIC2_CAP: CA5.2 UA1.32
B/I#: PR16.2 PR17.2 PUB01.13 UK1.63
BAT_CHG_LED: PR4.1 PR6.1 UK1.90
BAT_GATE: PCB12.1 PQB04.4 PUB01.25
BOARD_ID: RK2.1 RK4.2 UK1.66
BST_1.35VSDGPUP: PRW2.1 PUW1.10
BST_1V05: PR1009.1 PU1001.1
BST_1V05_R: PC1002.1 PR1009.2
BST_3V: PR301.1 PU301.1
BST_3V_R: PC302.1 PR301.2
BST_5V: PR305.1 PU302.13
BST_5V_R: PC313.1 PR305.2
BST_CHG: PRB13.1 PUB01.24
BST_CHG_R: PCB17.1 PDB03.1 PRB13.2
BST_DDR: PRM1.2 PUM1.18
BST_DDR_R: PCM4.1 PRM1.1
BST_GT: PRG1.1 PUG1.1
BST_GT_R: PCG5.1 PRG1.2
BST_PH1: PRZ79.1 PUZ2.1
BST_PH1_R: PCZ46.1 PRZ79.2
BST_PH2: PRZ82.1 PUZ3.1
BST_PH2_R: PCZ52.1 PRZ82.2
BST_PH3: PRZ85.1 PUZ4.1
BST_PH3_R: PCZ59.1 PRZ85.2
BST_PH4: PRZ88.1 PUZ5.1
BST_PH4_R: PCZ66.1 PRZ88.2
BST_VCCIOP: PRH3.1 PUH1.1
BST_VCCIOP_R: PCH4.1 PRH3.2
BST_VCCSA: PRA1.1 PUA1.1
BST_VCCSA_R: PCA5.1 PRA1.2
BT_ON: JWLAN1.46 RH179.2 RH271.1 RH272.2
BT_ON_R: RH271.2 UH1.BF32
CAP_LOCK#: C390.1 R5237.1 UK1.91
CATERR#: TC96.1(TP-1) UC1.BM30
CBN: CA26.1 CA98.1 UA1.24
CBP: CA26.2 CA98.2 UA1.23
CFG0: RC31.1 UC1.BN25
CFG2: RC32.1 UC1.BN26
CFG4: RC33.1 UC1.BR20
CFG5: RC36.1 UC1.BM20
CFG6: RC34.1 UC1.BT20
CFG7: RC35.1 UC1.BP20
CFG_RCOMP: RC19.1 UC1.BT25
CHARGE_LED: PD2.2 PJP1.8 PR4.2
CHG_ACIN: PCB16.1 PRB10.2 PRB12.1 PUB01.1
CHG_CCLIM: PRB28.2 PRB30.1 PUB01.11
CHG_COMP: PCB26.1 PRB31.1 PUB01.10
CHG_COMP_R: PCB27.1 PRB31.2
CHG_DCIN: PCB14.1 PCB36.1 PRB11.1 PUB01.18
CHG_DCIN_R: PDB01.1 PRB11.2
CHG_FSET: PRB34.1 PUB01.12
CHG_NTC: PRB18.1 PUB01.17
CHG_NTC_R: PRB18.2 PRB19.1
CHG_PHASE: PCB17.2 PLB02.1 PQB05.9 PRB21.1 PUB01.22
CHG_PROCHOT: PDB02.1 PRB44.2 PUB01.5
CHG_PROG: PRB35.1 PUB01.9
CHG_SRN: PCB22.2 PCB23.1 PRB22.1 PUB01.14
CHG_SRP: PCB22.1 PCB24.1 PRB20.1 PUB01.15
CHG_VDD: PCB30.1 PRB23.1 PRB27.2 PRB28.1 PRB37.1 PUB01.19
CHG_VDDP: PCB29.1 PCB35.1 PDB03.2 PRB37.2 PUB01.20
CL_CLK: TH55.1(TP-1) UH1.AR2
CL_DATA: TH56.1(TP-1) UH1.AT5
CL_RST#: TH57.1(TP-1) UH1.AU4
CLK_CNV_PRX_DTX_N: JWLAN1.21 UH1.BD4
CLK_CNV_PRX_DTX_P: JWLAN1.23 UH1.BE3
CLK_CNV_PTX_DRX_N: JWLAN1.63 UH1.BC5
CLK_CNV_PTX_DRX_P: JWLAN1.65 UH1.BB6
CLK_PCI_LPC: RH27.2 UK1.12
CLK_PCIE_N1: JWLAN1.41 UH1.AH9
CLK_PCIE_N2: JSSD1.53 UH1.AE14
CLK_PCIE_N3: UH1.AE6 UR1.6
CLK_PCIE_N5: UH1.AB2 UL1.16
CLK_PCIE_P1: JWLAN1.39 UH1.AH10
CLK_PCIE_P2: JSSD1.55 UH1.AE15
CLK_PCIE_P3: UH1.AE7 UR1.5
CLK_PCIE_P5: UH1.AB3 UL1.15
CLK_PEG_N4: UG1.AK13 UH1.AC2
CLK_PEG_P4: UG1.AL13 UH1.AC3
CLKOUT_LPC0: CH70.1 RH27.1 UH1.BB36
CLKOUT_LPC1: TH4973.1(TP-1) UH1.BB34
CLKREQ_PCIE#1: JWLAN1.45 RH206.2 UH1.BE31
CLKREQ_PCIE#2: JSSD1.52 RH207.2 UH1.AR32
CLKREQ_PCIE#3: RH208.2 UH1.BB30 UR1.2
CLKREQ_PCIE#5: RH205.2 RL6.2 UH1.AN29
CLKREQ_PCIE#5_R: RL6.1 UL1.12
CLKREQ_PEG#4: QG1.6 RH209.2 UH1.BA30
CMSRC: PRB04.2 PUB01.29
CNV_BRI_PRX_DTX: RWL13.2 RWL18.1 UH1.AY2
CNV_BRI_PRX_DTX_R: JWLAN1.22 RWL18.2 RWL32.2
CNV_BRI_PTX_DRX: RH26.2 RWL22.1 UH1.AV4
CNV_BRI_PTX_DRX_R: JWLAN1.28 RWL22.2
CNV_CLKREQ: JWLAN1.14 RWL2.1 UH1.BA17
CNV_PRX_DTX_N0: JWLAN1.15 UH1.BB3
CNV_PRX_DTX_N1: JWLAN1.9 UH1.BA3
CNV_PRX_DTX_P0: JWLAN1.17 UH1.BB4
CNV_PRX_DTX_P1: JWLAN1.11 UH1.BA2
CNV_PTX_DRX_N0: JWLAN1.57 UH1.BE6
CNV_PTX_DRX_N1: JWLAN1.51 UH1.BG6
CNV_PTX_DRX_P0: JWLAN1.59 UH1.BD7
CNV_PTX_DRX_P1: JWLAN1.53 UH1.BF6
CNV_RF_RESET#: JWLAN1.10 RWL1.1 UH1.BE16
CNV_RGI_PRX_DTX: RWL12.2 RWL21.1 UH1.AV3
CNV_RGI_PRX_DTX_R: JWLAN1.26 RWL21.2
CNV_RGI_PTX_DRX: RH167.1 RH168.1 RWL20.1 UH1.BA4
CNV_RGI_PTX_DRX_R: JWLAN1.24 RWL20.2 RWL33.2
CNV_WT_RCOMP: RH25.1 UH1.BA1
COMP_1PH: PCZ10.2 PCZ11.2 PUZ1.50
COMP_2PH: PCZ21.2 PCZ22.2 PUZ1.33
COMP_4PH: PCZ16.1 PRZ38.1 PUZ1.6
CPU_C10_GATE#: TH135.1(TP-1) UH1.AY3
CPU_DISPA_BCLK: RH29.2 UH1.AM3
CPU_DISPA_BCLK_R: RH29.1 UC1.G27
CPU_DISPA_SDI: RC2.2 UC1.G29
CPU_DISPA_SDI_R: RC2.1 UH1.AN3
CPU_DISPA_SDO: RH28.2 UH1.AM2
CPU_DISPA_SDO_R: RH28.1 UC1.G25
CPU_GPIOB21: RH153.2 RH154.2 UH1.BD30
CPU_SVID_ALERT#: RC39.2 UC1.BH31
CPU_SVID_ALERT#_R: PRZ7.2 PRZ19.2 RC39.1 RC40.2
CPU_SVID_CLK: CC155.1 RC37.2 UC1.BH32
CPU_SVID_CLK_R: PRZ8.2 PRZ17.2 RC37.1
CPU_SVID_DAT: RC38.2 UC1.BH29
CPU_SVID_DAT_R: PRZ6.1 PRZ21.2 RC38.1 RC41.1
CPU_TRIGOUT: RC8.2 UC1.J23
CPU_TRIGOUT_R: RC8.1 UH1.AK2
CPU_XDP_TCK0: RC390.1 UC1.BR28 UH1.AH4
CPU_XDP_TDI: RC381.1 UC1.BL32 UH1.AH2
CPU_XDP_TDO: RC384.1 UC1.BT28 UH1.AH3
CPU_XDP_TMS: RC380.1 UC1.BP28 UH1.AJ4
CPU_XDP_TRST#: RC392.1 UC1.BP30 UH1.AM4
CR_WAKE#: QR2.3 RR3.2 RR12.2 RR15.1
CR_WAKE#_R: RR3.1 UR1.32
CS_DDR: PRM2.2 PUM1.13
CSCL: RV14.2 TPV1.1(TP-1) UV2.29
CSCOMP_2PH: PCZ27.1 PCZ28.1 PHZ1.1 PRZ44.2 PRZ46.1 PUZ1.31
CSCOMP_4PH: PCZ24.1 PCZ25.2 PHZ3.1 PRZ43.1 PRZ45.1 PUZ1.8
CSDA: RV16.2 TPV2.1(TP-1) UV2.28
CSIN: PCB04.2 PCB05.1 PRB39.2 PUB01.31
CSIN_R: PRB03.3 PRB39.1
CSIP: PCB03.2 PCB04.1 PRB38.2 PUB01.32
CSIP_R: PRB03.2 PRB38.1
CSN_1PH: PHZ2.1 PLA1.3 PRZ4.1
CSN_1PH_R: PCZ2.1 PCZ5.1 PCZ8.1 PRZ4.2 PUZ1.48
CSP1_2PH: PCZ35.2 PRZ66.1 PUZ1.28
CSP1_4PH: PCZ34.2 PRZ59.2 PRZ60.2 PUZ1.11
CSP2_4PH: PCZ36.2 PRZ67.2 PRZ69.2 PUZ1.12
CSP3_4PH: PCZ37.2 PRZ70.2 PRZ71.2 PUZ1.13
CSP4_4PH: PCZ38.2 PRZ72.2 PRZ73.2 PRZ76.2 PUZ1.26
CSP_1PH: PCZ2.2 PCZ5.2 PRZ2.2 PRZ3.1 PUZ1.47
CSREF_2PH: PCZ29.1 PCZ35.1 PRG3.2 PUZ1.29
CSREF_4PH: PCZ26.2 PCZ34.1 PCZ36.1 PCZ37.1 PCZ38.1 PRZ60.1 PRZ69.1 PRZ71.1 PRZ76.1 PRZ81.2 PRZ84.2 PRZ87.2 PRZ90.2 PUZ1.10
CSSUM_2PH: PCZ27.2 PCZ28.2 PRZ50.2 PRZ52.1 PUZ1.30
CSSUM_4PH: PCZ24.2 PCZ25.1 PRZ48.2 PRZ49.2 PRZ51.2 PRZ53.2 PRZ54.2 PUZ1.9
D_MIC_CLK: D506.3 JEDP1.6 RV58.2 RV59.2
D_MIC_CLK_CODEC: RA55.2 RV59.1
D_MIC_CLK_CPU: RH253.1 UH1.BD16
D_MIC_CLK_R: CH107.1 RH253.2 RV58.1
D_MIC_DATA: D506.2 JEDP1.7 RV60.2 RV61.2
D_MIC_DATA_CODEC: RA56.1 RV61.1
D_MIC_DATA_CPU: RH254.1 UH1.BF15
D_MIC_DATA_R: RH254.2 RV60.1
DCC_EN_HDMI: RV24.2 UV2.3
DCHG_I: PCB31.1 PRB41.1 UK1.73
DCHG_I_R: PRB41.2 PUB01.7
DDR_DRAMRST#_R: CD10.2 JDIMM1.108 JDIMM2.108 RH40.2
DDR_M0_ACT#: JDIMM1.114 UC1.AU3
DDR_M0_ALERT#: JDIMM1.116 UC1.AU5
DDR_M0_BA0: JDIMM1.150 UC1.AH5
DDR_M0_BA1: JDIMM1.145 UC1.AH1
DDR_M0_BG0: JDIMM1.115 UC1.AU1
DDR_M0_BG1: JDIMM1.113 UC1.AU2
DDR_M0_CKE0: JDIMM1.109 UC1.AT1
DDR_M0_CKE1: JDIMM1.110 UC1.AT2
DDR_M0_CLK0: JDIMM1.137 UC1.AG1
DDR_M0_CLK1: JDIMM1.138 UC1.AK2
DDR_M0_CLK#0: JDIMM1.139 UC1.AG2
DDR_M0_CLK#1: JDIMM1.140 UC1.AK1
DDR_M0_CS#0: JDIMM1.149 UC1.AD5
DDR_M0_CS#1: JDIMM1.157 UC1.AE2
DDR_M0_D0: JDIMM1.7 UC1.BR6
DDR_M0_D1: JDIMM1.4 UC1.BT6
DDR_M0_D2: JDIMM1.20 UC1.BP3
DDR_M0_D3: JDIMM1.21 UC1.BR3
DDR_M0_D4: JDIMM1.3 UC1.BN5
DDR_M0_D5: JDIMM1.8 UC1.BP6
DDR_M0_D6: JDIMM1.16 UC1.BP2
DDR_M0_D7: JDIMM1.17 UC1.BN3
DDR_M0_D8: JDIMM1.28 UC1.BL4
DDR_M0_D9: JDIMM1.24 UC1.BL5
DDR_M0_D10: JDIMM1.38 UC1.BL2
DDR_M0_D11: JDIMM1.42 UC1.BM1
DDR_M0_D12: JDIMM1.29 UC1.BK4
DDR_M0_D13: JDIMM1.25 UC1.BK5
DDR_M0_D14: JDIMM1.41 UC1.BK1
DDR_M0_D15: JDIMM1.37 UC1.BK2
DDR_M0_D16: JDIMM1.46 UC1.BG4
DDR_M0_D17: JDIMM1.50 UC1.BG5
DDR_M0_D18: JDIMM1.63 UC1.BF4
DDR_M0_D19: JDIMM1.58 UC1.BF5
DDR_M0_D20: JDIMM1.49 UC1.BG2
DDR_M0_D21: JDIMM1.45 UC1.BG1
DDR_M0_D22: JDIMM1.59 UC1.BF1
DDR_M0_D23: JDIMM1.62 UC1.BF2
DDR_M0_D24: JDIMM1.66 UC1.BD2
DDR_M0_D25: JDIMM1.70 UC1.BD1
DDR_M0_D26: JDIMM1.80 UC1.BC4
DDR_M0_D27: JDIMM1.79 UC1.BC5
DDR_M0_D28: JDIMM1.71 UC1.BD5
DDR_M0_D29: JDIMM1.67 UC1.BD4
DDR_M0_D30: JDIMM1.83 UC1.BC1
DDR_M0_D31: JDIMM1.84 UC1.BC2
DDR_M0_D32: JDIMM1.174 UC1.AB1
DDR_M0_D33: JDIMM1.169 UC1.AB2
DDR_M0_D34: JDIMM1.183 UC1.AA4
DDR_M0_D35: JDIMM1.187 UC1.AA5
DDR_M0_D36: JDIMM1.170 UC1.AB5
DDR_M0_D37: JDIMM1.173 UC1.AB4
DDR_M0_D38: JDIMM1.182 UC1.AA2
DDR_M0_D39: JDIMM1.186 UC1.AA1
DDR_M0_D40: JDIMM1.190 UC1.V5
DDR_M0_D41: JDIMM1.191 UC1.V2
DDR_M0_D42: JDIMM1.207 UC1.U1
DDR_M0_D43: JDIMM1.208 UC1.U2
DDR_M0_D44: JDIMM1.195 UC1.V1
DDR_M0_D45: JDIMM1.194 UC1.V4
DDR_M0_D46: JDIMM1.203 UC1.U5
DDR_M0_D47: JDIMM1.204 UC1.U4
DDR_M0_D48: JDIMM1.216 UC1.R2
DDR_M0_D49: JDIMM1.212 UC1.P5
DDR_M0_D50: JDIMM1.215 UC1.R4
DDR_M0_D51: JDIMM1.225 UC1.P4
DDR_M0_D52: JDIMM1.211 UC1.R5
DDR_M0_D53: JDIMM1.228 UC1.P2
DDR_M0_D54: JDIMM1.224 UC1.R1
DDR_M0_D55: JDIMM1.229 UC1.P1
DDR_M0_D56: JDIMM1.232 UC1.M4
DDR_M0_D57: JDIMM1.236 UC1.M1
DDR_M0_D58: JDIMM1.250 UC1.L4
DDR_M0_D59: JDIMM1.245 UC1.L2
DDR_M0_D60: JDIMM1.237 UC1.M5
DDR_M0_D61: JDIMM1.233 UC1.M2
DDR_M0_D62: JDIMM1.249 UC1.L5
DDR_M0_D63: JDIMM1.246 UC1.L1
DDR_M0_DQS0: JDIMM1.13 UC1.BP5
DDR_M0_DQS1: JDIMM1.34 UC1.BK3
DDR_M0_DQS2: JDIMM1.55 UC1.BF3
DDR_M0_DQS3: JDIMM1.76 UC1.BC3
DDR_M0_DQS4: JDIMM1.179 UC1.AB3
DDR_M0_DQS5: JDIMM1.200 UC1.V3
DDR_M0_DQS6: JDIMM1.221 UC1.R3
DDR_M0_DQS7: JDIMM1.242 UC1.M3
DDR_M0_DQS#0: JDIMM1.11 UC1.BR5
DDR_M0_DQS#1: JDIMM1.32 UC1.BL3
DDR_M0_DQS#2: JDIMM1.53 UC1.BG3
DDR_M0_DQS#3: JDIMM1.74 UC1.BD3
DDR_M0_DQS#4: JDIMM1.177 UC1.AA3
DDR_M0_DQS#5: JDIMM1.198 UC1.U3
DDR_M0_DQS#6: JDIMM1.219 UC1.P3
DDR_M0_DQS#7: JDIMM1.240 UC1.L3
DDR_M0_MA0: JDIMM1.144 UC1.AH3
DDR_M0_MA1: JDIMM1.133 UC1.AP4
DDR_M0_MA2: JDIMM1.132 UC1.AN4
DDR_M0_MA3: JDIMM1.131 UC1.AP5
DDR_M0_MA4: JDIMM1.128 UC1.AP2
DDR_M0_MA5: JDIMM1.126 UC1.AP1
DDR_M0_MA6: JDIMM1.127 UC1.AP3
DDR_M0_MA7: JDIMM1.122 UC1.AN1
DDR_M0_MA8: JDIMM1.125 UC1.AN3
DDR_M0_MA9: JDIMM1.121 UC1.AT4
DDR_M0_MA10: JDIMM1.146 UC1.AH2
DDR_M0_MA11: JDIMM1.120 UC1.AN2
DDR_M0_MA12: JDIMM1.119 UC1.AU4
DDR_M0_MA13: JDIMM1.158 UC1.AE3
DDR_M0_MA14_WE#: JDIMM1.151 UC1.AG4
DDR_M0_MA15_CAS#: JDIMM1.156 UC1.AD1
DDR_M0_MA16_RAS#: JDIMM1.152 UC1.AH4
DDR_M0_ODT0: JDIMM1.155 UC1.AD3
DDR_M0_ODT1: JDIMM1.161 UC1.AE4
DDR_M0_PAR: JDIMM1.143 UC1.AG3
DDR_M1_ACT#: JDIMM2.114 UC1.AT9
DDR_M1_ALERT#: JDIMM2.116 UC1.AR8
DDR_M1_BA0: JDIMM2.150 UC1.AH8
DDR_M1_BA1: JDIMM2.145 UC1.AH9
DDR_M1_BG0: JDIMM2.115 UC1.AR9
DDR_M1_BG1: JDIMM2.113 UC1.AR7
DDR_M1_CKE0: JDIMM2.109 UC1.AT8
DDR_M1_CKE1: JDIMM2.110 UC1.AT10
DDR_M1_CLK0: JDIMM2.137 UC1.AM9
DDR_M1_CLK1: JDIMM2.138 UC1.AM7
DDR_M1_CLK#0: JDIMM2.139 UC1.AN9
DDR_M1_CLK#1: JDIMM2.140 UC1.AM8
DDR_M1_CS#0: JDIMM2.149 UC1.AF11
DDR_M1_CS#1: JDIMM2.157 UC1.AE7
DDR_M1_D0: JDIMM2.8 UC1.BT11
DDR_M1_D1: JDIMM2.7 UC1.BR11
DDR_M1_D2: JDIMM2.16 UC1.BT9
DDR_M1_D3: JDIMM2.21 UC1.BR8
DDR_M1_D4: JDIMM2.3 UC1.BP11
DDR_M1_D5: JDIMM2.4 UC1.BN11
DDR_M1_D6: JDIMM2.17 UC1.BP8
DDR_M1_D7: JDIMM2.20 UC1.BN8
DDR_M1_D8: JDIMM2.24 UC1.BL12
DDR_M1_D9: JDIMM2.28 UC1.BL11
DDR_M1_D10: JDIMM2.25 UC1.BL8
DDR_M1_D11: JDIMM2.38 UC1.BJ8
DDR_M1_D12: JDIMM2.37 UC1.BJ11
DDR_M1_D13: JDIMM2.41 UC1.BJ10
DDR_M1_D14: JDIMM2.29 UC1.BL7
DDR_M1_D15: JDIMM2.42 UC1.BJ7
DDR_M1_D16: JDIMM2.46 UC1.BG11
DDR_M1_D17: JDIMM2.50 UC1.BG10
DDR_M1_D18: JDIMM2.49 UC1.BG8
DDR_M1_D19: JDIMM2.62 UC1.BF8
DDR_M1_D20: JDIMM2.59 UC1.BF11
DDR_M1_D21: JDIMM2.63 UC1.BF10
DDR_M1_D22: JDIMM2.45 UC1.BG7
DDR_M1_D23: JDIMM2.58 UC1.BF7
DDR_M1_D24: JDIMM2.84 UC1.BB11
DDR_M1_D25: JDIMM2.70 UC1.BC11
DDR_M1_D26: JDIMM2.80 UC1.BB8
DDR_M1_D27: JDIMM2.67 UC1.BC8
DDR_M1_D28: JDIMM2.66 UC1.BC10
DDR_M1_D29: JDIMM2.83 UC1.BB10
DDR_M1_D30: JDIMM2.71 UC1.BC7
DDR_M1_D31: JDIMM2.79 UC1.BB7
DDR_M1_D32: JDIMM2.186 UC1.AA11
DDR_M1_D33: JDIMM2.182 UC1.AA10
DDR_M1_D34: JDIMM2.169 UC1.AC11
DDR_M1_D35: JDIMM2.173 UC1.AC10
DDR_M1_D36: JDIMM2.187 UC1.AA7
DDR_M1_D37: JDIMM2.183 UC1.AA8
DDR_M1_D38: JDIMM2.170 UC1.AC8
DDR_M1_D39: JDIMM2.174 UC1.AC7
DDR_M1_D40: JDIMM2.191 UC1.W8
DDR_M1_D41: JDIMM2.195 UC1.W7
DDR_M1_D42: JDIMM2.203 UC1.V10
DDR_M1_D43: JDIMM2.208 UC1.V11
DDR_M1_D44: JDIMM2.190 UC1.W11
DDR_M1_D45: JDIMM2.194 UC1.W10
DDR_M1_D46: JDIMM2.207 UC1.V7
DDR_M1_D47: JDIMM2.204 UC1.V8
DDR_M1_D48: JDIMM2.211 UC1.R11
DDR_M1_D49: JDIMM2.224 UC1.P11
DDR_M1_D50: JDIMM2.225 UC1.P7
DDR_M1_D51: JDIMM2.216 UC1.R8
DDR_M1_D52: JDIMM2.215 UC1.R10
DDR_M1_D53: JDIMM2.229 UC1.P10
DDR_M1_D54: JDIMM2.212 UC1.R7
DDR_M1_D55: JDIMM2.228 UC1.P8
DDR_M1_D56: JDIMM2.237 UC1.L11
DDR_M1_D57: JDIMM2.236 UC1.M11
DDR_M1_D58: JDIMM2.245 UC1.L7
DDR_M1_D59: JDIMM2.233 UC1.M8
DDR_M1_D60: JDIMM2.249 UC1.L10
DDR_M1_D61: JDIMM2.232 UC1.M10
DDR_M1_D62: JDIMM2.246 UC1.M7
DDR_M1_D63: JDIMM2.250 UC1.L8
DDR_M1_DQS0: JDIMM2.13 UC1.BP9
DDR_M1_DQS1: JDIMM2.34 UC1.BJ9
DDR_M1_DQS2: JDIMM2.55 UC1.BF9
DDR_M1_DQS3: JDIMM2.76 UC1.BB9
DDR_M1_DQS4: JDIMM2.179 UC1.AA9
DDR_M1_DQS5: JDIMM2.200 UC1.V9
DDR_M1_DQS6: JDIMM2.221 UC1.P9
DDR_M1_DQS7: JDIMM2.242 UC1.L9
DDR_M1_DQS#0: JDIMM2.11 UC1.BN9
DDR_M1_DQS#1: JDIMM2.32 UC1.BL9
DDR_M1_DQS#2: JDIMM2.53 UC1.BG9
DDR_M1_DQS#3: JDIMM2.74 UC1.BC9
DDR_M1_DQS#4: JDIMM2.177 UC1.AC9
DDR_M1_DQS#5: JDIMM2.198 UC1.W9
DDR_M1_DQS#6: JDIMM2.219 UC1.R9
DDR_M1_DQS#7: JDIMM2.240 UC1.M9
DDR_M1_MA0: JDIMM2.144 UC1.AJ9
DDR_M1_MA1: JDIMM2.133 UC1.AK6
DDR_M1_MA2: JDIMM2.132 UC1.AK5
DDR_M1_MA3: JDIMM2.131 UC1.AL5
DDR_M1_MA4: JDIMM2.128 UC1.AL6
DDR_M1_MA5: JDIMM2.126 UC1.AM6
DDR_M1_MA6: JDIMM2.127 UC1.AN7
DDR_M1_MA7: JDIMM2.122 UC1.AN10
DDR_M1_MA8: JDIMM2.125 UC1.AN8
DDR_M1_MA9: JDIMM2.121 UC1.AR11
DDR_M1_MA10: JDIMM2.146 UC1.AH7
DDR_M1_MA11: JDIMM2.120 UC1.AN11
DDR_M1_MA12: JDIMM2.119 UC1.AR10
DDR_M1_MA13: JDIMM2.158 UC1.AF9
DDR_M1_MA14_WE#: JDIMM2.151 UC1.AH11
DDR_M1_MA15_CAS#: JDIMM2.156 UC1.AF8
DDR_M1_MA16_RAS#: JDIMM2.152 UC1.AH10
DDR_M1_ODT0: JDIMM2.155 UC1.AF7
DDR_M1_ODT1: JDIMM2.161 UC1.AE8
DDR_M1_PAR: JDIMM2.143 UC1.AJ7
DDR_PG_CTRL: UC1.BT13 UC2.2
DEVSLP0: TH49.1(TP-1) UH1.AL48
DEVSLP1: R5217.2 UH1.AH35
DEVSLP1_R: JSSD1.38 R5216.2 R5217.1
DEVSLP2: TH4952.1(TP-1) UH1.AH40
DEVSLP4: TH48.1(TP-1) UH1.AR47
DEVSLP5: TH52.1(TP-1) UH1.AN46
DGPU_CLKREQ#: QG1.1 RG7.2 UG1.AK12
DGPU_HOLD_RST#: RH193.1 UG2.2 UH1.AT49
DGPU_PWR_EN: DG1.2 RG148.1 RH82.2 UG10.2 UH1.AU24
DGPU_PWROK: PRW1.2 PRW16.2 PUW1.1 RH164.2 UG11.2 UH1.AL47
DGPU_S_VID: TG11.1(TP-1) UG1.P5
DGPU_SEL0: RH257.1 RH258.2 UH1.AV34
DGPU_SEL1: RH155.1 RH156.2 UH1.AW32
DH_CHG: PRB14.1 PUB01.23
DH_CHG_R: PQB05.1 PRB14.2
DIFFOUT_2PH: PRZ39.1 PRZ41.2 PUZ1.35
DIFFOUT_4PH: PCZ17.2 PRZ36.2 PUZ1.4
DIMM1_CHA_EVENT#: JDIMM1.134 RD7.1
DIMM2_CHB_EVENT#: JDIMM2.134 RD25.1
DISPOFF#: CV18.1 JEDP1.18 RV2.2
DL_CHG: PQB05.8 PUB01.21
DMI_CRX_PTX_N0: UC1.E8 UH1.C33
DMI_CRX_PTX_N1: UC1.F6 UH1.C32
DMI_CRX_PTX_N2: UC1.E5 UH1.C31
DMI_CRX_PTX_N3: UC1.J9 UH1.C29
DMI_CRX_PTX_P0: UC1.D8 UH1.B33
DMI_CRX_PTX_P1: UC1.E6 UH1.B32
DMI_CRX_PTX_P2: UC1.D5 UH1.B31
DMI_CRX_PTX_P3: UC1.J8 UH1.B29
DMI_CTX_PRX_N0: UC1.A8 UH1.K34
DMI_CTX_PRX_N1: UC1.B6 UH1.G33
DMI_CTX_PRX_N2: UC1.A5 UH1.K32
DMI_CTX_PRX_N3: UC1.B4 UH1.G30
DMI_CTX_PRX_P0: UC1.B8 UH1.J35
DMI_CTX_PRX_P1: UC1.C6 UH1.F34
DMI_CTX_PRX_P2: UC1.B5 UH1.J32
DMI_CTX_PRX_P3: UC1.D4 UH1.F30
DP_HPD: RG395.2 RT803.1 UG29.1 UH1.AT6
DP_HPD_GPU#: QG56.1 RG394.2 UG1.R1
DP_RCOMP: RC1.1 UC1.D37
DPE_AUXN_SUB1: DU14.3 JUSBC1.A8 RT815.1 UT11.27
DPE_AUXP_SUB2: DU14.2 JUSBC1.B8 RT816.1 UT11.26
DRAM_RESET#: CH11.2 RH39.1 RH40.1 UH1.BB46
DRON: PUA1.3 PUG1.3 PUZ1.17 PUZ2.3 PUZ3.3 PUZ4.3 PUZ5.3
E51RXD_P80CLK: JWLAN1.32 UK1.31
E51TXD_P80DATA: JWLAN1.30 RK26.1 UK1.30
EC_AMP_EAPD: CA88.2 RA54.2 UA1.13
EC_BEEP#: CA27.1 UK1.23
EC_BKOFF#: RV2.1 RV3.1 UK1.105
EC_FAN_PWM1: JFAN1.3 RE2.2 UK1.26
EC_FAN_PWM2: JFAN2.3 RE4.2 UK1.25
EC_KBRST#: RH67.1 UH1.BE39 UK1.2
EC_LAN_ISOLATEB#_R: RM6.2 RM11.2 UL1.20
EC_MISO: RH241.2 UK1.119
EC_MOSI: RH240.2 UK1.120
EC_MUTE#: DA3.1 UK1.83
EC_ON: D514.2 PR310.1 RK29.2 UK1.112
EC_PCIE_WAKE#_CPU: RH182.1 UH1.BE36
EC_PECI: RK17.1 UK1.118
EC_PME#: R5178.2 RL15.2 UL1.21
EC_PME#_EC_R: R5178.1 UK1.76
EC_RST#: CK5.2 RK7.1 UK1.37
EC_RTC_RST: QC11.2 RC393.1 RH252.2 UK1.29
EC_SCI#: RK14.2 UH1.AU26 UK1.20
EC_SMB_CK: PRB16.2 PUB01.4
EC_SMB_CK1: PR14.2 PRB16.1 R5800.1 RH232.1 UK1.77
EC_SMB_CK2: Q7.6 QC9.6 QG2.3 RH234.1 RU54.2 UK1.79
EC_SMB_CK2_PD: RU54.1 UU4.32
EC_SMB_DA: PRB15.2 PUB01.3
EC_SMB_DA1: PR15.2 PRB15.1 R5799.1 RH233.1 UK1.78
EC_SMB_DA2: Q7.3 QC9.3 QG2.6 RH235.1 RU55.2 UK1.80
EC_SMB_DA2_PD: RU55.1 UU4.33
EC_SPICLK: CC144.1 RC369.2 RH243.2
EC_SPICLK_R: RC369.1 UK1.126
EC_SPICS#: RH242.2 UK1.128
EC_VCCST_PG: RC21.2 UC1.H13
EC_VCCST_PG_R: CC156.2 RC20.1 RC21.1 UK1.68
EC_VCIN1_AC_BYPASS: DG2.1 PRB43.1 RG200.1 RG393.1 UK1.64
ECAGND: CK3.2 LK2.2 PH1.2 PH2.2 UK1.69
EDP_AUXN: CV8.1 UC1.B26
EDP_AUXN_C: CV8.2 JEDP1.22
EDP_AUXP: CV7.1 UC1.C26
EDP_AUXP_C: CV7.2 JEDP1.23
EDP_DISP_UTIL: TC1.1(TP-1) UC1.A33
EDP_HPD: RV6.1 RV7.1 UH1.AN6
EDP_HPD_PANEL: JEDP1.19 RV6.2
EDP_TXN0: CV10.1 UC1.E29
EDP_TXN0_C: CV10.2 JEDP1.25
EDP_TXN1: CV12.1 UC1.E28
EDP_TXN1_C: CV12.2 JEDP1.28
EDP_TXN2: CV14.1 UC1.B29
EDP_TXN2_C: CV14.2 JEDP1.31
EDP_TXN3: CV16.1 UC1.B28
EDP_TXN3_C: CV16.2 JEDP1.34
EDP_TXP0: CV9.1 UC1.D29
EDP_TXP0_C: CV9.2 JEDP1.26
EDP_TXP1: CV11.1 UC1.F28
EDP_TXP1_C: CV11.2 JEDP1.29
EDP_TXP2: CV13.1 UC1.A29
EDP_TXP2_C: CV13.2 JEDP1.32
EDP_TXP3: CV15.1 UC1.C28
EDP_TXP3_C: CV15.2 JEDP1.35
EN_1.0V_VCCSTG: RC373.2 UC5.4
EN_1.0V_VCCSTU: CC408.1 RC370.2 UC4.3
EN_1.8V: PC1805.1 PR1804.2 PR1805.1 PU1801.7
EN_1.8VS: RC371.2 UC4.5
EN_1V05: PC1001.1 PR1003.2 PR1005.1 PU1001.11
EN_2.5V: PC2502.1 PR2501.2 PR2502.2 PR2503.1 PU2501.1
EN_3VS_5VS: R5253.2 U10.3 U10.5
EN_INVPWR: PCP4.1 PRP2.2 PRP3.1 PUP1.3
EN_VCCIOP: PCH13.1 PRH5.2 PRH7.1 PUH1.11
ENLDO_3V5V: PC329.1 PR306.2 PR308.1 PU301.11 PU302.5
FAN_SPEED1: CE5.1 JFAN1.2 RE1.2 UK1.28
FAN_SPEED2: CE6.1 JFAN2.2 RE3.2 UK1.101
FB_1.8V: PC1802.2 PR1803.2 PR1806.1 PU1801.1
FB_1V: PRH4.2 PRH6.2 PRH8.1 PUH1.14
FB_1V05: PR1006.2 PR1007.1 PR1020.2 PU1001.14
FB_2.5V: PC2504.2 PR2506.2 PR2507.1 PU2501.6
FB_2PH: PCZ20.2 PCZ21.1 PRZ41.1 PRZ42.1 PUZ1.34
FB_3V_LCDVDD: CV2.2 RV49.2 RV50.1 UV1.6
FB_4PH: PCZ16.2 PCZ19.2 PRZ35.1 PRZ36.1 PUZ1.5
FB_+1.0VSDGP: PCF2.2 PRF4.2 PRF6.1 PUF1.6
FB_CAL_PD_VDDQ: RG47.2 UG1.J27
FB_CAL_PU_GND: RG48.2 UG1.H27
FB_CAL_TERM_GND: RG49.2 UG1.H25
FB_DDR: PRM6.1 PRM9.1 PUM1.6
FB_GND_SENSE: TG10.1(TP-1) UG1.F2
FB_VDDQ_SENSE: PRW15.2 RG45.1 UG1.F1
FBA0_VREFC: CG89.1 RG50.2 RG51.2 RG52.1 UG4.J14
FBA0_ZQ1: RG58.1 UG4.J13
FBA1_VREFC: CG88.1 RG53.2 RG54.2 RG56.1 UG5.J14
FBA1_ZQ3: RG61.1 UG5.J13
FBA_CLKA0: RG63.1 UG1.R30 UG4.J12
FBA_CLKA0#: RG95.1 UG1.R31 UG4.J11
FBA_CLKA1: RG96.1 UG1.AB31 UG5.J12
FBA_CLKA1#: RG62.1 UG1.AC31 UG5.J11
FBA_CMD0: UG1.U30 UG4.G12
FBA_CMD1: UG1.T31 UG4.H10
FBA_CMD2: UG1.U29 UG4.H11
FBA_CMD3: UG1.R34 UG4.K11
FBA_CMD4: UG1.R33 UG4.K10
FBA_CMD5: UG1.U32 UG4.L12
FBA_CMD6: UG1.U33 UG4.K4
FBA_CMD7: UG1.U28 UG4.K5
FBA_CMD8: UG1.V28 UG4.J4
FBA_CMD9: UG1.V29 UG4.J5
FBA_CMD10: UG1.V30 UG4.H4
FBA_CMD11: UG1.U34 UG4.H5
FBA_CMD12: UG1.U31 UG4.G3
FBA_CMD13: RG89.2 UG1.V34 UG4.J2
FBA_CMD14: RG87.2 UG1.V33 UG4.J3
FBA_CMD15: UG1.Y32 UG4.L3
FBA_CMD16: UG1.AA31 UG5.L12
FBA_CMD17: UG1.AA29 UG5.K10
FBA_CMD18: UG1.AA28 UG5.K11
FBA_CMD19: UG1.AC34 UG5.H11
FBA_CMD20: UG1.AC33 UG5.H10
FBA_CMD21: UG1.AA32 UG5.G12
FBA_CMD22: UG1.AA33 UG5.H4
FBA_CMD23: UG1.Y28 UG5.H5
FBA_CMD24: UG1.Y29 UG5.J4
FBA_CMD25: UG1.W31 UG5.J5
FBA_CMD26: UG1.Y30 UG5.K4
FBA_CMD27: UG1.AA34 UG5.K5
FBA_CMD28: UG1.Y31 UG5.L3
FBA_CMD29: RG90.2 UG1.Y34 UG5.J2
FBA_CMD30: RG88.2 UG1.Y33 UG5.J3
FBA_CMD31: UG1.V31 UG5.G3
FBA_D0: UG1.L28 UG4.A4
FBA_D1: UG1.M29 UG4.A2
FBA_D2: UG1.L29 UG4.B4
FBA_D3: UG1.M28 UG4.B2
FBA_D4: UG1.N31 UG4.E4
FBA_D5: UG1.P29 UG4.E2
FBA_D6: UG1.R29 UG4.F4
FBA_D7: UG1.P28 UG4.F2
FBA_D8: UG1.J28 UG4.A11
FBA_D9: UG1.H29 UG4.A13
FBA_D10: UG1.J29 UG4.B11
FBA_D11: UG1.H28 UG4.B13
FBA_D12: UG1.G29 UG4.E11
FBA_D13: UG1.E31 UG4.E13
FBA_D14: UG1.E32 UG4.F11
FBA_D15: UG1.F30 UG4.F13
FBA_D16: UG1.C34 UG4.U11
FBA_D17: UG1.D32 UG4.U13
FBA_D18: UG1.B33 UG4.T11
FBA_D19: UG1.C33 UG4.T13
FBA_D20: UG1.F33 UG4.N11
FBA_D21: UG1.F32 UG4.N13
FBA_D22: UG1.H33 UG4.M11
FBA_D23: UG1.H32 UG4.M13
FBA_D24: UG1.P34 UG4.U4
FBA_D25: UG1.P32 UG4.U2
FBA_D26: UG1.P31 UG4.T4
FBA_D27: UG1.P33 UG4.T2
FBA_D28: UG1.L31 UG4.N4
FBA_D29: UG1.L34 UG4.N2
FBA_D30: UG1.L32 UG4.M4
FBA_D31: UG1.L33 UG4.M2
FBA_D32: UG1.AG28 UG5.U4
FBA_D33: UG1.AF29 UG5.U2
FBA_D34: UG1.AG29 UG5.T4
FBA_D35: UG1.AF28 UG5.T2
FBA_D36: UG1.AD30 UG5.N4
FBA_D37: UG1.AD29 UG5.N2
FBA_D38: UG1.AC29 UG5.M4
FBA_D39: UG1.AD28 UG5.M2
FBA_D40: UG1.AJ29 UG5.U11
FBA_D41: UG1.AK29 UG5.U13
FBA_D42: UG1.AJ30 UG5.T11
FBA_D43: UG1.AK28 UG5.T13
FBA_D44: UG1.AM29 UG5.N11
FBA_D45: UG1.AM31 UG5.N13
FBA_D46: UG1.AN29 UG5.M11
FBA_D47: UG1.AM30 UG5.M13
FBA_D48: UG1.AN31 UG5.A11
FBA_D49: UG1.AN32 UG5.A13
FBA_D50: UG1.AP30 UG5.B11
FBA_D51: UG1.AP32 UG5.B13
FBA_D52: UG1.AM33 UG5.E11
FBA_D53: UG1.AL31 UG5.E13
FBA_D54: UG1.AK33 UG5.F11
FBA_D55: UG1.AK32 UG5.F13
FBA_D56: UG1.AD34 UG5.A4
FBA_D57: UG1.AD32 UG5.A2
FBA_D58: UG1.AC30 UG5.B4
FBA_D59: UG1.AD33 UG5.B2
FBA_D60: UG1.AF31 UG5.E4
FBA_D61: UG1.AG34 UG5.E2
FBA_D62: UG1.AG32 UG5.F4
FBA_D63: UG1.AG33 UG5.F2
FBA_DBI0: UG1.P30 UG4.D2
FBA_DBI1: UG1.F31 UG4.D13
FBA_DBI2: UG1.F34 UG4.P13
FBA_DBI3: UG1.M32 UG4.P2
FBA_DBI4: UG1.AD31 UG5.P2
FBA_DBI5: UG1.AL29 UG5.P13
FBA_DBI6: UG1.AM32 UG5.D13
FBA_DBI7: UG1.AF34 UG5.D2
FBA_DEBUG0: TG1.1(TP-1) UG1.R32
FBA_DEBUG1: TG3.1(TP-1) UG1.AC32
FBA_EDC0: UG1.M31 UG4.C2
FBA_EDC1: UG1.G31 UG4.C13
FBA_EDC2: UG1.E33 UG4.R13
FBA_EDC3: UG1.M33 UG4.R2
FBA_EDC4: UG1.AE31 UG5.R2
FBA_EDC5: UG1.AK30 UG5.R13
FBA_EDC6: UG1.AN33 UG5.C13
FBA_EDC7: UG1.AF33 UG5.C2
FBA_VREFC_R: QG3.1 RG51.1 RG54.1
FBA_WCK01: UG1.K31 UG4.D4
FBA_WCK01#: UG1.L30 UG4.D5
FBA_WCK23: UG1.H34 UG4.P4
FBA_WCK23#: UG1.J34 UG4.P5
FBA_WCK45: UG1.AG30 UG5.P4
FBA_WCK45#: UG1.AG31 UG5.P5
FBA_WCK67: UG1.AJ34 UG5.D4
FBA_WCK67#: UG1.AK34 UG5.D5
FBB0_VREFC: CG123.1 RG64.2 RG65.2 RG66.1 UG6.J14
FBB0_ZQ1: RG74.1 UG6.J13
FBB1_VREFC: CG122.1 RG67.2 RG68.2 RG70.1 UG7.J14
FBB1_ZQ3: RG72.1 UG7.J13
FBB_CLKA0: RG76.1 UG1.D12 UG6.J12
FBB_CLKA0#: RG77.1 UG1.E12 UG6.J11
FBB_CLKA1: RG97.1 UG1.E20 UG7.J12
FBB_CLKA1#: RG98.1 UG1.F20 UG7.J11
FBB_CMD0: UG1.D13 UG6.G12
FBB_CMD1: UG1.E14 UG6.H10
FBB_CMD2: UG1.F14 UG6.H11
FBB_CMD3: UG1.A12 UG6.K11
FBB_CMD4: UG1.B12 UG6.K10
FBB_CMD5: UG1.C14 UG6.L12
FBB_CMD6: UG1.B14 UG6.K4
FBB_CMD7: UG1.G15 UG6.K5
FBB_CMD8: UG1.F15 UG6.J4
FBB_CMD9: UG1.E15 UG6.J5
FBB_CMD10: UG1.D15 UG6.H4
FBB_CMD11: UG1.A14 UG6.H5
FBB_CMD12: UG1.D14 UG6.G3
FBB_CMD13: RG93.2 UG1.A15 UG6.J2
FBB_CMD14: RG91.2 UG1.B15 UG6.J3
FBB_CMD15: UG1.C17 UG6.L3
FBB_CMD16: UG1.D18 UG7.L12
FBB_CMD17: UG1.E18 UG7.K10
FBB_CMD18: UG1.F18 UG7.K11
FBB_CMD19: UG1.A20 UG7.H11
FBB_CMD20: UG1.B20 UG7.H10
FBB_CMD21: UG1.C18 UG7.G12
FBB_CMD22: UG1.B18 UG7.H4
FBB_CMD23: UG1.G18 UG7.H5
FBB_CMD24: UG1.G17 UG7.J4
FBB_CMD25: UG1.F17 UG7.J5
FBB_CMD26: UG1.D16 UG7.K4
FBB_CMD27: UG1.A18 UG7.K5
FBB_CMD28: UG1.D17 UG7.L3
FBB_CMD29: RG94.2 UG1.A17 UG7.J2
FBB_CMD30: RG92.2 UG1.B17 UG7.J3
FBB_CMD31: UG1.E17 UG7.G3
FBB_D0: UG1.G9 UG6.A4
FBB_D1: UG1.E9 UG6.A2
FBB_D2: UG1.G8 UG6.B4
FBB_D3: UG1.F9 UG6.B2
FBB_D4: UG1.F11 UG6.E4
FBB_D5: UG1.G11 UG6.E2
FBB_D6: UG1.F12 UG6.F4
FBB_D7: UG1.G12 UG6.F2
FBB_D8: UG1.G6 UG6.A11
FBB_D9: UG1.F5 UG6.A13
FBB_D10: UG1.E6 UG6.B11
FBB_D11: UG1.F6 UG6.B13
FBB_D12: UG1.F4 UG6.E11
FBB_D13: UG1.G4 UG6.E13
FBB_D14: UG1.E2 UG6.F11
FBB_D15: UG1.F3 UG6.F13
FBB_D16: UG1.C2 UG6.U11
FBB_D17: UG1.D4 UG6.U13
FBB_D18: UG1.D3 UG6.T11
FBB_D19: UG1.C1 UG6.T13
FBB_D20: UG1.B3 UG6.N11
FBB_D21: UG1.C4 UG6.N13
FBB_D22: UG1.B5 UG6.M11
FBB_D23: UG1.C5 UG6.M13
FBB_D24: UG1.A11 UG6.U4
FBB_D25: UG1.C11 UG6.U2
FBB_D26: UG1.D11 UG6.T4
FBB_D27: UG1.B11 UG6.T2
FBB_D28: UG1.D8 UG6.N4
FBB_D29: UG1.A8 UG6.N2
FBB_D30: UG1.C8 UG6.M4
FBB_D31: UG1.B8 UG6.M2
FBB_D32: UG1.F24 UG7.U4
FBB_D33: UG1.G23 UG7.U2
FBB_D34: UG1.E24 UG7.T4
FBB_D35: UG1.G24 UG7.T2
FBB_D36: UG1.D21 UG7.N4
FBB_D37: UG1.E21 UG7.N2
FBB_D38: UG1.G21 UG7.M4
FBB_D39: UG1.F21 UG7.M2
FBB_D40: UG1.G27 UG7.U11
FBB_D41: UG1.D27 UG7.U13
FBB_D42: UG1.G26 UG7.T11
FBB_D43: UG1.E27 UG7.T13
FBB_D44: UG1.E29 UG7.N11
FBB_D45: UG1.F29 UG7.N13
FBB_D46: UG1.E30 UG7.M11
FBB_D47: UG1.D30 UG7.M13
FBB_D48: UG1.A32 UG7.A11
FBB_D49: UG1.C31 UG7.A13
FBB_D50: UG1.C32 UG7.B11
FBB_D51: UG1.B32 UG7.B13
FBB_D52: UG1.D29 UG7.E11
FBB_D53: UG1.A29 UG7.E13
FBB_D54: UG1.C29 UG7.F11
FBB_D55: UG1.B29 UG7.F13
FBB_D56: UG1.B21 UG7.A4
FBB_D57: UG1.C23 UG7.A2
FBB_D58: UG1.A21 UG7.B4
FBB_D59: UG1.C21 UG7.B2
FBB_D60: UG1.B24 UG7.E4
FBB_D61: UG1.C24 UG7.E2
FBB_D62: UG1.B26 UG7.F4
FBB_D63: UG1.C26 UG7.F2
FBB_DBI0: UG1.E11 UG6.D2
FBB_DBI1: UG1.E3 UG6.D13
FBB_DBI2: UG1.A3 UG6.P13
FBB_DBI3: UG1.C9 UG6.P2
FBB_DBI4: UG1.F23 UG7.P2
FBB_DBI5: UG1.F27 UG7.P13
FBB_DBI6: UG1.C30 UG7.D13
FBB_DBI7: UG1.A24 UG7.D2
FBB_DEBUG0: TG2.1(TP-1) UG1.C12
FBB_DEBUG1: TG4.1(TP-1) UG1.C20
FBB_EDC0: UG1.D10 UG6.C2
FBB_EDC1: UG1.D5 UG6.C13
FBB_EDC2: UG1.C3 UG6.R13
FBB_EDC3: UG1.B9 UG6.R2
FBB_EDC4: UG1.E23 UG7.R2
FBB_EDC5: UG1.E28 UG7.R13
FBB_EDC6: UG1.B30 UG7.C13
FBB_EDC7: UG1.A23 UG7.C2
FBB_VREFC_R: QG4.1 RG65.1 RG68.1
FBB_WCK01: UG1.F8 UG6.D4
FBB_WCK01#: UG1.E8 UG6.D5
FBB_WCK23: UG1.A5 UG6.P4
FBB_WCK23#: UG1.A6 UG6.P5
FBB_WCK45: UG1.D24 UG7.P4
FBB_WCK45#: UG1.D25 UG7.P5
FBB_WCK67: UG1.B27 UG7.D4
FBB_WCK67#: UG1.C27 UG7.D5
FRM_LCK#: RG398.2 UG1.L7
GC6_FB_EN: RH187.2 UH1.BB26
GC6_FB_EN1V8: QG8.2 RG402.2 UG1.M3
GC6_FB_EN3V3: DG3.2 QG8.3 RG113.2 RH187.1
GPD_7: RH11.1 RH12.2 UH1.BE41
GPP_H12: RH100.2 UH1.AB47
GPP_H15: RH99.1 UH1.AC47
GPP_J9: RH93.1 UH1.AU9
GPP_K18: RH202.1 UH1.T47
GPP_K19: RH203.1 UH1.T48
GPPJ_RCOMP_1P8: RH24.1 UH1.BD1 UH1.BE1 UH1.BE2
GPU_BUFRST#: TG9.1(TP-1) UG1.E1
GPU_DPE_AUXN: CT284.2 RG406.2 UG1.AB4
GPU_DPE_AUXN_C: CT284.1 RT807.1 UT11.25
GPU_DPE_AUXP: CT283.2 RG405.2 UG1.AB3
GPU_DPE_AUXP_C: CT283.1 RT812.1 UT11.24
GPU_DPE_N0: CT17.1 UG1.AD3
GPU_DPE_N0_C: CT17.2 UT11.10
GPU_DPE_N1: CT19.1 UG1.AC1
GPU_DPE_N1_C: CT19.2 UT11.13
GPU_DPE_N2: CT21.1 UG1.AC3
GPU_DPE_N2_C: CT21.2 UT11.16
GPU_DPE_N3: CT24.1 UG1.AC5
GPU_DPE_N3_C: CT24.2 UT11.19
GPU_DPE_P0: CT3.1 UG1.AD2
GPU_DPE_P0_C: CT3.2 UT11.9
GPU_DPE_P1: CT5.1 UG1.AD1
GPU_DPE_P1_C: CT5.2 UT11.12
GPU_DPE_P2: CT20.1 UG1.AC2
GPU_DPE_P2_C: CT20.2 UT11.15
GPU_DPE_P3: CT22.1 UG1.AC4
GPU_DPE_P3_C: CT22.2 UT11.18
GPU_EVENT#: DG243.1 RH186.1
GPU_EVENT#_1: DG243.2 RG400.2 UG1.L6
GPU_EVENT#_R: RH186.2 RH192.2 UH1.AW26
GPU_HDMI_CTRLCLK: QV2.4 RV36.1 UG1.AG3
GPU_HDMI_CTRLDAT: QV2.1 RV37.1 UG1.AG2
GPU_HDMI_TX0N: CV39.1 UG1.AH4
GPU_HDMI_TX0N_C: CV39.2 UV2.45
GPU_HDMI_TX0P: CV38.1 UG1.AH3
GPU_HDMI_TX0P_C: CV38.2 UV2.44
GPU_HDMI_TX1N: CV37.1 UG1.AJ2
GPU_HDMI_TX1N_C: CV37.2 UV2.42
GPU_HDMI_TX1P: CV36.1 UG1.AJ3
GPU_HDMI_TX1P_C: CV36.2 UV2.41
GPU_HDMI_TX2N: CV35.1 UG1.AJ1
GPU_HDMI_TX2N_C: CV35.2 UV2.39
GPU_HDMI_TX2P: CV34.1 UG1.AK1
GPU_HDMI_TX2P_C: CV34.2 UV2.38
GPU_HDMI_TXCN: CV41.1 UG1.AG4
GPU_HDMI_TXCN_C: CV41.2 UV2.48
GPU_HDMI_TXCP: CV40.1 UG1.AG5
GPU_HDMI_TXCP_C: CV40.2 UV2.47
GPU_I2C_8409_CLK: RV34.2 RV41.2 UV2.34
GPU_I2C_8409_DAT: RV35.2 RV42.2 UV2.33
GPU_OVERT#: DG7.1 QG1.3 RG392.1 UK1.19
GPU_PEX_RST_HOLD#: RG38.2 UG1.T8
GPUCORE_EN: DG4.2 DG5.1 DG7.2 QG17.5 RG103.1 RG105.1 UG10.4
GPUCORE_EN#: QG16.2 QG17.2 QG17.3 RG214.1
GS_SDO_SA0: R5801.2 R5802.1 U9.3
GSEN_I2CLK: R5800.2 U9.1
GSEN_I2DAT: R5799.2 U9.4
GSPI0_MOSI: RH94.2 UH1.BE30
GSPI1_MOSI: RH96.2 UH1.BA26
H_CPUPWRGD: CC157.2 UC1.BT31 UH1.AE3
H_PECI: RH13.2 RK17.2 UC1.BT34
H_PLTRST_CPU#: CH80.1 CH81.1 UC1.BP35 UH1.AG5
H_PM_DOWN: RC22.2 UC1.BP31
H_PM_DOWN_R: RC22.1 RH14.2 UH1.AE2
H_PM_SYNC: RH15.1 UH1.AF3
H_PM_SYNC_R: RH15.2 UC1.BM34
H_PROCHOT#: CK12.1 PRB17.1 QK1.1 RC18.1 RC42.2 RK8.2 RK9.2
H_PROCHOT#_CPU: RC42.1 UC1.BR30
H_PROCHOT#_EC: QK1.2 RK9.1 UK1.103
H_THERMTRIP#: RC45.2 UC1.J31
HDA_BIT_CLK: RH245.1 UH1.BD11
HDA_BIT_CLK_R: CA15.1 CH66.2 RH245.2 UA1.14
HDA_RST#: RH244.1 UH1.BE10
HDA_RST#_R: CH69.2 QA2.3 RH244.2
HDA_SDIN0: RA12.2 UH1.BE11
HDA_SDIN0_R: CA93.1 RA12.1 UA1.16
HDA_SDIN1: TH119.1(TP-1) UH1.BF10
HDA_SDOUT: QH2.3 RH118.2 RH196.1 RH246.1 UH1.BF12
HDA_SDOUT_R: CH68.2 RH246.2 UA1.17
HDA_SPKR: CA28.1 RH53.1 UH1.AW29
HDA_SYNC: RH247.1 UH1.BG13
HDA_SYNC_R: CH67.2 RH247.2 UA1.15
HDDHALT_LED#: JIO1.7 RH194.2 UH1.BE23
HDMI_1.2V_EN: RV11.1 RV30.1 UV3.1
HDMI_EQ: RV21.2 RV22.2 UV2.5
HDMI_HPD_GPU#: QG55.1 RG180.2 UG1.U3
HDMI_I2C_ADDR: RV23.2 UV2.31
HDMI_ID: RV26.2 UV2.32
HDMI_PRE: RV25.2 UV2.27
HDMI_SRC_HPD: RG114.2 UG28.1 UV2.40
HDMICONN_HPD_LS: DV1.1 DV1.9 JHDMI1.19 QV1.1 RV29.1 UV2.21
HDMICONN_SCL_LS: DV1.2 DV1.8 JHDMI1.15 RV27.1 RV39.2 UV2.7
HDMICONN_SCL_LS_R: QV2.3 RV39.1 RV41.1
HDMICONN_SDA_LS: DV1.4 DV1.7 JHDMI1.16 RV28.1 RV40.2 UV2.8
HDMICONN_SDA_LS_R: QV2.6 RV40.1 RV42.1
HGATE_1.35VSDGPUP: PQW1.4 PUW1.9
HP_OUT_L: CA96.1 JIO1.31 JIO1.32 LA9.1
HP_OUT_R: CA95.1 JIO1.34 JIO1.35 LA8.1
HP_OUTL: LA9.2 RA11.2
HP_OUTR: LA8.2 RA9.2
HPOUT_L: RA11.1 UA1.27
HPOUT_R: RA9.1 UA1.26
HRESET_987: RU64.1 UK1.18
HRESET_987_R: RU63.1 RU64.2 UU4.44
I2C_0_SCL: QC10.1 RH230.1 UH1.BC22
I2C_0_SDA: QC10.4 RH231.1 UH1.BF23
I2C_1_SCL: RH228.1 UH1.BE21
I2C_1_SDA: RH229.1 UH1.BF21
I2C_INT#: DT1.2 JTP1.2 R5236.2 R5808.2
ILIM_1PH: PCZ9.2 PRZ20.2 PUZ1.49
ILIM_2PH: PRZ44.1 PUZ1.32
ILIM_4PH: PRZ43.2 PUZ1.7
ILIM_SEL: RS17.1 US2.4
ILMT_1.35VSDGPUP: PRW4.2 PUW1.2
ILMT_1V05: PR1002.1 PR1004.2 PU1001.13
ILMT_VCCIOP: PRH9.2 PRH10.1 PUH1.13
IMON_1PH: PCZ6.2 PRZ13.2 PUZ1.46
IN_2.5V: PC2501.2 PJ2501.2 PU2501.4
INT_MIC: CA97.1 JIO1.29 LA10.1
INT_MIC_R: LA10.2 RA4.2 UA1.31
INVPWR_B+: CV54.1 FU1.1 LV1.2 PCP5.1 PCP6.1 PCP8.1 PCP326.1 PDP1.1 PRP4.1
INVPWR_B+_R: CV5.1 CV6.1 FU1.2 JEDP1.38 JEDP1.39 JEDP1.40
INVTPWM: CV17.1 JEDP1.17 RV4.2 RV5.1
IST_TRIG: TC287.1(TP-1) UC1.E3
JTAG_RST: RG43.1 UG1.AN11
JTAG_TCK_VGA: TG5.1(TP-1) UG1.AM10
JTAG_TDI: TG6.1(TP-1) UG1.AM11
JTAG_TDO: TG7.1(TP-1) UG1.AP12
JTAG_TMS: TG8.1(TP-1) UG1.AP11
KBL_ON: Q73.2 UK1.21
KBL_ON_GND: JKBL1.1 JKBL1.2 Q73.1 R23.2
KSI0: C389.2 JKB1.12 UK1.55
KSI1: JKB1.1 UK1.56
KSI2: JKB1.8 UK1.57
KSI3: JKB1.9 UK1.58
KSI4: JKB1.5 UK1.59
KSI5: JKB1.6 UK1.60
KSI6: JKB1.3 UK1.61
KSI7: JKB1.2 UK1.62
KSO0: JKB1.7 UK1.39
KSO1: JKB1.11 UK1.40
KSO2: JKB1.13 UK1.41
KSO3: JKB1.18 UK1.42
KSO4: JKB1.14 UK1.43
KSO5: JKB1.10 UK1.44
KSO6: JKB1.17 UK1.45
KSO7: JKB1.15 UK1.46
KSO8: JKB1.16 UK1.47
KSO9: JKB1.4 UK1.48
KSO10: JKB1.23 UK1.49
KSO11: JKB1.22 UK1.50
KSO12: JKB1.19 UK1.51
KSO13: JKB1.20 UK1.52
KSO14: JKB1.21 UK1.53
KSO15: JKB1.24 UK1.54
KSO16: JKB1.25 UK1.81
KSO17: JKB1.26 UK1.82
LAN_ACT#: RL31.2 UL1.27
LAN_ACT#_R: DM16.3 LED4.1 RL31.1
LAN_DISABLE_N: TH124.1(TP-1) UH1.BF41
LAN_LINK#: RL30.2 UL1.25
LAN_LINK#_R: DM16.2 LED5.1 RL30.1
LAN_MDIN0: DM12.3 TSL1.12 UL1.2
LAN_MDIN1: DM12.6 TSL1.9 UL1.5
LAN_MDIN2: DM13.3 TSL1.6 UL1.7
LAN_MDIN3: DM13.6 TSL1.3 UL1.10
LAN_MDIP0: DM12.4 TSL1.11 UL1.1
LAN_MDIP1: DM12.1 TSL1.8 UL1.4
LAN_MDIP2: DM13.4 TSL1.5 UL1.6
LAN_MDIP3: DM13.1 TSL1.2 UL1.9
LAN_PWR_EN: UK1.86 UL2.4
LAN_WAKE#: RH211.2 UH1.BG44
LANGND: CL2.1 CL3.1 DL1.2 JRJ45.9 JRJ45.10 JRJ45.11 JRJ45.12
LDO1_CAP: CA16.2 RA14.2 UA1.39
LDO2_CAP: CA17.2 UA1.21
LDO3_CAP: CA18.2 UA1.19
LDO_3V_VCCIOP: PCH12.1 PUH1.16 PUH1.17
LED1/GPO: RL56.1 UL1.26
LG_DDR: PQM1.8 PUM1.15
LG_GT: PQG1.8 PUG1.5
LG_PH1: PQZ1.8 PUZ2.5
LG_PH2: PQZ2.8 PUZ3.5
LG_PH3: PQZ3.8 PUZ4.5
LG_PH4: PQZ4.8 PUZ5.5
LG_VCCSA: PQA1.8 PUA1.5
LGATE_1.35VSDGPUP: PQW2.4 PUW1.6
LID_SW#: R5287.2 UK1.115
LID_SW#_OUT: C393.1 C394.1 D3.3 R5242.2 R5287.1 U7.3 U4019.1
LPC_AD0: UH1.BB39 UK1.10
LPC_AD1: UH1.AW37 UK1.8
LPC_AD2: UH1.AV37 UK1.7
LPC_AD3: UH1.BA38 UK1.5
LPC_FRAME#: UH1.BE38 UK1.4
LX_1.8V: PL1801.1 PR1802.1 PU1801.6
LX_1.35VSDGPUP: PCW2.2 PLW1.1 PQW1.1 PQW1.2 PQW1.3 PQW2.5 PRW13.1 PUW1.8
LX_1V05: PC1002.2 PL1001.1 PR1013.1 PU1001.6 PU1001.19 PU1001.20
LX_2.5V: PL2501.1 PR2505.1 PU2501.3
LX_3V: PC302.2 PL301.1 PL301.2 PR302.1 PU301.6 PU301.19 PU301.20
LX_3V_LCDVDD: LV3.1 RV48.1 UV1.3
LX_5V: PC313.2 PL302.1 PL302.2 PR307.1 PU302.2 PU302.12
LX_7237: PDP1.2 PLP1.2 PRP6.2 PUP1.6
LX_+1.0VSDGP: PLF1.1 PRF3.1 PUF1.3
LX_DDR: PCM4.2 PLM1.2 PQM1.9 PRM3.1 PUM1.16
LX_GT: PCG5.2 PQG1.2 PUG1.7
LX_GT_R: PLG1.1 PQG1.5 PQG1.6 PQG1.7 PRG2.1
LX_PH1: PCZ46.2 PQZ1.2 PUZ2.7
LX_PH1_R: PLZ1.1 PQZ1.5 PQZ1.6 PQZ1.7 PRZ80.1
LX_PH2: PCZ52.2 PQZ2.2 PUZ3.7
LX_PH2_R: PLZ2.1 PQZ2.5 PQZ2.6 PQZ2.7 PRZ83.1
LX_PH3: PCZ59.2 PQZ3.2 PUZ4.7
LX_PH3_R: PLZ3.1 PQZ3.5 PQZ3.6 PQZ3.7 PRZ86.1
LX_PH4: PCZ66.2 PQZ4.2 PUZ5.7
LX_PH4_R: PLZ4.1 PQZ4.5 PQZ4.6 PQZ4.7 PRZ89.1
LX_VCCIOP: PCH4.2 PLH1.1 PRH2.1 PUH1.6 PUH1.19 PUH1.20
LX_VCCSA: PCA5.2 PLA1.1 PQA1.9 PRA3.1 PUA1.7
MAINPWON: PR311.1 UK1.104
MCT1: RL58.1 TSL1.24
MCT2: RL59.1 TSL1.21
MCT3: RL60.1 TSL1.18
MCT4: RL61.1 TSL1.15
ME_FLASH_EN: QH2.2 RH118.1 UK1.99
MUTE_LED: C391.1 QA3.1 R5238.1
MUTE_LED_IN: QA3.2 RA37.1 UA1.47
MUX_AMSEL: RT800.2 RU57.2 UU4.16
MUX_AMSEL_R: RT800.1 RT809.1 UT11.22
MUX_CAD_SNK: RT859.1 RT860.1 UT11.29
MUX_DP_EQ0: RT813.2 RT817.1 RT818.1 UT11.14
MUX_DP_EQ1: RT814.2 RT838.1 RT840.1 UT11.2
MUX_EN: RT801.2 RU58.2 UU4.17
MUX_EN_R: RT801.1 RT810.1 UT11.23
MUX_HPD: DT2.2 RT803.2 RT839.2 RT1115.1 UT11.32
MUX_I2C_CLK: T163.1(TP-1) UU4.27
MUX_I2C_DATA: T164.1(TP-1) UU4.28
MUX_I2C_EN: RT856.2 RT857.1 RT858.1 UT11.17
MUX_POL: RT799.2 RU61.2 UU4.18
MUX_POL_R: RT799.1 RT808.1 UT11.21
MUX_SS_EQ0: RT841.2 RT845.1 RT846.1 UT11.11
MUX_SS_EQ1: RT847.2 RT848.1 RT849.1 UT11.3
MUX_USB3_EQ0: RT850.2 RT851.1 RT852.1 UT11.38
MUX_USB3_EQ1: RT853.2 RT854.1 RT855.1 UT11.35
NMI_DBG#: DK2.1 RK21.2 UK1.106
NMI_DBG#_CPU: DK2.2 RH195.2 UH1.AM45
NVDD_PWM3: PRV21.1 PUV1.22 PUV2.5
NVVDD_BST1: PRV1.1 PUV1.1
NVVDD_BST1_R: PCV1.1 PRV1.2
NVVDD_BST2: PRV6.1 PUV1.18
NVVDD_BST2_R: PCV10.1 PRV6.2
NVVDD_BST3: PRV24.1 PUV2.4
NVVDD_BST3_R: PCV21.1 PRV24.2
NVVDD_EN: PCV17.1 PRV14.1 PUV1.3 PUV2.1
NVVDD_FB: PCV20.2 PRV22.2 PRV38.2 PUV1.11
NVVDD_ILIM: PRV26.1 PUV1.12
NVVDD_ISEN2: PRV32.2 PRV35.1 PUV1.14
NVVDD_LG1: PQV1.8 PUV1.23
NVVDD_LG2: PQV2.8 PUV1.20
NVVDD_LG3: PQV3.8 PUV2.7
NVVDD_LX1: PCV1.2 PQV1.2 PUV1.24
NVVDD_LX1_1: PLV1.1 PQV1.5 PQV1.6 PQV1.7 PRV3.1
NVVDD_LX2: PCV10.2 PQV2.2 PUV1.19
NVVDD_LX2_1: PLV2.1 PQV2.5 PQV2.6 PQV2.7 PRV17.1
NVVDD_LX3: PCV21.2 PQV3.2 PUV2.2
NVVDD_LX3_1: PLV3.1 PQV3.5 PQV3.6 PQV3.7 PRV30.1
NVVDD_PHASE1: PLV1.2 PRV36.2
NVVDD_PHASE2: PLV2.2 PRV35.2
NVVDD_PHASE3: PLV3.2 PRV31.1
NVVDD_PSI: PRV8.2 RG37.2 UG1.M7
NVVDD_PSI_R: PRV5.2 PRV8.1 PRV12.1 PUV1.4
NVVDD_PVCC: PCV28.1 PRV33.2 PRV34.1 PUV1.21
NVVDD_PWM_VID: PRV37.2 UG1.P6
NVVDD_REFADJ: PRV11.2 PUV1.6
NVVDD_REFIN: PCV15.1 PRV10.1 PRV13.1 PUV1.7
NVVDD_RGND: PCV9.2 PCV15.2 PCV16.2 PCV20.1 PRV15.2 PRV19.2 PRV20.2 PUV1.10
NVVDD_SNUB1: PCV8.1 PRV3.2
NVVDD_SNUB2: PCV19.1 PRV17.2
NVVDD_SNUB3: PCV27.1 PRV30.2
NVVDD_TON: PRV16.2 PUV1.9
NVVDD_TSNS/ISEN3: PRV28.2 PRV31.2 PUV1.13
NVVDD_UG1: PRV2.1 PUV1.2
NVVDD_UG1_R: PQV1.1 PRV2.2
NVVDD_UG2: PRV9.1 PUV1.17
NVVDD_UG2_R: PQV2.1 PRV9.2
NVVDD_UG3: PRV23.1 PUV2.3
NVVDD_UG3_R: PQV3.1 PRV23.2
NVVDD_VCC/ISEN1: PRV33.1 PRV36.1 PUV1.15
NVVDD_VID: PRV37.1 PUV1.5
NVVDD_VREF: PCV9.1 PRV7.1 PRV28.1 PUV1.8
NVVDDS_PSI: RG39.2 UG1.P4
ON/OFF#: Q80.1 R5243.2 UK1.114
ON/OFF#_R: D1.3 JPWR1.3 Q80.3
PBTN_OUT#: R295.1 RH48.2 UK1.122
PBTN_OUT#_R: RH47.1 RH48.1 UH1.BE46
PC_BEEP: CA29.2 UA1.34
PC_BEEP_R: CA27.2 CA28.2 RA19.1
PCH_BKL_PWM: RV4.1 UH1.AU48
PCH_CPU_24M_CLK_N: UC1.D31 UH1.C6
PCH_CPU_24M_CLK_P: UC1.E31 UH1.D7
PCH_CPU_BCLK_N: UC1.A32 UH1.C8
PCH_CPU_BCLK_P: UC1.B31 UH1.B8
PCH_CPU_PCIBCLK_N: UC1.C36 UH1.B6
PCH_CPU_PCIBCLK_P: UC1.D35 UH1.A6
PCH_CS_TPM: RTT7.1 UH1.AT40
PCH_CS_TPM_R: RTT7.2 UT1.20
PCH_DP1_CTRL_CLK: RH33.2 UH1.AL13
PCH_DP1_CTRL_DATA: RH34.2 UH1.AR8
PCH_DP1_HPD: DT2.1 RT839.1 RU78.2 RU79.2 UU4.30
PCH_DP2_CTRL_CLK: RH35.2 UH1.AN13
PCH_DP2_CTRL_DATA: RH36.2 UH1.AL10
PCH_DP2_HPD: QV1.3 RV38.2 UH1.AN10
PCH_DP3_CTRL_CLK: RH38.2 UH1.AL9
PCH_DP3_CTRL_DATA: RH37.2 UH1.AR3
PCH_DP3_HPD: TH4953.1(TP-1) UH1.AP9
PCH_DPWROK: CK14.2 RH52.2 UK1.127
PCH_DPWROK_R: RH50.2 RH52.1 UH1.AW41
PCH_ENBKL: RH204.1 UH1.AV46 UK1.97
PCH_ENVDD: QV7.5 RV47.1 UH1.AV44 UV1.1
PCH_ENVDD#: QV7.2 QV7.3 RV51.2
PCH_GPP_B11: TH129.1(TP-1) UH1.AP29
PCH_GPP_J11: RH273.1 UH1.AR13
PCH_GPP_K17: TH128.1(TP-1) UH1.R47
PCH_JTAG_TCK1: RC391.1 UH1.AJ3
PCH_PECI: RH13.1 UH1.AF2
PCH_PLTRST#: RH7.1 UH1.AV29 UH3.1 UH3.2
PCH_PWR_EN: PR1804.1 RK30.2 U11.3 UK1.107
PCH_PWROK: CH73.2 CK10.1 DH2.2 RH210.2 RK20.2 UH1.AY42 UK1.32
PCH_RSMRST#: CH108.1 DH2.1 DH3.2 RH212.2 UH1.BA47 UK1.100
PCH_RTCRST#: CH10.2 CH83.2 CLRP2.2 QC11.6 RH32.2 UH1.BE47
PCH_RTCX1: CH6.1 RH19.1 UH1.BA49 YH2.2
PCH_RTCX2: CH7.1 RH19.2 UH1.BA48 YH2.1
PCH_SERIRQ: RH65.1 UH1.AW35
PCH_SMBCLK: QC7.1 QC8.6 RH226.1 UH1.BE26
PCH_SMBDATA: QC7.4 QC8.3 RH227.1 UH1.BF26
PCH_SML0ALERT#: RH97.2 UH1.BF24
PCH_SML0CLK: RH225.1 UH1.BF25
PCH_SML0DATA: RH224.1 UH1.BE24
PCH_SML1ALERT#: RH63.2 UH1.BD33
PCH_SML1CLK: QC9.1 RH223.1 UH1.BF27
PCH_SML1DATA: QC9.4 RH222.1 UH1.BE27
PCH_SPI_CLK: CH65.2 RH2.1 RTT6.1 UH1.AW47
PCH_SPI_CLK_R: CH3.1 RH2.2 RH243.1 UH2.6
PCH_SPI_CLK_TPM: RTT6.2 UT1.19
PCH_SPI_CS#0: RH175.2 RH242.1 RH259.1 UH1.AY47
PCH_SPI_CS#0_R: RH259.2 UH2.1
PCH_SPI_HOLD#: RH238.1 UH1.BA46
PCH_SPI_HOLD#_R: RH4.1 RH176.1 RH238.2 UH2.7
PCH_SPI_SI: RH98.1 RH236.1 RTT8.1 UH1.AU41
PCH_SPI_SI_R: RH236.2 RH240.1 UH2.5
PCH_SPI_SI_TPM: RTT8.2 UT1.21
PCH_SPI_SO: RH237.1 RTT9.1 UH1.BA45
PCH_SPI_SO_R: RH237.2 RH241.1 UH2.2
PCH_SPI_SO_TPM: RTT9.2 UT1.24
PCH_SPI_WP#: RH239.1 UH1.AY48
PCH_SPI_WP#_R: RH3.1 RH239.2 UH2.3
PCH_SRTCRST#: CH9.2 CH82.2 CLRP1.2 QC11.3 RH31.2 UH1.BD46
PCH_SUSWARN#: UH1.BC37 UK1.17
PCH_THERMTRIP#: RH158.1 UH1.AD3
PCH_THERMTRIP#_R: RC45.1 RH158.2 RH166.2
PCH_TRIGOUT: RH1.1 UH1.AK3
PCH_TRIGOUT_R: RH1.2 UC1.H23
PCH_VRALERT#: TH125.1(TP-1) UH1.BE32
PCH_XDP_CLK_R_DN: TC305.1(TP-1) UH1.Y3
PCH_XDP_CLK_R_DP: TC306.1(TP-1) UH1.Y4
PCIE_PRX_C_DTX_N14: CR13.2 UL1.18
PCIE_PRX_C_DTX_N15: CR15.2 UR1.8
PCIE_PRX_C_DTX_P14: CR11.2 UL1.17
PCIE_PRX_C_DTX_P15: CR14.2 UR1.7
PCIE_PRX_DTX_N9: JSSD1.5 UH1.G36
PCIE_PRX_DTX_N10: JSSD1.17 UH1.K37
PCIE_PRX_DTX_N11: JSSD1.29 UH1.G38
PCIE_PRX_DTX_N12: JSSD1.43 UH1.H42
PCIE_PRX_DTX_N14: CR13.1 UH1.D46
PCIE_PRX_DTX_N15: CR15.1 UH1.F44
PCIE_PRX_DTX_N16: JWLAN1.35 UH1.L41
PCIE_PRX_DTX_P9: JSSD1.7 UH1.F36
PCIE_PRX_DTX_P10: JSSD1.19 UH1.J37
PCIE_PRX_DTX_P11: JSSD1.31 UH1.F39
PCIE_PRX_DTX_P12: JSSD1.41 UH1.J41
PCIE_PRX_DTX_P14: CR11.1 UH1.C47
PCIE_PRX_DTX_P15: CR14.1 UH1.E45
PCIE_PRX_DTX_P16: JWLAN1.33 UH1.M40
PCIE_PTX_C_DRX_N9: C369.2 JSSD1.11
PCIE_PTX_C_DRX_N10: C371.2 JSSD1.23
PCIE_PTX_C_DRX_N11: C373.2 JSSD1.35
PCIE_PTX_C_DRX_N12: C375.2 JSSD1.47
PCIE_PTX_C_DRX_N14: CH76.1 UL1.14
PCIE_PTX_C_DRX_N15: CH78.1 UR1.4
PCIE_PTX_C_DRX_N16: CH60.1 JWLAN1.29
PCIE_PTX_C_DRX_P9: C370.2 JSSD1.13
PCIE_PTX_C_DRX_P10: C372.2 JSSD1.25
PCIE_PTX_C_DRX_P11: C374.2 JSSD1.37
PCIE_PTX_C_DRX_P12: C376.2 JSSD1.49
PCIE_PTX_C_DRX_P14: CH75.1 UL1.13
PCIE_PTX_C_DRX_P15: CH77.1 UR1.3
PCIE_PTX_C_DRX_P16: CH61.1 JWLAN1.27
PCIE_PTX_DRX_N9: C369.1 UH1.C34
PCIE_PTX_DRX_N10: C371.1 UH1.C35
PCIE_PTX_DRX_N11: C373.1 UH1.B36
PCIE_PTX_DRX_N12: C375.1 UH1.D38
PCIE_PTX_DRX_N14: CH76.2 UH1.C39
PCIE_PTX_DRX_N15: CH78.2 UH1.B40
PCIE_PTX_DRX_N16: CH60.2 UH1.B41
PCIE_PTX_DRX_P9: C370.1 UH1.D34
PCIE_PTX_DRX_P10: C372.1 UH1.B35
PCIE_PTX_DRX_P11: C374.1 UH1.C36
PCIE_PTX_DRX_P12: C376.1 UH1.E37
PCIE_PTX_DRX_P14: CH75.2 UH1.D39
PCIE_PTX_DRX_P15: CH77.2 UH1.C40
PCIE_PTX_DRX_P16: CH61.2 UH1.C41
PCIE_RCOMPN: RH21.1 UH1.B12
PCIE_RCOMPP: RH21.2 UH1.A13
PD_EE_CLK: CU68.1 RU62.2 UU5.6
PD_EE_CLK_R: RU62.1 UU4.38
PD_EE_CS_N: RU70.2 UU4.39 UU5.1
PD_EE_DI: UU4.37 UU5.5
PD_EE_DO: RU69.2 UU4.36 UU5.2
PD_EE_WP_N: RU68.2 UU5.3
PD_HOLD_N: RU71.2 UU5.7
PDB: CA94.2 DA3.2 QA2.1 RA15.1 RA26.2 UA1.2
PEDET: EC11.1 JSSD1.61 Q79.2 R5220.2
PEG_CRX_C_GTX_N0: CG532.2 UG1.AJ14
PEG_CRX_C_GTX_N1: CG534.2 UG1.AG14
PEG_CRX_C_GTX_N2: CG536.2 UG1.AJ15
PEG_CRX_C_GTX_N3: CG538.2 UG1.AK16
PEG_CRX_C_GTX_N4: CG540.2 UG1.AJ17
PEG_CRX_C_GTX_N5: CG542.2 UG1.AG17
PEG_CRX_C_GTX_N6: CG544.2 UG1.AJ18
PEG_CRX_C_GTX_N7: CG546.2 UG1.AK19
PEG_CRX_C_GTX_P0: CG531.2 UG1.AK14
PEG_CRX_C_GTX_P1: CG533.2 UG1.AH14
PEG_CRX_C_GTX_P2: CG535.2 UG1.AK15
PEG_CRX_C_GTX_P3: CG537.2 UG1.AL16
PEG_CRX_C_GTX_P4: CG539.2 UG1.AK17
PEG_CRX_C_GTX_P5: CG541.2 UG1.AH17
PEG_CRX_C_GTX_P6: CG543.2 UG1.AK18
PEG_CRX_C_GTX_P7: CG545.2 UG1.AL19
PEG_CRX_GTX_N0: CG532.1 UC1.E10
PEG_CRX_GTX_N1: CG534.1 UC1.E11
PEG_CRX_GTX_N2: CG536.1 UC1.E12
PEG_CRX_GTX_N3: CG538.1 UC1.E13
PEG_CRX_GTX_N4: CG540.1 UC1.E14
PEG_CRX_GTX_N5: CG542.1 UC1.E15
PEG_CRX_GTX_N6: CG544.1 UC1.E16
PEG_CRX_GTX_N7: CG546.1 UC1.E17
PEG_CRX_GTX_P0: CG531.1 UC1.F10
PEG_CRX_GTX_P1: CG533.1 UC1.D11
PEG_CRX_GTX_P2: CG535.1 UC1.F12
PEG_CRX_GTX_P3: CG537.1 UC1.D13
PEG_CRX_GTX_P4: CG539.1 UC1.F14
PEG_CRX_GTX_P5: CG541.1 UC1.D15
PEG_CRX_GTX_P6: CG543.1 UC1.F16
PEG_CRX_GTX_P7: CG545.1 UC1.D17
PEG_CTX_C_GRX_N0: CC16.2 UG1.AM12
PEG_CTX_C_GRX_N1: CC14.2 UG1.AM14
PEG_CTX_C_GRX_N2: CC12.2 UG1.AP15
PEG_CTX_C_GRX_N3: CC10.2 UG1.AM15
PEG_CTX_C_GRX_N4: CC8.2 UG1.AM17
PEG_CTX_C_GRX_N5: CC6.2 UG1.AP18
PEG_CTX_C_GRX_N6: CC4.2 UG1.AM18
PEG_CTX_C_GRX_N7: CC2.2 UG1.AM20
PEG_CTX_C_GRX_P0: CC15.2 UG1.AN12
PEG_CTX_C_GRX_P1: CC13.2 UG1.AN14
PEG_CTX_C_GRX_P2: CC11.2 UG1.AP14
PEG_CTX_C_GRX_P3: CC9.2 UG1.AN15
PEG_CTX_C_GRX_P4: CC7.2 UG1.AN17
PEG_CTX_C_GRX_P5: CC5.2 UG1.AP17
PEG_CTX_C_GRX_P6: CC3.2 UG1.AN18
PEG_CTX_C_GRX_P7: CC1.2 UG1.AN20
PEG_CTX_GRX_N0: CC16.1 UC1.B10
PEG_CTX_GRX_N1: CC14.1 UC1.B11
PEG_CTX_GRX_N2: CC12.1 UC1.B12
PEG_CTX_GRX_N3: CC10.1 UC1.B13
PEG_CTX_GRX_N4: CC8.1 UC1.B14
PEG_CTX_GRX_N5: CC6.1 UC1.B15
PEG_CTX_GRX_N6: CC4.1 UC1.B16
PEG_CTX_GRX_N7: CC2.1 UC1.B17
PEG_CTX_GRX_P0: CC15.1 UC1.C10
PEG_CTX_GRX_P1: CC13.1 UC1.A11
PEG_CTX_GRX_P2: CC11.1 UC1.C12
PEG_CTX_GRX_P3: CC9.1 UC1.A13
PEG_CTX_GRX_P4: CC7.1 UC1.C14
PEG_CTX_GRX_P5: CC5.1 UC1.A15
PEG_CTX_GRX_P6: CC3.1 UC1.C16
PEG_CTX_GRX_P7: CC1.1 UC1.A17
PEG_RCOMP: RC9.2 UC1.G2
PEX_TREMP: RG10.2 UG1.AP29
PG_+2.5V: PDM2.1 PR2504.2 PU2501.5
PIRQA#: RH169.1 UH1.BA36
PLT_RST#: CH79.2 CK4.1 JWLAN1.44 R28.1 R5218.2 RH7.2 RK31.2 RV19.2 UG2.1 UH3.4 UK1.13 UL1.19 UR1.1
PLT_RST#_R: JSSD1.50 R5218.1
PLT_RST#_TPM: R28.2 UT1.17
PLTRST_VGA#_1V8: CG200.1 RG16.1 RG100.2 UG1.AJ12 UG2.4 UG8.1 UG28.2 UG29.2
PLUG_IN#: JIO1.28 RA17.2
PLUG_IN#_R: RA16.1 RA17.1 UA1.48
PM_BATLOW#: RH41.1 UH1.BF44
PM_CLKRUN#: RH44.1 UH1.AV32
PM_SLP_A#: RH200.1 UH1.BE40
PM_SLP_S0#: TH4972.1(TP-1) UH1.BC28
PM_SLP_S3#: RH197.2 UH1.BF42 UK1.6
PM_SLP_S4#: PDM1.1 PR2501.1 RH198.2 UH1.BE42 UK1.123
PM_SLP_S5#: RH199.2 UH1.BC42 UK1.14
PM_SLP_SUS#: UH1.BD39 UK1.16
PROC_SELECT#: TC97.1(TP-1) UC1.BN1
PWM1_1PH/ICCMAX1: PRZ24.1 PUA1.2 PUZ1.44
PWM1_2PH/ICCMAX2: PRZ58.1 PUG1.2 PUZ1.23
PWM1_4PH/ICCMAX4: PRZ61.1 PUZ1.18 PUZ2.2
PWM2_2PH/ROSC1: PRZ65.1 PUZ1.22
PWM2_4PH/ADDR: PRZ62.1 PUZ1.19 PUZ3.2
PWM3_4PH/VBOOT: PRZ63.1 PUZ1.20 PUZ4.2
PWM4_4PH/ROSCM: PRZ64.1 PUZ1.21 PUZ5.2
PWR_LED#: JPWR1.4 UK1.92
PWROK_DDR: PTPM1.1(TP-1) PUM1.10
QPCN: PCB15.1 PUB01.28
QPCP: PCB15.2 PUB01.27
REFCLK_CNV: RH173.1 RWL29.1 UH1.R6
REFCLK_CNV_R: JWLAN1.56 RWL29.2
RJ45_RX1+: JRJ45.3 TSL1.17
RJ45_RX1-: JRJ45.6 TSL1.16
RJ45_TX0+: JRJ45.1 TSL1.14
RJ45_TX0-: JRJ45.2 TSL1.13
RJ45_TX2+: JRJ45.4 TSL1.20
RJ45_TX2-: JRJ45.5 TSL1.19
RJ45_TX3+: JRJ45.7 TSL1.23
RJ45_TX3-: JRJ45.8 TSL1.22
ROM_SCLK: RG132.1 RG138.2 UG1.H4
ROM_SI: RG130.1 RG136.2 UG1.H5
ROM_SO: RG131.1 RG137.2 UG1.H7
RSET: RL11.2 UL1.31
RTD3_CIO_PWR_EN: TH4962.1(TP-1) UH1.AE43
RTD3_USB_PWR_EN: TH4960.1(TP-1) UH1.BD29
S3_DDR: PCM18.1 PRM11.2 PRM12.2 PUM1.7
S5_DDR: PCM17.1 PDM1.2 PDM2.2 PRM8.2 PUM1.8
SA0_CHA_DIM1: JDIMM1.256 RD1.2 RD3.1
SA0_CHB_DIM2: JDIMM2.256 RD19.2 RD22.1
SA1_CHA_DIM1: JDIMM1.260 RD4.2 RD5.1
SA1_CHB_DIM2: JDIMM2.260 RD20.2 RD23.1
SA2_CHA_DIM1: JDIMM1.166 RD2.2 RD6.1
SA2_CHB_DIM2: JDIMM2.166 RD21.2 RD24.1
SATA_LED#: D513.2 JIO1.8 RH170.1 UH1.AK48
SATA_PRX_C_DTX_N0: C379.2 JHDD1.8
SATA_PRX_C_DTX_P0: C378.2 JHDD1.7
SATA_PRX_DTX_N0: C379.1 UH1.C45
SATA_PRX_DTX_P0: C378.1 UH1.C46
SATA_PTX_C_DRX_N0: C380.2 JHDD1.10
SATA_PTX_C_DRX_P0: C382.2 JHDD1.11
SATA_PTX_DRX_N0: C380.1 UH1.B38
SATA_PTX_DRX_P0: C382.1 UH1.C38
SD_CD#: JCR2.4 UR1.30
SD_CLK: RR6.1 UR1.17
SD_CLK_R: CR12.1 JCR2.7 RR6.2
SD_CMD: RR7.1 UR1.19
SD_CMD_R: JCR2.3 RR7.2
SD_D0: RR5.2 UR1.16
SD_D0_R: JCR2.9 RR5.1
SD_D1: RR4.2 UR1.15
SD_D1_R: JCR2.10 RR4.1
SD_D2: RR9.1 UR1.21
SD_D2_R: JCR2.1 RR9.2
SD_D3: RR8.1 UR1.20
SD_D3_R: JCR2.2 RR8.2
SD_RCOMP_1P8: RH22.1 UH1.BE5
SD_RCOMP_3P3: RH23.1 UH1.BE4
SD_WP: JCR2.11 UR1.29
SERIRQ: RH64.2 RH65.2 UK1.3
SIZE_SEL: RH255.1 RH256.1 UH1.BA33
SKTOCC#: TC102.1(TP-1) UC1.BR33
SLP_LAN#: TH131.1(TP-1) UH1.BF40
SLP_WLAN#: QWL3.2 UH1.BD42
SM_INTRUDER#: RH6.2 UH1.BB44
SM_PG_CTRL: PRM12.1 RC43.2 UC2.4
SM_RCOMP0: RC3.2 UC1.G1
SM_RCOMP1: RC4.2 UC1.H1
SM_RCOMP2: RC5.2 UC1.J2
SMB_CK2: Q7.1 R5284.1 UC3.8
SMB_DA2: Q7.4 R5285.1 UC3.7
SMBALERT#: R5236.1 RH95.2 UH1.BE25
SMBUS_CLK: JDIMM1.253 JDIMM2.253 QC8.1 RC377.1
SMBUS_DAT: JDIMM1.254 JDIMM2.254 QC8.4 RC376.1
SNB_1.8V: PC1806.1 PR1802.2
SNB_1.35VSDGPUP: PCW6.1 PRW13.2
SNB_2.5V: PC2503.1 PR2505.2
SNB_CHG: PCB18.1 PRB21.2
SNB_DDR: PCM14.1 PRM3.2
SNB_GT: PCG7.1 PRG2.2
SNB_INVPWR: PCP7.1 PRP6.1
SNB_PH1: PCZ47.1 PRZ80.2
SNB_PH2: PCZ54.1 PRZ83.2
SNB_PH3: PCZ61.1 PRZ86.2
SNB_PH4: PCZ68.1 PRZ89.2
SNDW2_CLK: TH121.1(TP-1) UH1.BD12
SNDW2_DATA: TH120.1(TP-1) UH1.BE12
SNUB_1V05: PC1003.1 PR1013.2
SNUB_VCCIOP: PCH2.1 PRH2.2
SPK_DET#: JSPK1.5 RH191.1 UH1.AM47
SPK_L+_CONN: DA9.3 JSPK1.4 RA33.2
SPK_L-_CONN: DA9.2 JSPK1.3 RA32.2
SPK_OUT_L+: RA33.1 UA1.42
SPK_OUT_L-: RA32.1 UA1.43
SPK_OUT_R+: RA31.1 UA1.45
SPK_OUT_R-: RA30.1 UA1.44
SPK_R+_CONN: DA8.3 JSPK1.2 RA31.2
SPK_R-_CONN: DA8.2 JSPK1.1 RA30.2
SPOK: DH3.1 PR303.2 PR309.2 PR314.2 QS1.5
SPOK#: QS1.2 QS1.3 RS40.2
SPOK_3V: PR314.1 PU301.9
SPOK_5V: PR309.1 PU302.4
SRN_R: PRB08.3 PRB22.2
SRP_R: PRB08.2 PRB20.2
SSD1_IF: Q79.1 R5219.1 UH1.AJ43
STRAP0: RG122.2 RG124.1 UG1.J2
STRAP1: RG123.2 RG125.1 UG1.J7
STRAP2: RG118.2 RG126.1 UG1.J6
STRAP3: RG127.1 RG133.2 UG1.J5
STRAP4: RG128.1 RG134.2 UG1.J3
STRAP5: RG129.1 RG135.2 UG1.J1
SUS_STAT#: TH4950.1(TP-1) UH1.BF38
SUSACK#: RH177.1 UK1.15
SUSACK#_R: RH177.2 UH1.BE35
SUSCLK: RWL5.2 UH1.BE45
SUSP#: PRH5.1 PRM11.1 PRP2.1 R5253.1 RC371.1 RC373.1 RK27.1 UC6.4 UK1.116
SW1_2PH: PLG1.2 PRZ52.2 PRZ66.2
SW1_4PH: PLZ1.2 PRZ48.1 PRZ59.1
SW2_4PH: PLZ2.2 PRZ51.1 PRZ67.1
SW3_4PH: PLZ3.2 PRZ53.1 PRZ70.1
SW4_4PH: PLZ4.2 PRZ54.1 PRZ73.1
SW_1PH: PLA1.2 PRZ3.2
SWTRAP: RK34.2 UK1.70
SYS_PEX_RST_MON#: RG34.2 UG1.R8
SYS_PWROK: CH72.2 CK15.1 UH1.AU3 UK1.74
SYS_RESET#: CH71.2 CLRP3.2 RH213.2 UH1.AU2
SYSON: CK9.1 PR2502.1 RC370.1 RK23.1 UK1.95
TBT_CIO_PLUG_EVENT#: TH4964.1(TP-1) UH1.AJ47
TBT_FORCE_PWR: TH4963.1(TP-1) UH1.AJ46
TBTC_ADCIN1: RU66.2 RU72.1 UU4.6
TBTC_ADCIN2: RU67.2 RU73.1 UU4.10
TBTC_I2C_IRQ2Z: RU51.2 UK1.89 UU4.34
TESTMODE: RG42.1 UG1.AK11
THERM_C_D+: CV273.1 QC12.1 QC12.2 UC3.2
THERM_C_D-: CV273.2 QC12.3 UC3.3
TMDS_SNK_ML0_N: DV2.1 DV2.9 JHDMI1.9 RV15.2 RV45.2
TMDS_SNK_ML0_N_R: RV15.1 UV2.16
TMDS_SNK_ML0_P: DV2.2 DV2.8 JHDMI1.7 RV13.2 RV45.1
TMDS_SNK_ML0_P_R: RV13.1 UV2.17
TMDS_SNK_ML1_N: DV3.1 DV3.9 JHDMI1.6 RV12.2 RV44.2
TMDS_SNK_ML1_N_R: RV12.1 UV2.19
TMDS_SNK_ML1_P: DV3.2 DV3.8 JHDMI1.4 RV10.2 RV44.1
TMDS_SNK_ML1_P_R: RV10.1 UV2.20
TMDS_SNK_ML2_N: DV3.4 DV3.7 JHDMI1.3 RV9.2 RV43.2
TMDS_SNK_ML2_N_R: RV9.1 UV2.22
TMDS_SNK_ML2_P: DV3.5 DV3.6 JHDMI1.1 RV8.2 RV43.1
TMDS_SNK_ML2_P_R: RV8.1 UV2.23
TMDS_SNK_ML3_N: DV2.4 DV2.7 JHDMI1.12 LM13.2 RV46.2
TMDS_SNK_ML3_N_R: CV275.2 LM13.1 UV2.13
TMDS_SNK_ML3_P: DV2.5 DV2.6 JHDMI1.10 LM13.3 RV46.1
TMDS_SNK_ML3_P_R: CV275.1 LM13.4 UV2.14
TON_DDR: PRM7.2 PUM1.9
TP_CLK: C5257.1 DM5.1 JTP1.6 RK12.1 UK1.87
TP_DATA: C5256.1 DM5.3 JTP1.7 RK13.1 UK1.88
TP_EN: DT1.3 JTP1.1 UK1.1
TP_INT#_EC: R5808.1 UK1.125
TP_SMBCLK: C5258.1 DM5.6 JTP1.4 QC7.6 RC81.1 RH261.2
TP_SMBDATA: C5259.1 DM5.4 JTP1.3 QC7.3 RC82.1 RH262.2
TPM_GPIO: RTT10.1 UT1.6
TPM_IRQ#: R5202.1 RH178.2 UH1.AW13
TPM_PP: RTT12.1 RTT35.2 UT1.7
TPM_SERIRQ: R5202.2 UT1.18
TSENSE_2PH: PCZ32.1 PRZ75.1 PUZ1.25
TSENSE_4PH: PCZ30.1 PRZ74.1 PUZ1.14
U2D_DN1: LS9.4 US2.11
U2D_DP1: LS9.1 US2.10
UART_2_CCTS_DRTS: RH81.1 UH1.AV21
UART_2_CRTS_DCTS: RH79.1 UH1.AW21
UART_2_CRXD_DTXD: RH76.1 RWL32.1 UH1.BD20
UART_2_CTXD_DRXD: RH78.1 RWL33.1 UH1.BE20
UG_DDR: PQM1.1 PUM1.17
UG_GT: PQG1.1 PUG1.8
UG_PH1: PQZ1.1 PUZ2.8
UG_PH2: PQZ2.1 PUZ3.8
UG_PH3: PQZ3.1 PUZ4.8
UG_PH4: PQZ4.1 PUZ5.8
UG_VCCSA: PRA2.2 PUA1.8
UG_VCCSA_R: PQA1.1 PRA2.1
USB2_RCOMP: RH8.1 UH1.F4
USB3_DPE_MRX_C_DTX_N1: CT320.1 DU2.4 DU2.7 JUSBC1.B10 RT1112.1
USB3_DPE_MRX_C_DTX_N2: CT322.1 DU1.4 DU1.7 JUSBC1.A10 RT1114.1
USB3_DPE_MRX_C_DTX_P1: CT319.1 DU2.5 DU2.6 JUSBC1.B11 RT1111.1
USB3_DPE_MRX_C_DTX_P2: CT321.1 DU1.5 DU1.6 JUSBC1.A11 RT1113.1
USB3_DPE_MRX_DTX_N1: CT320.2 UT11.31
USB3_DPE_MRX_DTX_N2: CT322.2 UT11.39
USB3_DPE_MRX_DTX_P1: CT319.2 UT11.30
USB3_DPE_MRX_DTX_P2: CT321.2 UT11.40
USB3_DPE_MTX_C_DRX_N1: CT280.1 DU1.2 DU1.9 JUSBC1.A3
USB3_DPE_MTX_C_DRX_N2: CT282.1 DU2.2 DU2.9 JUSBC1.B3
USB3_DPE_MTX_C_DRX_P1: CT279.1 DU1.1 DU1.10 JUSBC1.A2
USB3_DPE_MTX_C_DRX_P2: CT281.1 DU2.1 DU2.10 JUSBC1.B2
USB3_DPE_MTX_DRX_N1: CT280.2 UT11.34
USB3_DPE_MTX_DRX_N2: CT282.2 UT11.36
USB3_DPE_MTX_DRX_P1: CT279.2 UT11.33
USB3_DPE_MTX_DRX_P2: CT281.2 UT11.37
USB3_PRX_C_MTX_N4: CT286.1 UT11.4
USB3_PRX_C_MTX_P4: CT285.1 UT11.5
USB3_PRX_DTX_N1: RS34.1 UH1.D11
USB3_PRX_DTX_N2: JIO1.13 UH1.B9
USB3_PRX_DTX_N3: JIO1.19 UH1.B10
USB3_PRX_DTX_P1: RS32.1 UH1.C11
USB3_PRX_DTX_P2: JIO1.14 UH1.C9
USB3_PRX_DTX_P3: JIO1.20 UH1.C10
USB3_PRX_MTX_N4: CT286.2 UH1.K16
USB3_PRX_MTX_P4: CT285.2 UH1.J15
USB3_PRX_R_DTX_N1: DS6.1 DS6.9 JUSB3.5 RS34.2
USB3_PRX_R_DTX_P1: DS6.2 DS6.8 JUSB3.6 RS32.2
