# Allegro board LAJ643PR10-0325.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
SY8286RAC_QFN20_3X3
  oval 0.889x0.254 smd: 1(0,0) 2(0,-0.45) 3(0,-0.9) 4(0,-1.35) 5(0,-1.8) 11(3.1,-1.8) 12(3.1,-1.35) 13(3.1,-0.9) 14(3.1,-0.45) 15(3.1,0)
  oval 0.254x0.889 smd: 6(0.65,-2.45) 7(1.1,-2.45) 8(1.55,-2.45) 9(2,-2.45) 10(2.45,-2.45) 16(2.45,0.65) 17(2,0.65) 18(1.55,0.65) 19(1.1,0.65) 20(0.65,0.65)
  rect 0.991x0.991 smd: 21(1.55,-0.9)
SY8288RAC_QFN20_3X3
  oval 0.889x0.254 smd: 1(0,0) 2(0,-0.45) 3(0,-0.9) 4(0,-1.35) 5(0,-1.8) 11(3.1,-1.8) 12(3.1,-1.35) 13(3.1,-0.9) 14(3.1,-0.45) 15(3.1,0)
  oval 0.254x0.889 smd: 6(0.65,-2.45) 7(1.1,-2.45) 8(1.55,-2.45) 9(2,-2.45) 10(2.45,-2.45) 16(2.45,0.65) 17(2,0.65) 18(1.55,0.65) 19(1.1,0.65) 20(0.65,0.65)
  rect 0.991x0.991 smd: 21(1.55,-0.9)
T-SOL_5-531809001000-6_15P-T
  round 1.397 hole 0.991: 1(0,0) 2(2.5,0) 3(5,0) 4(6.73,0) 5(8.39,0) 6(10.35,0) 7(12.5,0) 8(15,0) 9(17.42,0) 10(19.17,0) 11(21.07,0)
  rect 1.575x2.489 hole 0.61x1.905: 12(23.745,-7.5) 13(-7.505,-7.5) 14(23.745,-27.15) 15(-7.505,-27.15)
TAI-T_HCB1608KF-221T20_2P
  rect 0.787x0.94 smd: 1(0,0) 2(1.65,0)
TAI-T_HCB2012KF-121T50_2P
  rect 0.813x1.397 smd: 1(0,0) 2(1.702,0)
TAI-T_LAN-8100G_25P
  oval 0.635x1.778 smd: 1(0,0) 2(1,0) 3(2,0) 4(3,0) 5(4,0) 6(5,0) 7(6,0) 8(7,0) 9(8,0) 10(9,0) 11(10,0) 12(11,0) 13(11,8.99) 14(10,8.99) 15(9,8.99) 16(8,8.99) 17(7,8.99) 18(6,8.99) 19(5,8.99) 20(4,8.99) 21(3,8.99) 22(2,8.99) 23(1,8.99) 24(0,8.99)
  rect 0.889x0.787 smd: 25(-1.32,4.54)
TAI-T_TMPC0412HP-2R2MG-Z03_2P
  rect 1.499x2.311 smd: 1(0,0) 2(3.7,0)
TPC12
  round 0.305 smd: 1(0,0)
TPS2546RTER_QFN16_3X3
  oval 0.254x0.889 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 9(1.5,3.1) 10(1,3.1) 11(0.5,3.1) 12(0,3.1)
  oval 0.889x0.254 smd: 5(2.3,0.8) 6(2.3,1.3) 7(2.3,1.8) 8(2.3,2.3) 13(-0.8,2.3) 14(-0.8,1.8) 15(-0.8,1.3) 16(-0.8,0.8)
  rect 1.651x1.651 smd: 17(0.75,1.55)
TPS22966DPUR_SON14_2X3
  oval 0.203x0.762 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.4,2.05) 9(2,2.05) 10(1.6,2.05) 11(1.2,2.05) 12(0.8,2.05) 13(0.4,2.05) 14(0,2.05)
  rect 2.489x0.889 smd: 15(1.2,1.025)
TPS65987DDHRSHR_VQFN56_7X7
  oval 0.991x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 8(0,-2.8) 9(0,-3.2) 10(0,-3.6) 11(0,-4) 12(0,-4.4) 13(0,-4.8) 14(0,-5.2) 29(7,-5.2) 30(7,-4.8) 31(7,-4.4) 32(7,-4) 33(7,-3.6) 34(7,-3.2) 35(7,-2.8) 36(7,-2.4) 37(7,-2) 38(7,-1.6) 39(7,-1.2) 40(7,-0.8) 41(7,-0.4) 42(7,0)
  oval 0.203x0.991 smd: 15(0.9,-6.1) 16(1.3,-6.1) 17(1.7,-6.1) 18(2.1,-6.1) 19(2.5,-6.1) 20(2.9,-6.1) 21(3.3,-6.1) 22(3.7,-6.1) 23(4.1,-6.1) 24(4.5,-6.1) 25(4.9,-6.1) 26(5.3,-6.1) 27(5.7,-6.1) 28(6.1,-6.1) 43(6.1,0.9) 44(5.7,0.9) 45(5.3,0.9) 46(4.9,0.9) 47(4.5,0.9) 48(4.1,0.9) 49(3.7,0.9) 50(3.3,0.9) 51(2.9,0.9) 52(2.5,0.9) 53(2.1,0.9) 54(1.7,0.9) 55(1.3,0.9) 56(0.9,0.9)
  rect 1.753x2.591 smd: 57(1.625,-1.15)
  rect 1.753x2.54 smd: 58(1.625,-4.075)
  rect 3.404x5.512 smd: 59(4.55,-2.6)
TUSB1046-DCIRNQR_WQFN40_4X6
  oval 0.889x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 8(0,-2.8) 21(6.1,-2.8) 22(6.1,-2.4) 23(6.1,-2) 24(6.1,-1.6) 25(6.1,-1.2) 26(6.1,-0.8) 27(6.1,-0.4) 28(6.1,0)
  oval 0.203x0.889 smd: 9(0.85,-3.45) 10(1.25,-3.45) 11(1.65,-3.45) 12(2.05,-3.45) 13(2.45,-3.45) 14(2.85,-3.45) 15(3.25,-3.45) 16(3.65,-3.45) 17(4.05,-3.45) 18(4.45,-3.45) 19(4.85,-3.45) 20(5.25,-3.45) 29(5.25,0.65) 30(4.85,0.65) 31(4.45,0.65) 32(4.05,0.65) 33(3.65,0.65) 34(3.25,0.65) 35(2.85,0.65) 36(2.45,0.65) 37(2.05,0.65) 38(1.65,0.65) 39(1.25,0.65) 40(0.85,0.65)
  rect 4.699x2.692 smd: 41(3.05,-1.4)
TWVM_FPC1020-08RC-MA0HA_8P
  oval 0.61x1.295 smd: 1(0,0) 2(1,0) 3(2,0) 4(3,0) 5(4,0) 6(5,0) 7(6,0) 8(7,0)
  rect 2.489x2.21 smd: 9(-3,-3.05) 10(10,-3.05)
W25X20CLSNIG_SO8
  oval 0.635x1.854 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,5.165) 6(2.54,5.165) 7(1.27,5.165) 8(0,5.165)
Y_X1A000141000200_2P
  rect 0.991x1.803 smd: 1(0,0) 2(2.5,0)
Y_XRCGB24M000F2P51R0_4P
  rect 0.762x0.711 smd: 1(0,0) 2(1.35,0) 3(1.35,1) 4(0,1)
Y_XRCGB25M000F2P18R0_4P
  rect 0.762x0.711 smd: 1(0,0) 2(1.35,0) 3(1.35,1) 4(0,1)
Y_XRCGB27M000F2P18R0_4P
  rect 0.762x0.711 smd: 1(0,0) 2(1.35,0) 3(1.35,1) 4(0,1)
YSUSB2P0-5_SOT-23-6-6
  oval 0.61x0.889 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,2.3) 5(0.95,2.3) 6(0,2.3)

## Nets
1.0VSDGP_ON: PCF5.1 PRF1.2 PRF5.1 PUF1.1
1.0VSDGPU_EN: CG196.2 DG5.2 PRF1.1 RG103.2
1.8VSDGPU_MAIN: QG7.3 RG108.2 UG10.1
1.8VSDGPU_MAIN_EN: QG7.2 RG179.2 RG403.2 UG1.P7 UG27.5
1.8VSDGPU_MAIN_EN#: QG7.5 QG7.6 QG57.2 RG106.2
1.35VS_DGPU_EN: PCW1.1 PRW5.1 PRW6.1 PUW1.3
1.35VS_DGPU_FB: PCW4.1 PRW8.1 PRW10.2 PRW11.1 PUW1.4
1.35VSDGPU_PWR_EN: DG3.1 PRW5.2 RG12.1
1V8_AON_EN_R: CG269.1 DG1.1 RG148.2 UG27.3
1VSDGPU_PG: DG3.3 PRF2.2 PUF1.5 UG11.1
3V_FB: PC312.1 PU301.13
3V_FB_1: PC312.2 PR304.1
3V_SN: PC311.1 PR302.2
5V_3V_EN: PC328.1 PR310.2 PR311.2 PR313.1 PU301.12 PU302.6
5V_FB: PC327.1 PU302.7
5V_FB_1: PC327.2 PR312.1
5V_SN: PC325.1 PR307.2
+0.6V_A_VREFDQ: TC286.1(TP-1) UC1.BP13
+0.6V_B_VREFDQ: CD82.1 RD27.2 UC1.BR13
+0.6V_DDR_VREFCA: CD11.2 CD12.2 CD14.2 JDIMM1.164 RD8.1 RD9.1 RD10.2
+0.6V_DDRB_VREFCA: CD69.2 CD70.2 CD72.2 CD81.2 JDIMM2.164 RD26.1 RD27.1 RD28.2
+0.6V_VREFCA: CD15.1 RD9.2 UC1.BN13
+0.6VS_VTT: CD7.1 CD8.1 CD9.1 CD66.1 CD67.1 CD68.1 JDIMM1.258 JDIMM2.258 PJM3.2
+0.6VSP: PCM5.1 PCM6.1 PJM3.1 PUM1.2 PUM1.20
+0.95VS_VCCIO: CC33.1 CC34.1 CC35.1 CC405.1 PJH2.2 RC1.2 RC9.1 UC1.AG12 UC1.G15 UC1.G17 UC1.G19 UC1.G21 UC1.H15 UC1.H16 UC1.H17 UC1.H19 UC1.H20 UC1.H21 UC1.H26 UC1.H27 UC1.J15 UC1.J16 UC1.J17 UC1.J19 UC1.J20 UC1.J21 UC1.J26 UC1.J27
+0.95VS_VCCIOP: PCH6.1 PCH7.1 PCH8.1 PCH9.1 PCH10.1 PCH11.1 PJH2.1 PLH1.2 PRH4.1
+1.0VSDGPU: CG13.1 CG14.1 CG16.1 CG28.1 CG29.1 CG33.1 CG34.1 CG134.1 CG203.1 CG204.1 CG205.1 CG206.1 CG207.1 CG208.1 CG209.1 CG210.1 CG211.1 CG212.1 CG213.1 CG214.1 PJF2.2 RG391.2 UG1.AC7 UG1.AC8 UG1.AF6 UG1.AG6 UG1.AG8 UG1.AG9 UG1.AG19 UG1.AG21 UG1.AG22 UG1.AG24 UG1.AH21 UG1.AH25
+1.0VSDGPUP: PCF2.1 PCF3.1 PCF4.1 PJF2.1 PLF1.2 PRF4.1
+1.2V_HDMI: CV19.1 CV20.1 CV21.1 CV22.1 CV23.1 CV24.1 CV25.1 CV26.1 CV27.1 CV28.1 CV29.1 CV30.1 CV44.2 RV31.1 UV2.6 UV2.11 UV2.15 UV2.18 UV2.30 UV2.43 UV2.46 UV3.4
+1.2V_VCCPLL_OC: CC36.1 CC37.1 CC401.1 RC374.2 RC375.2 UC1.BH13 UC1.BJ13 UC1.G11
+1.2V_VCCSFR_OC_OUT: RC374.1 UC6.6
+1.2V_VDDQ: CC41.2 CD13.2 CD16.1 CD17.1 CD18.1 CD19.1 CD20.1 CD21.1 CD22.1 CD23.1 CD24.1 CD25.1 CD26.1 CD27.1 CD28.1 CD29.1 CD30.1 CD31.1 CD71.2 CD73.1 CD74.1 CD75.1 CD76.1 CD77.1 CD78.1 CD79.1 CD80.1 CD83.1 CD84.1 CD85.1 CD86.1 CD87.1 CD88.1 CD89.1 CD90.1 CD91.1 CD92.1 CD93.1 CD94.1 CD95.1 CD96.1 CD97.1 JDIMM1.12 JDIMM1.33 JDIMM1.54 JDIMM1.75 JDIMM1.96 JDIMM1.111 JDIMM1.112 JDIMM1.117 JDIMM1.118 JDIMM1.123 JDIMM1.124 JDIMM1.129 JDIMM1.130 JDIMM1.135 JDIMM1.136 JDIMM1.141 JDIMM1.142 JDIMM1.147 JDIMM1.148 JDIMM1.153 JDIMM1.154 JDIMM1.159 JDIMM1.160 JDIMM1.163 JDIMM1.178 JDIMM1.199 JDIMM1.220 JDIMM1.241 JDIMM2.12 JDIMM2.33 JDIMM2.54 JDIMM2.75 JDIMM2.96 JDIMM2.111 JDIMM2.112 JDIMM2.117 JDIMM2.118 JDIMM2.123 JDIMM2.124 JDIMM2.129 JDIMM2.130 JDIMM2.135 JDIMM2.136 JDIMM2.141 JDIMM2.142 JDIMM2.147 JDIMM2.148 JDIMM2.153 JDIMM2.154 JDIMM2.159 JDIMM2.160 JDIMM2.163 JDIMM2.178 JDIMM2.199 JDIMM2.220 JDIMM2.241 PJM2.2 PUM1.19 RC14.2 RD7.2 RD8.2 RD25.2 RD26.2 RH39.2 UC2.5
+1.2V_VDDQ_CPU: CC17.1 CC18.1 CC19.1 CC20.1 CC24.1 CC25.1 CC26.1 CC27.1 CC28.1 CC29.1 CC30.1 CC31.1 CC32.1 CC152.1 CC153.1 CC154.1 CC399.1 RC14.1 RC375.1 UC1.AA6 UC1.AE12 UC1.AF5 UC1.AF6 UC1.AG5 UC1.AG9 UC1.AJ12 UC1.AL11 UC1.AP6 UC1.AP7 UC1.AR6 UC1.AR12 UC1.AT12 UC1.AW6 UC1.AY6 UC1.J5 UC1.J6 UC1.K6 UC1.K12 UC1.L6 UC1.L12 UC1.R6 UC1.T6 UC1.W6 UC1.Y12 UC6.1 UC6.2 UC6.7
+1.2VP: CD32.1 PCM8.1 PCM9.1 PCM10.1 PCM11.1 PCM12.1 PCM13.1 PJM2.1 PLM1.1 PRM6.2 PUM1.5
+1.05V_BCLKPLL2: CH23.1 CH106.1 RH88.2 UH1.B1 UH1.B2 UH1.B3
+1.05V_CNV_HVLDO: RH57.2 UH1.AE17
+1.05V_FHV0: RH120.2 UH1.AF31
+1.05V_FHV1: RH119.2 UH1.AG31
+1.05V_FUSE: RH56.2 UH1.AD31
+1.05V_OC: CH22.1 RH87.2 UH1.V19
+1.05V_OCPLL1: CH21.1 CH105.1 RH86.2 UH1.C1 UH1.C2
+1.05V_PCH: CH24.1 RH56.1 RH57.1 RH58.1 RH59.1 RH61.1 RH83.1 RH84.1 RH85.1 RH86.1 RH87.1 RH88.1 RH119.1 RH120.1 RH160.1
+1.05V_PCH_PRIM: CH62.1 RH55.1 UH1.AA22 UH1.AA23 UH1.AB20 UH1.AB22 UH1.AB23 UH1.AB27 UH1.AB28 UH1.AB30 UH1.AD20 UH1.AD23 UH1.AD27 UH1.AD28 UH1.AD30 UH1.AF23 UH1.AF27 UH1.AF30
+1.05V_SRC: RH85.2 UH1.W19 UH1.W20
+1.05V_VCCAMPHYPLL: CH18.1 CH19.1 CH104.1 RH61.2 UH1.C49 UH1.D49 UH1.E49
+1.05V_VCCAZPLL: CH17.1 RH84.2 UH1.D1 UH1.E1
+1.05V_VCCCLPLLEBB: CH15.1 RH59.2 UH1.W31
+1.05V_VCCDSW: CH16.1 UH1.BG45 UH1.BG46
+1.05V_VCCMPHY: CH12.1 CH13.1 RH54.1 UH1.U26 UH1.U29 UH1.V25 UH1.V27 UH1.V28 UH1.V30 UH1.V31
+1.05V_VCCSFR: CC39.1 CH102.1 CH103.1 RC143.2 UC1.H28 UC1.J28
+1.05V_VCCST: CC38.1 CC406.1 CK16.1 PCZ3.2 PRZ5.1 PRZ6.2 PRZ7.1 PRZ8.1 RC20.2 RC40.1 RC41.2 RC140.2 RH166.1 UC1.H30 UK1.117
+1.05V_VCCSTU: CC391.1 RC140.1 RC143.1 UC4.13 UC4.14
+1.05V_VCCUSB: CH14.1 RH58.2 UH1.W22 UH1.W23
+1.05V_XTAL: CH20.1 CH101.1 CH109.1 RH83.2 UH1.P2 UH1.P3
+1.05VALW: CC390.1 CC396.1 PJ1002.2 RC383.1 RH54.2 RH55.2 RH160.2 UC4.1 UC4.2 UC5.1 UC5.2 UC5.7
+1.05VALWP: PC1004.1 PC1005.1 PC1006.1 PC1007.1 PC1008.1 PJ1002.1 PL1001.2 PR1006.1
+1.05VS_VCCSTG: CC40.1 CC398.1 RC18.2 RC380.2 RC381.2 RC384.2 UC1.G30 UC1.H29 UC5.6
+1.8V_PG: PR1003.1 PR1801.2 PU1801.2
+1.8V_PHVLDO: RH172.1 UH1.AF19 UH1.AF20
+1.8V_PRIM: CH29.1 CH35.1 CH63.1 CH86.1 RH26.1 RH93.2 RH146.2 RH147.2 RH148.2 RH150.2 RH161.2 RH167.2 RH172.2 RWL12.1 RWL13.1 UH1.AG19 UH1.AG20 UH1.AN15 UH1.AR15 UH1.BB11
+1.8V_TBTC_PDLDO: CU69.1 CU74.1 UU4.35
+1.8VALW: CC394.1 CG339.1 CG574.1 CG575.1 CG576.1 PJ1802.2 RH161.1 UC4.6 UC4.7 UG27.1 UG27.2 UG27.6 UG27.7
+1.8VALWP: PC1802.1 PC1803.1 PC1804.1 PJ1802.1 PL1801.2 PR1803.1
+1.8VS: CC395.1 LA3.2 PRV5.1 UC4.8 UC4.9
+1.8VS_AVDD: CA13.1 CA14.2 LA3.1 UA1.20
+1.8VSDGPU_AON: CG49.1 CG50.1 CG51.1 CG135.1 CG334.1 CG340.1 CG563.1 CG568.1 CG572.1 QV2.2 QV2.5 RG5.2 RG6.2 RG7.1 RG34.1 RG35.2 RG36.2 RG37.1 RG38.1 RG39.1 RG83.2 RG85.2 RG86.2 RG100.1 RG124.2 RG125.2 RG126.2 RG127.2 RG128.2 RG129.2 RG130.2 RG131.2 RG132.2 RG179.1 RG180.1 RG394.1 RG396.1 RG397.1 RG398.1 RG399.1 RG400.1 RG403.1 RG407.1 RV36.2 RV37.2 UG1.J8 UG1.K8 UG8.5 UG27.13 UG27.14 UG28.5 UG29.5
+1.8VSDGPU_MAIN: CG15.1 CG17.1 CG25.1 CG27.1 CG30.1 CG31.1 CG32.1 CG43.1 CG52.1 CG53.1 CG54.1 CG55.1 CG136.1 CG137.1 CG338.1 CG564.1 CG565.1 CG566.1 CG567.1 CG569.1 CG570.1 CG571.1 CG573.1 LG1.2 LG3.1 QG2.2 QG2.5 RG3019.1 UG1.AG13 UG1.AG15 UG1.AG16 UG1.AG18 UG1.AG25 UG1.AH12 UG1.AH15 UG1.AH18 UG1.AH26 UG1.AH27 UG1.AJ27 UG1.AK27 UG1.AL27 UG1.AM28 UG1.AN28 UG1.L8 UG1.M8 UG8.2 UG27.8 UG27.9
+1.24V_PRIM_DPHY: RH174.1 UH1.AJ22 UH1.AJ23
+1.24V_PRIM_MAR: CH36.1 UH1.BG5
+1.24V_VCCLDOSRAM_IN: RH174.2 UH1.AK22 UH1.AK23
+1.35VRAMP: PCW11.1 PJW1.1 PJW2.1 PLW1.2 PRW9.1
+1.35VSDGPU: CG18.1 CG19.1 CG20.1 CG21.1 CG22.1 CG23.1 CG24.1 CG26.1 CG36.1 CG37.1 CG38.1 CG39.1 CG40.1 CG41.1 CG56.1 CG57.1 CG58.1 CG59.1 CG60.1 CG61.1 CG62.1 CG63.1 CG64.1 CG65.1 CG66.1 CG67.1 CG68.1 CG69.1 CG70.1 CG71.1 CG72.1 CG73.1 CG74.1 CG75.1 CG76.1 CG77.1 CG78.1 CG79.1 CG80.1 CG81.1 CG82.1 CG83.1 CG84.1 CG85.1 CG86.1 CG87.1 CG90.1 CG91.1 CG92.1 CG93.1 CG94.1 CG95.1 CG96.1 CG97.1 CG98.1 CG99.1 CG100.1 CG101.1 CG102.1 CG103.1 CG104.1 CG105.1 CG106.1 CG107.1 CG108.1 CG109.1 CG110.1 CG111.1 CG112.1 CG113.1 CG114.1 CG115.1 CG116.1 CG117.1 CG118.1 CG119.1 CG120.1 CG121.1 CG126.1 CG127.1 CG128.1 CG129.1 CG130.1 CG131.1 CG132.1 CG133.1 CG138.1 CG139.1 CG140.1 CG141.1 CG142.1 CG143.1 CG144.1 CG145.1 CG146.1 CG147.1 CG148.1 CG149.1 CG150.1 CG151.1 CG152.1 CG153.1 CG154.1 CG155.1 CG156.1 CG157.1 CG158.1 CG159.1 CG160.1 CG161.1 CG162.1 CG163.1 CG164.1 CG165.1 CG166.1 CG167.1 CG168.1 CG169.1 CG170.1 CG171.1 CG172.1 CG173.1 CG174.1 CG175.1 CG176.1 CG177.1 CG178.1 CG179.1 CG180.1 CG181.1 CG182.1 CG183.1 CG184.1 CG185.1 CG186.1 CG187.1 CG188.1 CG189.1 CG202.1 CG217.1 CG218.1 CG219.1 CG220.1 CG221.1 CG222.1 CG223.1 PJW1.2 PJW2.2 RG45.2 RG47.1 RG50.1 RG53.1 RG55.1 RG64.1 RG67.1 RG69.1 RG87.1 RG88.1 RG91.1 RG92.1 UG1.AA27 UG1.AA30 UG1.AB27 UG1.AB33 UG1.AC27 UG1.AD27 UG1.AE27 UG1.AF27 UG1.AG27 UG1.B13 UG1.B16 UG1.B19 UG1.E13 UG1.E16 UG1.E19 UG1.H8 UG1.H9 UG1.H10 UG1.H11 UG1.H12 UG1.H13 UG1.H14 UG1.H15 UG1.H16 UG1.H18 UG1.H19 UG1.H20 UG1.H21 UG1.H22 UG1.H23 UG1.H24 UG1.L27 UG1.M27 UG1.N27 UG1.P27 UG1.R27 UG1.T27 UG1.T30 UG1.T33 UG1.V27 UG1.W27 UG1.W30 UG1.W33 UG1.Y27 UG4.B1 UG4.B3 UG4.B12 UG4.B14 UG4.C5 UG4.C10 UG4.D1 UG4.D3 UG4.D11 UG4.D12 UG4.D14 UG4.E5 UG4.E10 UG4.F1 UG4.F3 UG4.F12 UG4.F14 UG4.G1 UG4.G2 UG4.G4 UG4.G11 UG4.G13 UG4.G14 UG4.H3 UG4.H12 UG4.K3 UG4.K12 UG4.L1 UG4.L2 UG4.L4 UG4.L11 UG4.L13 UG4.L14 UG4.M1 UG4.M3 UG4.M12 UG4.M14 UG4.N5 UG4.N10 UG4.P1 UG4.P3 UG4.P11 UG4.P12 UG4.P14 UG4.R5 UG4.R10 UG4.T1 UG4.T3 UG4.T12 UG4.T14 UG5.B1 UG5.B3 UG5.B12 UG5.B14 UG5.C5 UG5.C10 UG5.D1 UG5.D3 UG5.D11 UG5.D12 UG5.D14 UG5.E5 UG5.E10 UG5.F1 UG5.F3 UG5.F12 UG5.F14 UG5.G1 UG5.G2 UG5.G4 UG5.G11 UG5.G13 UG5.G14 UG5.H3 UG5.H12 UG5.K3 UG5.K12 UG5.L1 UG5.L2 UG5.L4 UG5.L11 UG5.L13 UG5.L14 UG5.M1 UG5.M3 UG5.M12 UG5.M14 UG5.N5 UG5.N10 UG5.P1 UG5.P3 UG5.P11 UG5.P12 UG5.P14 UG5.R5 UG5.R10 UG5.T1 UG5.T3 UG5.T12 UG5.T14 UG6.B1 UG6.B3 UG6.B12 UG6.B14 UG6.C5 UG6.C10 UG6.D1 UG6.D3 UG6.D11 UG6.D12 UG6.D14 UG6.E5 UG6.E10 UG6.F1 UG6.F3 UG6.F12 UG6.F14 UG6.G1 UG6.G2 UG6.G4 UG6.G11 UG6.G13 UG6.G14 UG6.H3 UG6.H12 UG6.K3 UG6.K12 UG6.L1 UG6.L2 UG6.L4 UG6.L11 UG6.L13 UG6.L14 UG6.M1 UG6.M3 UG6.M12 UG6.M14 UG6.N5 UG6.N10 UG6.P1 UG6.P3 UG6.P11 UG6.P12 UG6.P14 UG6.R5 UG6.R10 UG6.T1 UG6.T3 UG6.T12 UG6.T14 UG7.B1 UG7.B3 UG7.B12 UG7.B14 UG7.C5 UG7.C10 UG7.D1 UG7.D3 UG7.D11 UG7.D12 UG7.D14 UG7.E5 UG7.E10 UG7.F1 UG7.F3 UG7.F12 UG7.F14 UG7.G1 UG7.G2 UG7.G4 UG7.G11 UG7.G13 UG7.G14 UG7.H3 UG7.H12 UG7.K3 UG7.K12 UG7.L1 UG7.L2 UG7.L4 UG7.L11 UG7.L13 UG7.L14 UG7.M1 UG7.M3 UG7.M12 UG7.M14 UG7.N5 UG7.N10 UG7.P1 UG7.P3 UG7.P11 UG7.P12 UG7.P14 UG7.R5 UG7.R10 UG7.T1 UG7.T3 UG7.T12 UG7.T14
+2.5V: CD3.1 CD4.1 CD5.1 CD6.1 CD62.1 CD63.1 CD64.1 CD65.1 CD98.1 CD99.1 CD100.1 CD101.1 JDIMM1.257 JDIMM1.259 JDIMM2.257 JDIMM2.259 PJ2502.2
+2.5VP: PC2504.1 PC2505.1 PC2506.1 PJ2502.1 PL2501.2 PR2506.1
+3.3V_HDA: CH64.1 RH117.1 RH163.2 UH1.BB14
+3V_1.8V_PGPPA: RH44.2 RH64.1 RH67.2 RH143.2 RH150.1 RH155.2 RH169.2 RH181.2 RH255.2 RH257.2 UH1.AN32
+3V_1.8V_PGPPD: RH141.2 RH148.1 UH1.AN24
+3V_1.8V_PGPPEF: CH33.1 RH140.2 RH147.1 RH191.2 UH1.AE35 UH1.AE36
+3V_1.8V_PGPPHK: CH32.1 RH99.2 RH100.1 RH139.2 RH146.1 RH202.2 RH203.2 UH1.AC35 UH1.AC36
+3V_GSEN: C5245.2 C5246.2 C5247.2 D511.1 R5247.2 R5798.2 R5801.1 U9.9 U9.10
+3V_LDO3V3: QT2.3 RU65.1 UU4.9
+3V_LID: C395.1 D508.1 PR18.1 PR21.2 R13.2 R125.2 R5242.1 R5243.1 RH92.2 RK33.1 U7.2 U4019.8
+3V_PCH_PRIM: C408.1 C5278.2 DH4.2 JP3.2 PR1801.1 QC7.2 QC7.5 QC10.2 QC10.5 R5219.2 RH33.1 RH34.1 RH35.1 RH36.1 RH37.1 RH38.1 RH63.1 RH90.1 RH91.1 RH95.1 RH97.1 RH125.1 RH138.1 RH139.1 RH140.1 RH141.1 RH143.1 RH163.1 RH178.1 RH179.1 RH180.1 RH182.2 RH192.1 RH194.1 RH195.1 RH213.1 RH214.2 RH215.2 RH216.2 RH217.2 RH218.2 RH219.2 RH220.2 RH221.2 RH222.2 RH223.2 RH224.2 RH225.2 RH226.2 RH227.2 RH230.2 RH231.2 U11.7 U11.8 UH1.AN21 UH1.AN26 UH1.AP26 UH1.AT44
+3V_PHVC: RH90.2 UH1.AW9
+3V_PHVLDO: CH30.1 CH31.1 CH85.1 RH125.2 UH1.AY8 UH1.BB7
+3V_SMBUS: D510.1 D514.1 D517.1 RH232.2 RH233.2
+3V_SPI: CH2.1 RH3.2 RH4.2 RH98.2 RH138.2 RH175.1 UH1.AN44 UH2.8
+3V_TBTC_PDLDO: CU71.1 CU72.1 QT2.1 RU51.1 RU65.2 RU66.1 RU67.1 RU68.1 RU69.1 RU70.1 RU71.1 UU5.8
+3V_USB2: RH91.2 RH263.1 UH1.V23
+3VALW: C388.1 C401.1 C5275.2 C5277.1 CL28.1 CW1.1 D1.2 DM5.5 JL33.1 JP3.1 JPWR1.5 JTP1.8 PC1014.1 PCH14.1 PJ302.2 PJ1801.1 PJ2501.1 PJF1.1 PR303.1 PR1004.1 PR2504.1 PRH9.1 PRM8.1 PRV29.1 PU1001.15 PUH1.15 QWL2.3 RC934.2 RH12.1 RH162.1 RH260.2 RH263.2 RK12.2 RK13.2 RR1.1 RU53.2 RU78.1 RWL8.2 RWL31.1 U10.1 U10.2 U11.1 U11.2 U11.4 UL2.5
+3VALW_DSW: CH34.1 RH41.2 RH45.2 RH47.2 RH162.2 RH171.2 RH211.1 UH1.BE48 UH1.BE49
+3VALW_EC: CK1.1 CK2.1 CK8.1 LK1.1 PR9.1 PR10.1 RG200.2 RK1.2 RK2.2 RK7.2 RK21.1 RK32.1 UK1.9 UK1.22 UK1.33 UK1.96 UK1.124
+3VALWP: PC306.1 PC307.1 PC308.1 PC309.1 PJ302.1 PL301.3 PL301.4 PR304.2 PU301.14
+3VB_1.8V: PC1801.1 PJ1801.2 PU1801.3
+3VDS_AUDIO: CA3.1 CA4.1 LA1.1 RA25.1 RA26.1 UA1.18
+3VL: D508.2 D510.2 D511.2 DH1.3 PJ303.2 PQ2.2 PR16.1 PRB44.1 Q32.2 Q80.2 R295.2 RH234.2 RH235.2 RK1.1 RS17.2 RS43.1 RU52.2
+3VL_RTC: CH26.1 CH27.1 CH84.1 DH1.1 RH6.1 RH31.1 RH32.1 UH1.BC49 UH1.BD49
+3VL_TBTC: CU70.1 RU52.1 RU53.1 UU4.5
+3VLP: PC310.1 PJ303.1 PU301.16 PU301.17
+3VS: C400.1 C5251.1 C5254.1 C5263.1 CD1.2 CD2.2 CD60.2 CD61.2 CD102.2 CD103.2 CH1.1 CV31.1 CV32.1 CV33.1 CV43.2 CV53.2 CV274.1 JDIMM1.255 JDIMM2.255 JIO1.6 JP4.1 LA1.2 PRF2.1 PRW1.1 PRZ18.1 Q7.2 Q7.5 QC8.2 QC8.5 QC9.2 QC9.5 QR2.2 QV1.2 QWL1.2 R1.1 R5220.1 R5247.1 R5284.2 R5285.2 R5807.1 RA3.1 RA54.1 RC43.1 RC376.2 RC377.2 RD1.1 RD2.1 RD4.1 RD19.1 RD20.1 RD21.1 RE1.1 RE3.1 RG14.1 RG106.1 RG108.1 RG111.1 RG113.1 RG392.2 RH53.2 RH76.2 RH78.2 RH79.2 RH81.2 RH82.1 RH94.1 RH96.1 RH154.1 RH164.1 RH170.2 RH205.1 RH206.1 RH207.1 RH208.1 RH209.1 RH228.2 RH229.2 RK14.1 RM6.1 RR15.2 RT6.1 RU57.1 RU58.1 RU61.1 RV14.1 RV16.1 RV21.1 RV23.1 RV26.1 RV30.2 RV34.1 RV35.1 RV38.1 RV135.2 RV136.1 U10.13 U10.14 U12.6 UC3.1 UG10.5 UG11.5 UH3.5 UV2.1 UV2.24 UV3.3
+3VS_CAMERA: C5253.1 C5255.1 C5274.2 JEDP1.10 R5806.2 U12.1
+3VS_CR: CR2.1 CR7.1 R1.2 RR2.1 UR1.11
+3VS_MUX: CT270.1 CT271.1 CT272.1 CT273.1 CT274.1 RT6.2 RT807.2 RT813.1 RT814.1 RT841.1 RT847.1 RT850.1 RT853.1 RT856.1 RT859.2 RT1115.2 UT11.1 UT11.6 UT11.20 UT11.28
+3VS_SSD: C365.1 C366.1 C367.1 C368.1 C409.1 C410.1 C5249.1 C5250.1 JP4.2 JSSD1.2 JSSD1.4 JSSD1.12 JSSD1.14 JSSD1.16 JSSD1.18 JSSD1.62 JSSD1.64 JSSD1.66
+3VS_TPM: CTT1.1 CTT2.1 CTT3.1 CTT4.1 CTT323.1 RC934.1 RTT10.2 RTT35.1 UT1.1 UT1.8 UT1.14 UT1.22
+3VS_WLAN: CWL2.1 CWL3.1 CWL4.1 CWL5.1 CWL7.1 CWL8.1 JWLAN1.2 JWLAN1.4 JWLAN1.64 JWLAN1.66 QWL2.1 RWL3.2 RWL4.1 RWL8.1
+5V_HDMI: CV45.1 CV52.2 JHDMI1.18 RV27.2 RV28.2 UV4.3
+5V_TYPEC: CU57.2 CU58.2 CU59.1 CU60.2 DU13.2 DU13.3 JPHW8.2 JUSBC1.A4 JUSBC1.A9 JUSBC1.B4 JUSBC1.B9
+5V_TYPEC_L: CU63.1 CU64.1 CU65.1 JPHW8.1 UU4.13 UU4.14
+5VALW: C402.1 C405.1 C5276.2 CC389.1 CC397.1 CC402.1 CC407.1 CS21.1 CS113.1 CS114.1 CU61.2 CU62.1 CU73.1 JIO1.1 JIO1.2 JIO1.3 JIO1.4 JIO1.5 LV2.1 PCA6.1 PCG6.1 PCP3.1 PCP327.1 PCP328.1 PCP329.1 PCP330.1 PCP331.1 PCW3.1 PCW12.1 PCW13.1 PCW14.1 PCZ39.1 PCZ53.1 PCZ60.1 PCZ67.1 PJ305.2 PRM4.1 PRM5.1 PRV27.1 PRV32.1 PRV34.2 PRZ47.1 PRZ56.1 PRZ72.1 PUA1.4 PUG1.4 PUP1.1 PUW1.7 PUZ2.4 PUZ3.4 PUZ4.4 PUZ5.4 RV51.1 U10.4 U10.6 U10.7 UC4.4 UC5.3 UC6.3 US3.1 US3.2 US3.3 UU4.11 UU4.12 UU4.25
+5VALWP: PC319.1 PC320.1 PC321.1 PC322.1 PC323.1 PC324.1 PC330.1 PC331.1 PC332.1 PC333.1 PJ305.1 PL302.3 PL302.4 PR312.2 PU302.8
+5VL: PJ306.2 RS9.2
+5VLP: PC326.1 PJ306.1 PU302.9
+5VS: C406.1 C5260.1 CA91.1 CA92.2 CE1.1 CE2.1 CE3.1 CE4.1 CE7.1 CE8.1 CG337.1 DA1.1 JFAN1.1 JFAN2.1 JKB1.27 JKB1.32 LA2.2 LA4.2 R23.1 R24.1 R5221.1 R5222.1 RE2.1 RE4.1 RG214.2 U10.8 U10.9 UG27.4 UV4.1
+5VS_AVDD: CA11.1 CA12.2 LA2.1 UA1.33 UA1.40
+5VS_HDD1: C381.2 C411.1 C412.1 JHDD1.1 JHDD1.2 JHDD1.3 R5221.2 R5222.2
+5VS_KBL: JKBL1.3 JKBL1.4 R24.2
+5VS_PVDD: CA21.1 CA22.1 CA24.2 CA25.2 LA4.1 UA1.41 UA1.46
+16.8V_BATT: PC9.1 PC11.1 PCB19.1 PCB20.1 PCB33.1 PCB34.1 PDB01.3 PL13.2 PL14.2 PRB06.2 PRB08.4
+16.8V_BATT+: PC8.1 PC10.1 PJPB1.1 PJPB1.2 PJPB1.3 PJPB1.4 PL13.1 PL14.1 PR22.1
+16.8V_BATT_CHG: PCB12.2 PLB02.2 PQB04.1 PQB04.2 PQB04.3 PRB08.1
+19V_ADPIN: PC1.1 PC2.1 PD1.2 PJP1.9 PJP1.10 PJP1.11 PJP1.12 PL11.1 PL12.1
+19V_P1: PCB02.1 PQB01.1 PQB01.2 PQB01.3 PQB02.3 PQB03.1 PQB03.2 PQB03.3 PRB02.2 PRB04.1
+19V_P2: PQB03.5 PRB03.1
+19V_VIN: PC3.1 PC4.1 PCB01.1 PDB01.2 PL11.2 PL12.2 PQB01.5 PRB10.1
+19VB: LV1.1 PJ301.1 PJ304.1 PJ1001.1 PJB1.1 PJH1.1 PJM1.1 PJPP2.1 PJV1.1 PJW5.2 PJZ1.2 PQB04.5 PR19.1 PR306.1 PRB03.4 RS39.2 RS40.1
+19VB_1.35VSDGPUP: PCW7.1 PCW8.1 PCW9.1 PCW10.1 PJW5.1 PQW1.5
+19VB_1V5: PC1011.1 PC1012.1 PC1013.1 PJ1001.2 PU1001.2 PU1001.3 PU1001.4 PU1001.5
+19VB_3V: PC301.1 PC303.1 PC305.1 PJ301.2 PU301.2 PU301.3 PU301.4 PU301.5
+19VB_5V: PC314.1 PC316.1 PC317.1 PJ304.2 PU302.1
+19VB_CHG: PCB08.1 PCB09.1 PCB10.1 PCB11.1 PJB1.2 PQB05.2 PQB05.3 PQB05.4 PQB05.10
+19VB_CPU: PCA1.1 PCA2.1 PCA3.1 PCA4.1 PCG1.1 PCG2.1 PCG3.1 PCG4.1 PCZ40.1 PCZ41.1 PCZ42.1 PCZ43.1 PCZ44.1 PCZ45.1 PCZ48.1 PCZ49.1 PCZ50.1 PCZ51.1 PCZ55.1 PCZ56.1 PCZ57.1 PCZ58.1 PCZ62.1 PCZ63.1 PCZ64.1 PCZ65.1 PJZ1.1 PQA1.2 PQA1.3 PQA1.4 PQA1.10 PQG1.3 PQG1.4 PQG1.9 PQZ1.3 PQZ1.4 PQZ1.9 PQZ2.3 PQZ2.4 PQZ2.9 PQZ3.3 PQZ3.4 PQZ3.9 PQZ4.3 PQZ4.4 PQZ4.9 PRZ55.1
+19VB_DDR: PCM1.1 PCM2.1 PJM1.2 PQM1.2 PQM1.3 PQM1.4 PQM1.10 PRM7.1
+19VB_GPU_NVVDD: PCV2.1 PCV3.1 PCV4.1 PCV5.1 PCV6.1 PCV7.1 PCV11.1 PCV12.1 PCV13.1 PCV14.1 PCV22.1 PCV23.1 PCV24.1 PCV25.1 PJV1.2 PQV1.3 PQV1.4 PQV1.9 PQV2.3 PQV2.4 PQV2.9 PQV3.3 PQV3.4 PQV3.9 PRV18.1
+19VB_INVPWR: PCP1.1 PCP2.1 PJPP2.2 PLP1.1
+19VB_VCCIOP: PCH1.1 PCH3.1 PCH5.1 PJH1.2 PUH1.2 PUH1.3 PUH1.4 PUH1.5
+AVDD33: CR3.1 CR6.1 RR1.2 RR2.2 RR11.2 RR12.1 UR1.27
+DVDD: CA1.1 CA2.1 RA3.2 RA16.2 UA1.3
+V12_I: CR9.1 CR10.1 RR14.2 UR1.14
+V12_O: CR16.1 RR14.1 UR1.10
+VCC0: CK13.1 RK32.2 RK33.2 UK1.111
+VCC_CORE: PCZ173.1 PCZ174.1 PCZ175.1 PCZ176.1 PCZ177.1 PCZ178.1 PCZ179.1 PCZ180.1 PCZ181.1 PCZ182.1 PCZ183.1 PCZ184.1 PCZ185.1 PCZ186.1 PCZ187.1 PCZ188.1 PCZ189.1 PCZ190.1 PCZ191.1 PCZ192.1 PCZ193.1 PCZ217.1 PCZ218.1 PCZ219.1 PCZ220.1 PCZ221.1 PCZ222.1 PCZ223.1 PCZ224.1 PCZ225.1 PCZ226.1 PCZ227.1 PCZ228.1 PCZ229.1 PCZ230.1 PCZ231.1 PCZ232.1 PCZ233.1 PCZ234.1 PCZ235.1 PCZ236.1 PCZ237.1 PCZ238.1 PCZ239.1 PCZ240.1 PCZ307.1 PCZ308.1 PCZ309.1 PCZ310.1 PCZ311.1 PCZ312.1 PCZ313.1 PCZ314.1 PCZ315.1 PLZ1.4 PLZ2.4 PLZ3.4 PLZ4.4 RC10.2 UC1.AA13 UC1.AA31 UC1.AA32 UC1.AA33 UC1.AA34 UC1.AA35 UC1.AA36 UC1.AA37 UC1.AA38 UC1.AB29 UC1.AB30 UC1.AB31 UC1.AB32 UC1.AB35 UC1.AB36 UC1.AB37 UC1.AB38 UC1.AC13 UC1.AC14 UC1.AC29 UC1.AC30 UC1.AC31 UC1.AC32 UC1.AC33 UC1.AC34 UC1.AC35 UC1.AC36 UC1.AD13 UC1.AD14 UC1.AD31 UC1.AD32 UC1.AD33 UC1.AD34 UC1.AD35 UC1.AD36 UC1.AD37 UC1.AD38 UC1.AE13 UC1.AE14 UC1.AE30 UC1.AE31 UC1.AE32 UC1.AE35 UC1.AE36 UC1.AE37 UC1.AE38 UC1.AF29 UC1.AF30 UC1.AF31 UC1.AF32 UC1.AF33 UC1.AF34 UC1.AF35 UC1.AF36 UC1.AF37 UC1.AF38 UC1.AG14 UC1.AG31 UC1.AG32 UC1.AG33 UC1.AG34 UC1.AG35 UC1.AG36 UC1.AH13 UC1.AH14 UC1.AH29 UC1.AH30 UC1.AH31 UC1.AH32 UC1.AJ14 UC1.AJ29 UC1.AJ30 UC1.AJ31 UC1.AJ32 UC1.AJ33 UC1.AJ34 UC1.AJ35 UC1.AJ36 UC1.AK31 UC1.AK32 UC1.AK33 UC1.AK34 UC1.AK35 UC1.AK36 UC1.AK37 UC1.AK38 UC1.AL13 UC1.AL29 UC1.AL30 UC1.AL31 UC1.AL32 UC1.AL35 UC1.AL36 UC1.AL37 UC1.AL38 UC1.AM13 UC1.AM14 UC1.AM29 UC1.AM30 UC1.AM31 UC1.AM32 UC1.AM33 UC1.AM34 UC1.AM35 UC1.AM36 UC1.AN13 UC1.AN14 UC1.AN31 UC1.AN32 UC1.AN33 UC1.AN34 UC1.AN35 UC1.AN36 UC1.AN37 UC1.AN38 UC1.AP13 UC1.AP30 UC1.AP31 UC1.AP32 UC1.AP35 UC1.AP36 UC1.AP37 UC1.AP38 UC1.K13 UC1.K14 UC1.L13 UC1.L14 UC1.N13 UC1.N14 UC1.N30 UC1.N31 UC1.N32 UC1.N35 UC1.N36 UC1.N37 UC1.N38 UC1.P13 UC1.P14 UC1.P29 UC1.P30 UC1.P31 UC1.P32 UC1.P33 UC1.P34 UC1.P35 UC1.P36 UC1.R13 UC1.R31 UC1.R32 UC1.R33 UC1.R34 UC1.R35 UC1.R36 UC1.R37 UC1.R38 UC1.T29 UC1.T30 UC1.T31 UC1.T32 UC1.T35 UC1.T36 UC1.T37 UC1.T38 UC1.U29 UC1.U30 UC1.U31 UC1.U32 UC1.U33 UC1.U34 UC1.U35 UC1.U36 UC1.V13 UC1.V14 UC1.V31 UC1.V32 UC1.V33 UC1.V34 UC1.V35 UC1.V36 UC1.V37 UC1.V38 UC1.W13 UC1.W14 UC1.W29 UC1.W30 UC1.W31 UC1.W32 UC1.W35 UC1.W36 UC1.W37 UC1.W38 UC1.Y29 UC1.Y30 UC1.Y31 UC1.Y32 UC1.Y33 UC1.Y34 UC1.Y35 UC1.Y36
+VCC_GT: PCG55.1 PCG56.1 PCG57.1 PCG58.1 PCG59.1 PCG60.1 PCG61.1 PCG62.1 PCG63.1 PCG64.1 PCG65.1 PCG66.1 PCG75.1 PCG76.1 PCG77.1 PCG78.1 PCG79.1 PCG80.1 PCG81.1 PCG82.1 PCG83.1 PCG84.1 PCG85.1 PCG86.1 PLG1.4 RC12.2 UC1.AT14 UC1.AT31 UC1.AT32 UC1.AT33 UC1.AT34 UC1.AT35 UC1.AT36 UC1.AT37 UC1.AT38 UC1.AU14 UC1.AU29 UC1.AU30 UC1.AU31 UC1.AU32 UC1.AU35 UC1.AU36 UC1.AU37 UC1.AU38 UC1.AV29 UC1.AV30 UC1.AV31 UC1.AV32 UC1.AV33 UC1.AV34 UC1.AV35 UC1.AV36 UC1.AW14 UC1.AW31 UC1.AW32 UC1.AW33 UC1.AW34 UC1.AW35 UC1.AW36 UC1.AW37 UC1.AW38 UC1.AY29 UC1.AY30 UC1.AY31 UC1.AY32 UC1.AY35 UC1.AY36 UC1.AY37 UC1.AY38 UC1.BA13 UC1.BA14 UC1.BA29 UC1.BA30 UC1.BA31 UC1.BA32 UC1.BA33 UC1.BA34 UC1.BA35 UC1.BA36 UC1.BB13 UC1.BB14 UC1.BB31 UC1.BB32 UC1.BB33 UC1.BB34 UC1.BB35 UC1.BB36 UC1.BB37 UC1.BB38 UC1.BC29 UC1.BC30 UC1.BC31 UC1.BC32 UC1.BC35 UC1.BC36 UC1.BC37 UC1.BC38 UC1.BD13 UC1.BD14 UC1.BD29 UC1.BD30 UC1.BD31 UC1.BD32 UC1.BD33 UC1.BD34 UC1.BD35 UC1.BD36 UC1.BE31 UC1.BE32 UC1.BE33 UC1.BE34 UC1.BE35 UC1.BE36 UC1.BE37 UC1.BE38 UC1.BF13 UC1.BF14 UC1.BF29 UC1.BF30 UC1.BF31 UC1.BF32 UC1.BF35 UC1.BF36 UC1.BF37 UC1.BF38 UC1.BG29 UC1.BG30 UC1.BG31 UC1.BG32 UC1.BG33 UC1.BG34 UC1.BG35 UC1.BG36 UC1.BH33 UC1.BH34 UC1.BH35 UC1.BH36 UC1.BH37 UC1.BH38 UC1.BJ16 UC1.BJ17 UC1.BJ19 UC1.BJ20 UC1.BJ21 UC1.BJ23 UC1.BJ24 UC1.BJ26 UC1.BJ27 UC1.BJ37 UC1.BJ38 UC1.BK16 UC1.BK17 UC1.BK19 UC1.BK20 UC1.BK21 UC1.BK23 UC1.BK24 UC1.BK26 UC1.BK27 UC1.BL15 UC1.BL16 UC1.BL17 UC1.BL23 UC1.BL24 UC1.BL25 UC1.BL26 UC1.BL27 UC1.BL28 UC1.BL36 UC1.BL37 UC1.BM15 UC1.BM16 UC1.BM17 UC1.BM36 UC1.BM37 UC1.BN15 UC1.BN16 UC1.BN17 UC1.BN36 UC1.BN37 UC1.BN38 UC1.BP15 UC1.BP16 UC1.BP17 UC1.BP37 UC1.BP38 UC1.BR15 UC1.BR16 UC1.BR17 UC1.BR37 UC1.BT15 UC1.BT16 UC1.BT17 UC1.BT37
+VCC_SA: PCA23.1 PCA25.1 PCA26.1 PCA27.1 PCA28.1 PCA29.1 PCA30.1 PCA31.1 PCA32.1 PCA33.1 PCA34.1 PLA1.4 RC15.2 UC1.J30 UC1.K29 UC1.K30 UC1.K31 UC1.K32 UC1.K33 UC1.K34 UC1.K35 UC1.L31 UC1.L32 UC1.L35 UC1.L36 UC1.L37 UC1.L38 UC1.M29 UC1.M30 UC1.M31 UC1.M32 UC1.M33 UC1.M34 UC1.M35 UC1.M36
+VCCRTCEXT: CH25.1 UH1.BF47 UH1.BG47
GND: C365.2 C366.2 C367.2 C368.2 C381.1 C388.2 C389.1 C390.2 C391.2 C393.2 C394.2 C395.2 C400.2 C401.2 C402.2 C403.2 C404.2 C405.2 C406.2 C407.2 C408.2 C409.2 C410.2 C411.2 C412.2 C5245.1 C5246.1 C5247.1 C5249.2 C5250.2 C5251.2 C5253.2 C5254.2 C5255.2 C5256.2 C5257.2 C5258.2 C5259.2 C5260.2 C5263.2 C5274.1 C5275.1 C5276.1 C5277.2 C5278.1 CA1.2 CA2.2 CA3.2 CA4.2 CA15.2 CA18.1 CA21.2 CA22.2 CA24.1 CA25.1 CA30.1 CA31.1 CA32.1 CA36.1 CA37.1 CA38.1 CA88.1 CA91.2 CA92.1 CA93.2 CA94.1 CC17.2 CC18.2 CC19.2 CC20.2 CC24.2 CC25.2 CC26.2 CC27.2 CC28.2 CC29.2 CC30.2 CC31.2 CC32.2 CC33.2 CC34.2 CC35.2 CC36.2 CC37.2 CC38.2 CC39.2 CC40.2 CC41.1 CC144.2 CC152.2 CC153.2 CC154.2 CC155.2 CC156.1 CC157.1 CC389.2 CC390.2 CC391.2 CC392.2 CC393.2 CC394.2 CC395.2 CC396.2 CC397.2 CC398.2 CC399.2 CC401.2 CC402.2 CC405.2 CC406.2 CC407.2 CC408.2 CD1.1 CD2.1 CD3.2 CD4.2 CD5.2 CD6.2 CD7.2 CD8.2 CD9.2 CD10.1 CD11.1 CD12.1 CD13.1 CD14.1 CD16.2 CD17.2 CD18.2 CD19.2 CD20.2 CD21.2 CD22.2 CD23.2 CD24.2 CD25.2 CD26.2 CD27.2 CD28.2 CD29.2 CD30.2 CD31.2 CD32.2 CD60.1 CD61.1 CD62.2 CD63.2 CD64.2 CD65.2 CD66.2 CD67.2 CD68.2 CD69.1 CD70.1 CD71.1 CD72.1 CD73.2 CD74.2 CD75.2 CD76.2 CD77.2 CD78.2 CD79.2 CD80.2 CD81.1 CD83.2 CD84.2 CD85.2 CD86.2 CD87.2 CD88.2 CD89.2 CD90.2 CD91.2 CD92.2 CD93.2 CD94.2 CD95.2 CD96.2 CD97.2 CD98.2 CD99.2 CD100.2 CD101.2 CD102.1 CD103.1 CE1.2 CE2.2 CE3.2 CE4.2 CE5.2 CE6.2 CE7.2 CE8.2 CG1.2 CG2.2 CG3.2 CG4.2 CG5.2 CG6.2 CG7.2 CG9.2 CG10.2 CG11.2 CG12.2 CG13.2 CG14.2 CG15.2 CG16.2 CG17.2 CG18.2 CG19.2 CG20.2 CG21.2 CG22.2 CG23.2 CG24.2 CG25.2 CG26.2 CG27.2 CG28.2 CG29.2 CG30.2 CG31.2 CG32.2 CG33.2 CG34.2 CG36.2 CG37.2 CG38.2 CG39.2 CG40.2 CG41.2 CG42.2 CG43.2 CG46.2 CG49.2 CG50.2 CG51.2 CG52.2 CG53.2 CG54.2 CG55.2 CG56.2 CG57.2 CG58.2 CG59.2 CG60.2 CG61.2 CG62.2 CG63.2 CG64.2 CG65.2 CG66.2 CG67.2 CG68.2 CG69.2 CG70.2 CG71.2 CG72.2 CG73.2 CG74.2 CG75.2 CG76.2 CG77.2 CG78.2 CG79.2 CG80.2 CG81.2 CG82.2 CG83.2 CG84.2 CG85.2 CG86.2 CG87.2 CG88.2 CG89.2 CG90.2 CG91.2 CG92.2 CG93.2 CG94.2 CG95.2 CG96.2 CG97.2 CG98.2 CG99.2 CG100.2 CG101.2 CG102.2 CG103.2 CG104.2 CG105.2 CG106.2 CG107.2 CG108.2 CG109.2 CG110.2 CG111.2 CG112.2 CG113.2 CG114.2 CG115.2 CG116.2 CG117.2 CG118.2 CG119.2 CG120.2 CG121.2 CG122.2 CG123.2 CG124.2 CG126.2 CG127.2 CG128.2 CG129.2 CG130.2 CG131.2 CG132.2 CG133.2 CG134.2 CG135.2 CG136.2 CG137.2 CG138.2 CG139.2 CG140.2 CG141.2 CG142.2 CG143.2 CG144.2 CG145.2 CG146.2 CG147.2 CG148.2 CG149.2 CG150.2 CG151.2 CG152.2 CG153.2 CG154.2 CG155.2 CG156.2 CG157.2 CG158.2 CG159.2 CG160.2 CG161.2 CG162.2 CG163.2 CG164.2 CG165.2 CG166.2 CG167.2 CG168.2 CG169.2 CG170.2 CG171.2 CG172.2 CG173.2 CG174.2 CG175.2 CG176.2 CG177.2 CG178.2 CG179.2 CG180.2 CG181.2 CG182.2 CG183.2 CG184.2 CG185.2 CG186.2 CG187.2 CG188.2 CG189.2 CG190.2 CG191.2 CG192.2 CG193.2 CG194.2 CG195.2 CG196.1 CG197.1 CG200.2 CG202.2 CG203.2 CG204.2 CG205.2 CG206.2 CG207.2 CG208.2 CG209.2 CG210.2 CG211.2 CG212.2 CG213.2 CG214.2 CG215.2 CG216.2 CG217.2 CG218.2 CG219.2 CG220.2 CG221.2 CG222.2 CG223.2 CG269.2 CG334.2 CG335.2 CG336.2 CG337.2 CG338.2 CG339.2 CG340.2 CG563.2 CG564.2 CG565.2 CG566.2 CG567.2 CG568.2 CG569.2 CG570.2 CG571.2 CG572.2 CG573.2 CG574.2 CG575.2 CG576.2 CG2818.2 CH1.2 CH2.2 CH3.2 CH4.2 CH5.2 CH6.2 CH7.2 CH9.1 CH10.1 CH11.1 CH12.2 CH13.2 CH14.2 CH15.2 CH16.2 CH17.2 CH18.2 CH19.2 CH20.2 CH21.2 CH22.2 CH23.2 CH24.2 CH25.2 CH26.2 CH27.2 CH29.2 CH30.2 CH31.2 CH32.2 CH33.2 CH34.2 CH35.2 CH36.2 CH62.2 CH63.2 CH64.2 CH65.1 CH66.1 CH67.1 CH68.1 CH69.1 CH70.2 CH71.1 CH72.1 CH73.1 CH79.1 CH80.2 CH81.2 CH82.1 CH83.1 CH84.2 CH85.2 CH86.2 CH101.2 CH102.2 CH103.2 CH104.2 CH105.2 CH106.2 CH107.2 CH108.2 CH109.2 CK1.2 CK2.2 CK4.2 CK5.1 CK8.2 CK9.2 CK10.2 CK11.1 CK12.2 CK13.2 CK14.1 CK15.2 CK16.2 CL1.1 CL3.2 CL4.2 CL5.2 CL8.2 CL9.2 CL10.2 CL11.2 CL12.2 CL13.2 CL14.2 CL15.2 CL16.2 CL19.2 CL20.2 CL23.2 CL24.1 CL25.1 CL26.2 CL27.2 CL28.2 CL29.2 CLRP1.1 CLRP2.1 CLRP3.1 CR1.2 CR2.2 CR3.2 CR4.2 CR6.2 CR7.2 CR9.2 CR10.2 CR12.2 CR16.2 CR17.2 CS7.2 CS8.2 CS9.2 CS21.2 CS22.2 CS107.2 CS108.2 CS109.2 CS110.2 CS111.2 CS113.2 CS114.2 CT270.2 CT271.2 CT272.2 CT273.2 CT274.2 CTT1.2 CTT2.2 CTT3.2 CTT4.2 CTT323.2 CU57.1 CU58.1 CU59.2 CU60.1 CU61.1 CU62.2 CU63.2 CU64.2 CU65.2 CU66.2 CU67.2 CU68.2 CU69.2 CU70.2 CU71.2 CU72.2 CU73.2 CU74.2 CV1.1 CV3.2 CV4.2 CV5.2 CV6.2 CV17.2 CV18.2 CV19.2 CV20.2 CV21.2 CV22.2 CV23.2 CV24.2 CV25.2 CV26.2 CV27.2 CV28.2 CV29.2 CV30.2 CV31.2 CV32.2 CV33.2 CV43.1 CV44.1 CV45.2 CV46.2 CV47.2 CV49.2 CV52.1 CV53.1 CV54.2 CV274.2 CW1.2 CWL1.2 CWL2.2 CWL3.2 CWL4.2 CWL5.2 CWL7.2 CWL8.2 D1.1 D3.1 D506.1 D507.1 DA1.2 DA8.1 DA9.1 DL1.1 DM5.2 DM12.2 DM13.2 DM16.1 DS5.1 DS6.3 DT1.1 DU1.3 DU1.8 DU2.3 DU2.8 DU3.3 DU3.8 DU13.1 DU14.1 DV1.3 DV2.3 DV3.3 EC11.2 H1.1(TP-1) H2.1(TP-1) H4.1(TP-1) H7.1(TP-1) H8.1(TP-1) H9.1(TP-1) H11.1(TP-1) H12.1(TP-1) H13.1(TP-1) H14.1(TP-1) H15.1(TP-1) H16.1(TP-1) H17.1(TP-1) H18.1(TP-1) H19.1(TP-1) H20.1(TP-1) H22.1(TP-1) H23.1(TP-1) H33.1(TP-1) H34.1(TP-1) JCR2.5 JCR2.8 JCR2.12 JCR2.13 JCR2.14 JCR2.15 JDIMM1.1 JDIMM1.2 JDIMM1.5 JDIMM1.6 JDIMM1.9 JDIMM1.10 JDIMM1.14 JDIMM1.15 JDIMM1.18 JDIMM1.19 JDIMM1.22 JDIMM1.23 JDIMM1.26 JDIMM1.27 JDIMM1.30 JDIMM1.31 JDIMM1.35 JDIMM1.36 JDIMM1.39 JDIMM1.40 JDIMM1.43 JDIMM1.44 JDIMM1.47 JDIMM1.48 JDIMM1.51 JDIMM1.52 JDIMM1.56 JDIMM1.57 JDIMM1.60 JDIMM1.61 JDIMM1.64 JDIMM1.65 JDIMM1.68 JDIMM1.69 JDIMM1.72 JDIMM1.73 JDIMM1.77 JDIMM1.78 JDIMM1.81 JDIMM1.82 JDIMM1.85 JDIMM1.86 JDIMM1.89 JDIMM1.90 JDIMM1.93 JDIMM1.94 JDIMM1.98 JDIMM1.99 JDIMM1.102 JDIMM1.103 JDIMM1.106 JDIMM1.107 JDIMM1.167 JDIMM1.168 JDIMM1.171 JDIMM1.172 JDIMM1.175 JDIMM1.176 JDIMM1.180 JDIMM1.181 JDIMM1.184 JDIMM1.185 JDIMM1.188 JDIMM1.189 JDIMM1.192 JDIMM1.193 JDIMM1.196 JDIMM1.197 JDIMM1.201 JDIMM1.202 JDIMM1.205 JDIMM1.206 JDIMM1.209 JDIMM1.210 JDIMM1.213 JDIMM1.214 JDIMM1.217 JDIMM1.218 JDIMM1.222 JDIMM1.223 JDIMM1.226 JDIMM1.227 JDIMM1.230 JDIMM1.231 JDIMM1.234 JDIMM1.235 JDIMM1.238 JDIMM1.239 JDIMM1.243 JDIMM1.244 JDIMM1.247 JDIMM1.248 JDIMM1.251 JDIMM1.252 JDIMM1.261 JDIMM1.262 JDIMM2.1 JDIMM2.2 JDIMM2.5 JDIMM2.6 JDIMM2.9 JDIMM2.10 JDIMM2.14 JDIMM2.15 JDIMM2.18 JDIMM2.19 JDIMM2.22 JDIMM2.23 JDIMM2.26 JDIMM2.27 JDIMM2.30 JDIMM2.31 JDIMM2.35 JDIMM2.36 JDIMM2.39 JDIMM2.40 JDIMM2.43 JDIMM2.44 JDIMM2.47 JDIMM2.48 JDIMM2.51 JDIMM2.52 JDIMM2.56 JDIMM2.57 JDIMM2.60 JDIMM2.61 JDIMM2.64 JDIMM2.65 JDIMM2.68 JDIMM2.69 JDIMM2.72 JDIMM2.73 JDIMM2.77 JDIMM2.78 JDIMM2.81 JDIMM2.82 JDIMM2.85 JDIMM2.86 JDIMM2.89 JDIMM2.90 JDIMM2.93 JDIMM2.94 JDIMM2.98 JDIMM2.99 JDIMM2.102 JDIMM2.103 JDIMM2.106 JDIMM2.107 JDIMM2.167 JDIMM2.168 JDIMM2.171 JDIMM2.172 JDIMM2.175 JDIMM2.176 JDIMM2.180 JDIMM2.181 JDIMM2.184 JDIMM2.185 JDIMM2.188 JDIMM2.189 JDIMM2.192 JDIMM2.193 JDIMM2.196 JDIMM2.197 JDIMM2.201 JDIMM2.202 JDIMM2.205 JDIMM2.206 JDIMM2.209 JDIMM2.210 JDIMM2.213 JDIMM2.214 JDIMM2.217 JDIMM2.218 JDIMM2.222 JDIMM2.223 JDIMM2.226 JDIMM2.227 JDIMM2.230 JDIMM2.231 JDIMM2.234 JDIMM2.235 JDIMM2.238 JDIMM2.239 JDIMM2.243 JDIMM2.244 JDIMM2.247 JDIMM2.248 JDIMM2.251 JDIMM2.252 JDIMM2.261 JDIMM2.262 JEDP1.1 JEDP1.2 JEDP1.5 JEDP1.20 JEDP1.21 JEDP1.24 JEDP1.27 JEDP1.30 JEDP1.33 JEDP1.36 JEDP1.41 JEDP1.42 JFAN1.4 JFAN1.5 JFAN1.6 JFAN2.4 JFAN2.5 JFAN2.6 JHDD1.6 JHDD1.9 JHDD1.12 JHDD1.13 JHDD1.14 JHDMI1.2 JHDMI1.5 JHDMI1.8 JHDMI1.11 JHDMI1.17 JHDMI1.20 JHDMI1.21 JHDMI1.22 JHDMI1.23 JIO1.9 JIO1.12 JIO1.15 JIO1.18 JIO1.21 JIO1.24 JIO1.37 JIO1.38 JKB1.33 JKB1.34 JKBL1.5 JKBL1.6 JPWR1.1 JPWR1.2 JPWR1.7 JPWR1.8 JSPK1.6 JSPK1.7 JSPK1.8 JSSD1.1 JSSD1.3 JSSD1.9 JSSD1.15 JSSD1.21 JSSD1.27 JSSD1.33 JSSD1.39 JSSD1.45 JSSD1.51 JSSD1.57 JSSD1.63 JSSD1.65 JSSD1.67 JSSD1.68 JSSD1.69 JTP1.5 JTP1.9 JTP1.10 JUSB3.4 JUSB3.7 JUSB3.10 JUSB3.11 JUSB3.12 JUSB3.13 JUSBC1.1 JUSBC1.2 JUSBC1.3 JUSBC1.4 JUSBC1.5 JUSBC1.6 JUSBC1.7 JUSBC1.8 JUSBC1.9 JUSBC1.10 JUSBC1.A1 JUSBC1.A12 JUSBC1.B1 JUSBC1.B12 JWLAN1.1 JWLAN1.7 JWLAN1.18 JWLAN1.25 JWLAN1.31 JWLAN1.37 JWLAN1.43 JWLAN1.49 JWLAN1.55 JWLAN1.61 JWLAN1.67 JWLAN1.68 JWLAN1.69 LK2.1 PC1.2 PC2.2 PC3.2 PC4.2 PC5.2 PC6.2 PC8.2 PC9.2 PC10.2 PC11.2 PC301.2 PC303.2 PC305.2 PC306.2 PC307.2 PC308.2 PC309.2 PC310.2 PC311.2 PC314.2 PC316.2 PC317.2 PC318.2 PC319.2 PC320.2 PC321.2 PC322.2 PC323.2 PC324.2 PC325.2 PC326.2 PC328.2 PC329.2 PC330.2 PC331.2 PC332.2 PC333.2 PC1001.2 PC1003.2 PC1004.2 PC1005.2 PC1006.2 PC1007.2 PC1010.2 PC1011.2 PC1012.2 PC1013.2 PC1014.2 PC1801.2 PC1803.2 PC1804.2 PC1805.2 PC1806.2 PC2501.1 PC2502.2 PC2503.2 PC2505.2 PC2506.2 PCA1.2 PCA2.2 PCA3.2 PCA4.2 PCA6.2 PCA7.2 PCA23.2 PCA25.2 PCA26.2 PCA27.2 PCA28.2 PCA29.2 PCA30.2 PCA31.2 PCA32.2 PCA33.2 PCA34.2 PCB03.1 PCB05.2 PCB08.2 PCB09.2 PCB10.2 PCB11.2 PCB14.2 PCB16.2 PCB18.2 PCB19.2 PCB20.2 PCB23.2 PCB24.2 PCB26.2 PCB27.2 PCB29.2 PCB30.2 PCB31.2 PCB32.2 PCB33.2 PCB34.2 PCB35.2 PCB36.2 PCF1.1 PCF3.2 PCF4.2 PCF5.2 PCF6.2 PCG1.2 PCG2.2 PCG3.2 PCG4.2 PCG6.2 PCG7.2 PCG55.2 PCG56.2 PCG57.2 PCG58.2 PCG59.2 PCG60.2 PCG61.2 PCG62.2 PCG63.2 PCG64.2 PCG65.2 PCG66.2 PCG75.2 PCG76.2 PCG77.2 PCG78.2 PCG79.2 PCG80.2 PCG81.2 PCG82.2 PCG83.2 PCG84.2 PCG85.2 PCG86.2 PCH1.2 PCH2.2 PCH3.2 PCH5.2 PCH7.2 PCH8.2 PCH9.2 PCH10.2 PCH11.2 PCH12.2 PCH13.2 PCH14.2 PCM1.2 PCM2.2 PCM5.2 PCM6.2 PCM7.1 PCM8.2 PCM9.2 PCM10.2 PCM11.2 PCM12.2 PCM13.2 PCM14.2 PCM15.2 PCM16.2 PCM17.2 PCM18.2 PCP1.2 PCP2.2 PCP3.2 PCP4.2 PCP5.2 PCP6.2 PCP7.2 PCP326.2 PCP327.2 PCP328.2 PCP329.2 PCP330.2 PCP331.2 PCV2.2 PCV3.2 PCV4.2 PCV5.2 PCV6.2 PCV7.2 PCV8.2 PCV11.2 PCV12.2 PCV13.2 PCV14.2 PCV17.2 PCV18.2 PCV19.2 PCV22.2 PCV23.2 PCV24.2 PCV25.2 PCV26.2 PCV27.2 PCV28.2 PCV29.2 PCV30.2 PCV31.2 PCV32.2 PCV33.2 PCV34.2 PCV35.2 PCV36.2 PCV37.2 PCV38.2 PCV39.2 PCV40.2 PCV41.2 PCV42.2 PCV43.2 PCV44.2 PCV45.2 PCV46.2 PCV47.2 PCV48.2 PCV49.2 PCV50.2 PCV51.2 PCV52.2 PCV53.2 PCV54.2 PCV55.2 PCV56.2 PCV57.2 PCV58.2 PCV59.2 PCV60.2 PCV61.2 PCV62.2 PCV63.2 PCV64.2 PCV65.2 PCV66.2 PCV67.2 PCV68.2 PCV69.2 PCV70.2 PCV71.2 PCV72.2 PCV73.2 PCV74.2 PCV75.2 PCV76.2 PCV77.2 PCV78.2 PCV79.2 PCV80.2 PCV81.2 PCV82.2 PCV83.2 PCV84.2 PCV85.2 PCV86.2 PCV87.2 PCV88.2 PCV89.2 PCV90.2 PCV91.2 PCV92.2 PCV93.2 PCW1.2 PCW3.2 PCW5.2 PCW6.2 PCW7.2 PCW8.2 PCW9.2 PCW10.2 PCW11.2 PCW12.2 PCW13.2 PCW14.2 PCZ3.1 PCZ6.1 PCZ8.2 PCZ9.1 PCZ11.1 PCZ18.1 PCZ23.2 PCZ26.1 PCZ29.2 PCZ30.2 PCZ31.1 PCZ32.2 PCZ33.2 PCZ39.2 PCZ40.2 PCZ41.2 PCZ42.2 PCZ43.2 PCZ44.2 PCZ45.2 PCZ47.2 PCZ48.2 PCZ49.2 PCZ50.2 PCZ51.2 PCZ53.2 PCZ54.2 PCZ55.2 PCZ56.2 PCZ57.2 PCZ58.2 PCZ60.2 PCZ61.2 PCZ62.2 PCZ63.2 PCZ64.2 PCZ65.2 PCZ67.2 PCZ68.2 PCZ173.2 PCZ174.2 PCZ175.2 PCZ176.2 PCZ177.2 PCZ178.2 PCZ179.2 PCZ180.2 PCZ181.2 PCZ182.2 PCZ183.2 PCZ184.2 PCZ185.2 PCZ186.2 PCZ187.2 PCZ188.2 PCZ189.2 PCZ190.2 PCZ191.2 PCZ192.2 PCZ193.2 PCZ217.2 PCZ218.2 PCZ219.2 PCZ220.2 PCZ221.2 PCZ222.2 PCZ223.2 PCZ224.2 PCZ225.2 PCZ226.2 PCZ227.2 PCZ228.2 PCZ229.2 PCZ230.2 PCZ231.2 PCZ232.2 PCZ233.2 PCZ234.2 PCZ235.2 PCZ236.2 PCZ237.2 PCZ238.2 PCZ239.2 PCZ240.2 PCZ307.2 PCZ308.2 PCZ309.2 PCZ310.2 PCZ311.2 PCZ312.2 PCZ313.2 PCZ314.2 PCZ315.2 PD1.1 PD2.1 PD3.2 PDM3.2 PHZ4.2 PHZ5.2 PJP1.1 PJP1.2 PJP1.3 PJP1.4 PJPB1.9 PJPB1.10 PJPB1.11 PJPB1.12 PJPB1.13 PJPB1.14 PQ1.3 PQ2.1 PQ2.4 PQA1.5 PQA1.6 PQA1.7 PQB05.5 PQB05.6 PQB05.7 PQG1.10 PQM1.5 PQM1.6 PQM1.7 PQV1.10 PQV2.10 PQV3.10 PQW2.1 PQW2.2 PQW2.3 PQW3.3 PQZ1.10 PQZ2.10 PQZ3.10 PQZ4.10 PR2.2 PR5.2 PR6.2 PR20.2 PR308.2 PR313.2 PR1002.2 PR1005.2 PR1007.2 PR1805.2 PR1806.2 PR2503.2 PR2507.2 PRB01.1 PRB12.2 PRB19.2 PRB25.2 PRB29.2 PRB30.2 PRB34.2 PRB35.2 PRF5.2 PRF6.2 PRH7.2 PRH8.2 PRH10.2 PRM9.2 PRP3.2 PRP5.2 PRV12.2 PRV20.1 PRV21.2 PRV26.2 PRW3.2 PRW4.1 PRW6.2 PRW11.2 PRW12.2 PRZ13.1 PRZ20.1 PRZ22.1 PRZ24.2 PRZ37.1 PRZ40.2 PRZ57.2 PRZ58.2 PRZ61.2 PRZ62.2 PRZ63.2 PRZ64.2 PRZ65.2 PRZ77.2 PRZ78.2 PU301.7 PU301.8 PU301.18 PU301.21 PU302.3 PU302.11 PU1001.7 PU1001.8 PU1001.18 PU1001.21 PU1801.4 PU1801.8 PU1801.9 PU2501.2 PUA1.6 PUA1.9 PUB01.33 PUF1.2 PUG1.6 PUG1.9 PUH1.7 PUH1.8 PUH1.18 PUH1.21 PUM1.1 PUM1.3 PUM1.14 PUM1.21 PUP1.2 PUP1.5 PUP1.7 PUV1.25 PUV2.6 PUV2.9 PUW1.11 PUZ1.53 PUZ2.6 PUZ2.9 PUZ3.6 PUZ3.9 PUZ4.6 PUZ4.9 PUZ5.6 PUZ5.9 Q32.3 Q73.3 Q79.3 QA3.3 QC11.1 QC11.4 QG3.3 QG4.3 QG7.1 QG7.4 QG8.1 QG8.4 QG16.3 QG17.1 QG17.4 QG55.3 QG56.3 QG57.3 QK1.3 QS1.1 QS1.4 QT2.2 QV7.1 QV7.4 QWL3.3 R124.2 R5216.1 R5802.2 R5804.2 RA15.2 RA20.2 RA22.1 RA23.1 RA24.1 RA37.2 RC3.1 RC4.1 RC5.1 RC11.2 RC13.2 RC16.2 RC19.2 RC31.2 RC32.2 RC33.2 RC34.2 RC35.2 RC36.2 RC390.2 RC391.2 RC392.2 RC393.2 RD3.2 RD5.2 RD6.2 RD10.1 RD11.1 RD22.2 RD23.2 RD24.2 RD28.1 RD29.1 RG9.2 RG10.1 RG11.2 RG12.2 RG16.2 RG42.2 RG43.2 RG48.1 RG49.1 RG52.2 RG56.2 RG57.2 RG58.2 RG59.2 RG60.2 RG61.2 RG66.2 RG70.2 RG71.2 RG72.2 RG73.2 RG74.2 RG75.2 RG89.1 RG90.1 RG93.1 RG94.1 RG118.1 RG122.1 RG123.1 RG133.1 RG134.1 RG135.1 RG136.1 RG137.1 RG138.1 RG381.1 RG401.1 RG402.1 RG404.1 RG405.1 RG406.1 RH8.2 RH11.2 RH14.1 RH20.1 RH22.2 RH23.2 RH24.2 RH25.2 RH50.1 RH153.1 RH156.1 RH168.2 RH173.2 RH176.2 RH193.2 RH196.2 RH197.1 RH198.1 RH199.1 RH200.2 RH204.2 RH210.1 RH212.1 RH256.2 RH258.1 RH273.2 RK4.1 RK20.1 RK23.2 RK26.2 RK27.2 RK28.1 RK29.1 RK30.1 RK31.1 RK34.1 RL11.1 RL55.2 RM11.1 RR10.2 RS13.1 RS14.1 RS41.1 RS42.1 RT808.2 RT809.2 RT810.2 RT812.2 RT815.2 RT816.2 RT817.2 RT818.2 RT838.2 RT840.2 RT845.2 RT846.2 RT848.2 RT849.2 RT851.2 RT852.2 RT854.2 RT855.2 RT857.2 RT858.2 RT860.2 RT1111.2 RT1112.2 RT1113.2 RT1114.2 RTT12.2 RU63.2 RU72.2 RU73.2 RU79.1 RV3.2 RV5.2 RV7.2 RV18.2 RV22.1 RV24.1 RV25.1 RV29.2 RV33.2 RV47.2 RV50.2 RWL1.2 RWL2.2 U7.1 U9.5 U9.6 U9.7 U9.8 U10.11 U10.15 U11.5 U11.9 U12.2 U4019.4 UA1.49 UC1.A3 UC1.A4 UC1.A6 UC1.A9 UC1.A10 UC1.A12 UC1.A14 UC1.A16 UC1.A18 UC1.A20 UC1.A22 UC1.A24 UC1.A26 UC1.A28 UC1.A30 UC1.A34 UC1.A36 UC1.A37 UC1.AA12 UC1.AA29 UC1.AA30 UC1.AB6 UC1.AB33 UC1.AB34 UC1.AC1 UC1.AC2 UC1.AC3 UC1.AC4 UC1.AC5 UC1.AC6 UC1.AC12 UC1.AC37 UC1.AC38 UC1.AD6 UC1.AD7 UC1.AD8 UC1.AD9 UC1.AD10 UC1.AD11 UC1.AD12 UC1.AD29 UC1.AD30 UC1.AE6 UC1.AE33 UC1.AE34 UC1.AF1 UC1.AF2 UC1.AF3 UC1.AF4 UC1.AF12 UC1.AF13 UC1.AF14 UC1.AG6 UC1.AG7 UC1.AG8 UC1.AG10 UC1.AG11 UC1.AG13 UC1.AG29 UC1.AG30 UC1.AH6 UC1.AH12 UC1.AH33 UC1.AH34 UC1.AH35 UC1.AH36 UC1.AJ1 UC1.AJ2 UC1.AJ3 UC1.AJ4 UC1.AJ5 UC1.AJ6 UC1.AJ13 UC1.AJ37 UC1.AJ38 UC1.AK4 UC1.AK29 UC1.AK30 UC1.AL4 UC1.AL7 UC1.AL8 UC1.AL9 UC1.AL10 UC1.AL12 UC1.AL14 UC1.AL33 UC1.AL34 UC1.AM1 UC1.AM2 UC1.AM3 UC1.AM4 UC1.AM5 UC1.AM12 UC1.AM37 UC1.AM38 UC1.AN5 UC1.AN6 UC1.AN12 UC1.AN29 UC1.AN30 UC1.AP8 UC1.AP9 UC1.AP10 UC1.AP11 UC1.AP12 UC1.AP33 UC1.AP34 UC1.AR1 UC1.AR2 UC1.AR3 UC1.AR4 UC1.AR5 UC1.AR13 UC1.AR14 UC1.AR29 UC1.AR30 UC1.AR31 UC1.AR32 UC1.AR33 UC1.AR34 UC1.AR35 UC1.AR36 UC1.AR37 UC1.AR38 UC1.AT6 UC1.AT29 UC1.AT30 UC1.AU6 UC1.AU7 UC1.AU8 UC1.AU9 UC1.AU10 UC1.AU11 UC1.AU12 UC1.AU33 UC1.AU34 UC1.AV37 UC1.AV38 UC1.AW1 UC1.AW2 UC1.AW3 UC1.AW4 UC1.AW5 UC1.AW12 UC1.AW29 UC1.AW30 UC1.AY12 UC1.AY14 UC1.AY33 UC1.AY34 UC1.B3 UC1.B9 UC1.B37 UC1.BA6 UC1.BA7 UC1.BA8 UC1.BA9 UC1.BA10 UC1.BA11 UC1.BA12 UC1.BA37 UC1.BA38 UC1.BB1 UC1.BB2 UC1.BB3 UC1.BB4 UC1.BB5 UC1.BB6 UC1.BB12 UC1.BB29 UC1.BB30 UC1.BC6 UC1.BC12 UC1.BC13 UC1.BC14 UC1.BC33 UC1.BC34 UC1.BD6 UC1.BD7 UC1.BD8 UC1.BD9 UC1.BD10 UC1.BD11 UC1.BD12 UC1.BD37 UC1.BD38 UC1.BE1 UC1.BE2 UC1.BE3 UC1.BE4 UC1.BE5 UC1.BE6 UC1.BE29 UC1.BE30 UC1.BF6 UC1.BF12 UC1.BF33 UC1.BF34 UC1.BG6 UC1.BG12 UC1.BG13 UC1.BG14 UC1.BG37 UC1.BG38 UC1.BH1 UC1.BH2 UC1.BH3 UC1.BH4 UC1.BH5 UC1.BH6 UC1.BH7 UC1.BH8 UC1.BH9 UC1.BH10 UC1.BH11 UC1.BH12 UC1.BH14 UC1.BJ12 UC1.BJ14 UC1.BJ15 UC1.BJ18 UC1.BJ22 UC1.BJ25 UC1.BJ29 UC1.BJ30 UC1.BJ31 UC1.BJ32 UC1.BJ33 UC1.BJ34 UC1.BJ35 UC1.BJ36 UC1.BK6 UC1.BK13 UC1.BK14 UC1.BK15 UC1.BK18 UC1.BK22 UC1.BK25 UC1.BK29 UC1.BL6 UC1.BL13 UC1.BL14 UC1.BL18 UC1.BL19 UC1.BL20 UC1.BL21 UC1.BL22 UC1.BL29 UC1.BL33 UC1.BL35 UC1.BL38 UC1.BM2 UC1.BM3 UC1.BM5 UC1.BM6 UC1.BM7 UC1.BM8 UC1.BM9 UC1.BM11 UC1.BM12 UC1.BM13 UC1.BM14 UC1.BM18 UC1.BM21 UC1.BM22 UC1.BM23 UC1.BM24 UC1.BM25 UC1.BM26 UC1.BM27 UC1.BM28 UC1.BM29 UC1.BM33 UC1.BM35 UC1.BM38 UC1.BN2 UC1.BN4 UC1.BN7 UC1.BN12 UC1.BN14 UC1.BN18 UC1.BN19 UC1.BN20 UC1.BN21 UC1.BN24 UC1.BN29 UC1.BN30 UC1.BN31 UC1.BN34 UC1.BP7 UC1.BP12 UC1.BP14 UC1.BP18 UC1.BP21 UC1.BP24 UC1.BP25 UC1.BP26 UC1.BP29 UC1.BP33 UC1.BP34 UC1.BR7 UC1.BR9 UC1.BR12 UC1.BR14 UC1.BR18 UC1.BR21 UC1.BR24 UC1.BR25 UC1.BR26 UC1.BR29 UC1.BR34 UC1.BR36 UC1.BR38 UC1.BT3 UC1.BT4 UC1.BT5 UC1.BT8 UC1.BT12 UC1.BT14 UC1.BT18 UC1.BT21 UC1.BT24 UC1.BT26 UC1.BT29 UC1.BT32 UC1.BT35 UC1.BT36 UC1.C2 UC1.C5 UC1.C8 UC1.C9 UC1.C11 UC1.C13 UC1.C15 UC1.C17 UC1.C19 UC1.C21 UC1.C23 UC1.C25 UC1.C27 UC1.C29 UC1.C31 UC1.C37 UC1.D3 UC1.D6 UC1.D9 UC1.D10 UC1.D12 UC1.D14 UC1.D16 UC1.D18 UC1.D20 UC1.D22 UC1.D24 UC1.D26 UC1.D28 UC1.D30 UC1.D33 UC1.D38 UC1.E4 UC1.E9 UC1.E34 UC1.E35 UC1.E38 UC1.F2 UC1.F3 UC1.F4 UC1.F5 UC1.F8 UC1.F9 UC1.F11 UC1.F13 UC1.F15 UC1.F17 UC1.F19 UC1.F21 UC1.F23 UC1.F25 UC1.F27 UC1.F29 UC1.F31 UC1.F36 UC1.G4 UC1.G5 UC1.G6 UC1.G8 UC1.G9 UC1.G10 UC1.G12 UC1.G14 UC1.G16 UC1.G18 UC1.G20 UC1.G22 UC1.G23 UC1.G24 UC1.G26 UC1.G28 UC1.H11 UC1.H12 UC1.H18 UC1.H22 UC1.H25 UC1.H32 UC1.H35 UC1.J4 UC1.J7 UC1.J10 UC1.J18 UC1.J22 UC1.J25 UC1.J32 UC1.J33 UC1.J36 UC1.K1 UC1.K2 UC1.K3 UC1.K4 UC1.K5 UC1.K7 UC1.K8 UC1.K9 UC1.K10 UC1.K11 UC1.K38 UC1.L29 UC1.L30 UC1.L33 UC1.L34 UC1.M6 UC1.M12 UC1.M13 UC1.M14 UC1.N1 UC1.N2 UC1.N3 UC1.N4 UC1.N5 UC1.N6 UC1.N7 UC1.N8 UC1.N9 UC1.N10 UC1.N11 UC1.N12 UC1.N33 UC1.N34 UC1.P6 UC1.P12 UC1.P37 UC1.P38 UC1.R12 UC1.R29 UC1.R30 UC1.T1 UC1.T2 UC1.T3 UC1.T4 UC1.T5 UC1.T7 UC1.T8 UC1.T9 UC1.T10 UC1.T11 UC1.T12 UC1.T13 UC1.T14 UC1.T33 UC1.T34 UC1.U6 UC1.U37 UC1.U38 UC1.V6 UC1.V12 UC1.V29 UC1.V30 UC1.W1 UC1.W2 UC1.W3 UC1.W4 UC1.W5 UC1.W12 UC1.W33 UC1.W34 UC1.Y7 UC1.Y8 UC1.Y9 UC1.Y10 UC1.Y11 UC1.Y13 UC1.Y14 UC1.Y37 UC1.Y38 UC2.3 UC3.5 UC4.11 UC4.15 UC5.5 UC6.5 UG1.A2 UG1.A33 UG1.AA13 UG1.AA15 UG1.AA17 UG1.AA18 UG1.AA20 UG1.AA22 UG1.AB2 UG1.AB5 UG1.AB7 UG1.AB12 UG1.AB14 UG1.AB16 UG1.AB19 UG1.AB21 UG1.AB23 UG1.AB28 UG1.AB30 UG1.AB32 UG1.AC13 UG1.AC15 UG1.AC17 UG1.AC18 UG1.AC20 UG1.AC22 UG1.AE2 UG1.AE5 UG1.AE7 UG1.AE28 UG1.AE30 UG1.AE32 UG1.AE33 UG1.AG11 UG1.AH2 UG1.AH5 UG1.AH7 UG1.AH10 UG1.AH11 UG1.AH13 UG1.AH16 UG1.AH19 UG1.AH22 UG1.AH24 UG1.AH28 UG1.AH29 UG1.AH30 UG1.AH32 UG1.AH33 UG1.AJ7 UG1.AK7 UG1.AK10 UG1.AL2 UG1.AL5 UG1.AL12 UG1.AL14 UG1.AL15 UG1.AL17 UG1.AL18 UG1.AL20 UG1.AL21 UG1.AL23 UG1.AL24 UG1.AL26 UG1.AL28 UG1.AL30 UG1.AL32 UG1.AL33 UG1.AM13 UG1.AM16 UG1.AM19 UG1.AM22 UG1.AM25 UG1.AN1 UG1.AN4 UG1.AN7 UG1.AN10 UG1.AN13 UG1.AN16 UG1.AN19 UG1.AN22 UG1.AN25 UG1.AN30 UG1.AN34 UG1.AP2 UG1.AP33 UG1.B1 UG1.B4 UG1.B7 UG1.B10 UG1.B22 UG1.B25 UG1.B28 UG1.B31 UG1.B34 UG1.C7 UG1.C10 UG1.C13 UG1.C16 UG1.C19 UG1.C22 UG1.C25 UG1.C28 UG1.D2 UG1.D31 UG1.D33 UG1.E5 UG1.E7 UG1.E10 UG1.E22 UG1.E25 UG1.F7 UG1.F28 UG1.G2 UG1.G3 UG1.G5 UG1.G7 UG1.G10 UG1.G13 UG1.G16 UG1.G19 UG1.G22 UG1.G25 UG1.G28 UG1.G30 UG1.G32 UG1.G33 UG1.K2 UG1.K5 UG1.K7 UG1.K28 UG1.K30 UG1.K32 UG1.K33 UG1.M13 UG1.M15 UG1.M17 UG1.M18 UG1.M20 UG1.M22 UG1.N2 UG1.N5 UG1.N7 UG1.N12 UG1.N14 UG1.N16 UG1.N19 UG1.N21 UG1.N23 UG1.N28 UG1.N30 UG1.N32 UG1.N33 UG1.P13 UG1.P15 UG1.P17 UG1.P18 UG1.P20 UG1.P22 UG1.R12 UG1.R14 UG1.R16 UG1.R19 UG1.R21 UG1.R23 UG1.T2 UG1.T5 UG1.T7 UG1.T13 UG1.T15 UG1.T17 UG1.T18 UG1.T20 UG1.T22 UG1.T28 UG1.T32 UG1.U12 UG1.U14 UG1.U16 UG1.U19 UG1.U21 UG1.U23 UG1.V12 UG1.V14 UG1.V16 UG1.V19 UG1.V21 UG1.V23 UG1.W13 UG1.W15 UG1.W17 UG1.W18 UG1.W20 UG1.W22 UG1.W28 UG1.W32 UG1.Y12 UG1.Y14 UG1.Y16 UG1.Y19 UG1.Y21 UG1.Y23 UG2.3 UG4.A1 UG4.A3 UG4.A12 UG4.A14 UG4.B5 UG4.B10 UG4.C1 UG4.C3 UG4.C4 UG4.C11 UG4.C12 UG4.C14 UG4.D10 UG4.E1 UG4.E3 UG4.E12 UG4.E14 UG4.F5 UG4.F10 UG4.G5 UG4.G10 UG4.H1 UG4.H2 UG4.H13 UG4.H14 UG4.K1 UG4.K2 UG4.K13 UG4.K14 UG4.L5 UG4.L10 UG4.M5 UG4.M10 UG4.N1 UG4.N3 UG4.N12 UG4.N14 UG4.P10 UG4.R1 UG4.R3 UG4.R4 UG4.R11 UG4.R12 UG4.R14 UG4.T5 UG4.T10 UG4.U1 UG4.U3 UG4.U12 UG4.U14 UG5.A1 UG5.A3 UG5.A12 UG5.A14 UG5.B5 UG5.B10 UG5.C1 UG5.C3 UG5.C4 UG5.C11 UG5.C12 UG5.C14 UG5.D10 UG5.E1 UG5.E3 UG5.E12 UG5.E14 UG5.F5 UG5.F10 UG5.G5 UG5.G10 UG5.H1 UG5.H2 UG5.H13 UG5.H14 UG5.K1 UG5.K2 UG5.K13 UG5.K14 UG5.L5 UG5.L10 UG5.M5 UG5.M10 UG5.N1 UG5.N3 UG5.N12 UG5.N14 UG5.P10 UG5.R1 UG5.R3 UG5.R4 UG5.R11 UG5.R12 UG5.R14 UG5.T5 UG5.T10 UG5.U1 UG5.U3 UG5.U12 UG5.U14 UG6.A1 UG6.A3 UG6.A12 UG6.A14 UG6.B5 UG6.B10 UG6.C1 UG6.C3 UG6.C4 UG6.C11 UG6.C12 UG6.C14 UG6.D10 UG6.E1 UG6.E3 UG6.E12 UG6.E14 UG6.F5 UG6.F10 UG6.G5 UG6.G10 UG6.H1 UG6.H2 UG6.H13 UG6.H14 UG6.K1 UG6.K2 UG6.K13 UG6.K14 UG6.L5 UG6.L10 UG6.M5 UG6.M10 UG6.N1 UG6.N3 UG6.N12 UG6.N14 UG6.P10 UG6.R1 UG6.R3 UG6.R4 UG6.R11 UG6.R12 UG6.R14 UG6.T5 UG6.T10 UG6.U1 UG6.U3 UG6.U12 UG6.U14 UG7.A1 UG7.A3 UG7.A12 UG7.A14 UG7.B5 UG7.B10 UG7.C1 UG7.C3 UG7.C4 UG7.C11 UG7.C12 UG7.C14 UG7.D10 UG7.E1 UG7.E3 UG7.E12 UG7.E14 UG7.F5 UG7.F10 UG7.G5 UG7.G10 UG7.H1 UG7.H2 UG7.H13 UG7.H14 UG7.K1 UG7.K2 UG7.K13 UG7.K14 UG7.L5 UG7.L10 UG7.M5 UG7.M10 UG7.N1 UG7.N3 UG7.N12 UG7.N14 UG7.P10 UG7.R1 UG7.R3 UG7.R4 UG7.R11 UG7.R12 UG7.R14 UG7.T5 UG7.T10 UG7.U1 UG7.U3 UG7.U12 UG7.U14 UG8.3 UG10.3 UG11.3 UG27.11 UG27.15 UG28.3 UG29.3 UH1.A2 UH1.A3 UH1.A4 UH1.A5 UH1.A8 UH1.A28 UH1.A33 UH1.A37 UH1.A45 UH1.A46 UH1.A47 UH1.A48 UH1.AA5 UH1.AA19 UH1.AA20 UH1.AA25 UH1.AA27 UH1.AA28 UH1.AA30 UH1.AA31 UH1.AA49 UH1.AB19 UH1.AB25 UH1.AB31 UH1.AC4 UH1.AC12 UH1.AC17 UH1.AC33 UH1.AC38 UH1.AC46 UH1.AD1 UH1.AD2 UH1.AD19 UH1.AD22 UH1.AD25 UH1.AD49 UH1.AE4 UH1.AE12 UH1.AE33 UH1.AE38 UH1.AE46 UH1.AF22 UH1.AF25 UH1.AF28 UH1.AG1 UH1.AG22 UH1.AG23 UH1.AG25 UH1.AG27 UH1.AG28 UH1.AG30 UH1.AG49 UH1.AH12 UH1.AH17 UH1.AH33 UH1.AH38 UH1.AJ19 UH1.AJ20 UH1.AJ25 UH1.AJ27 UH1.AJ28 UH1.AJ30 UH1.AJ31 UH1.AK4 UH1.AK19 UH1.AK20 UH1.AK25 UH1.AK27 UH1.AK28 UH1.AK30 UH1.AK31 UH1.AK46 UH1.AL12 UH1.AL17 UH1.AL21 UH1.AL24 UH1.AL26 UH1.AL29 UH1.AL33 UH1.AL37 UH1.AL38 UH1.AM1 UH1.AM18 UH1.AM32 UH1.AM49 UH1.AN12 UH1.AN16 UH1.AN34 UH1.AN38 UH1.AP4 UH1.AP46 UH1.AR12 UH1.AR16 UH1.AR34 UH1.AR38 UH1.AT1 UH1.AT16 UH1.AT18 UH1.AT21 UH1.AT24 UH1.AT26 UH1.AT29 UH1.AT32 UH1.AT34 UH1.AT45 UH1.AV11 UH1.AV39 UH1.AW4 UH1.AW10 UH1.AW40 UH1.AW46 UH1.B47 UH1.B48 UH1.B49 UH1.BA5 UH1.BA6 UH1.BA12 UH1.BA14 UH1.BA44 UH1.BB9 UH1.BB41 UH1.BB43 UH1.BC8 UH1.BC10 UH1.BC13 UH1.BC15 UH1.BC19 UH1.BC24 UH1.BC26 UH1.BC31 UH1.BC35 UH1.BC40 UH1.BC45 UH1.BD43 UH1.BE44 UH1.BF1 UH1.BF2 UH1.BF3 UH1.BF48 UH1.BF49 UH1.BG2 UH1.BG3 UH1.BG4 UH1.BG17 UH1.BG22 UH1.BG25 UH1.BG28 UH1.BG33 UH1.BG37 UH1.BG48 UH1.C4 UH1.C5 UH1.C12 UH1.C25 UH1.C30 UH1.C48 UH1.D8 UH1.D12 UH1.D16 UH1.D17 UH1.D30 UH1.D33 UH1.E8 UH1.E10 UH1.E13 UH1.E15 UH1.E17 UH1.E19 UH1.E22 UH1.E24 UH1.E26 UH1.E31 UH1.E33 UH1.E35 UH1.E40 UH1.E42 UH1.F3 UH1.F41 UH1.F43 UH1.F47 UH1.G3 UH1.G6 UH1.G44 UH1.H8 UH1.J4 UH1.J9 UH1.J10 UH1.J26 UH1.J29 UH1.J40 UH1.J46 UH1.J47 UH1.J48 UH1.K11 UH1.K39 UH1.M5 UH1.M16 UH1.M18 UH1.M21 UH1.M24 UH1.M32 UH1.M34 UH1.M49 UH1.N12 UH1.N16 UH1.N34 UH1.N35 UH1.N37 UH1.N38 UH1.P4 UH1.P26 UH1.P29 UH1.P46 UH1.R3 UH1.R4 UH1.R12 UH1.R16 UH1.R26 UH1.R29 UH1.R34 UH1.R38 UH1.T4 UH1.T5 UH1.T7 UH1.T17 UH1.T18 UH1.T32 UH1.T49 UH1.U12 UH1.U15 UH1.U17 UH1.U21 UH1.U24 UH1.U33 UH1.U38 UH1.V4 UH1.V20 UH1.V22 UH1.V46 UH1.W25 UH1.W27 UH1.W28 UH1.W30 UH1.Y9 UH1.Y10 UH1.Y12 UH1.Y17 UH1.Y33 UH1.Y38 UH2.4 UH3.3 UK1.11 UK1.24 UK1.35 UK1.94 UK1.113 UL1.33 UL2.2 UR1.33 US2.14 US2.17 UT1.2 UT1.9 UT1.16 UT1.23 UT1.32 UT1.33 UT11.41 UU4.1 UU4.2 UU4.3 UU4.4 UU4.20 UU4.45 UU4.46 UU4.47 UU4.51 UU4.59 UU5.4 UV1.2 UV2.49 UV3.2 UV3.7 UV4.2 YH1.2 YH1.4
GNDA: CA5.1 CA11.2 CA12.1 CA13.2 CA14.1 CA16.1 CA17.1 CA19.2 CA20.2 CA23.1 CA30.2 CA31.2 CA32.2 CA36.2 CA37.2 CA38.2 CA95.2 CA96.2 CA97.2 JIO1.30 JIO1.33 JIO1.36 RA14.1 RA22.2 RA23.2 RA24.2 UA1.22 UA1.30 UA1.37
VBAT: PRB06.1 PUB01.26
VCC_5V: PC318.1 PU302.10
VCCGT_SENSE: PRZ31.2 RC12.1 UC1.AH38
VCCIO_SENSE: TC92.1(TP-1) UC1.H14
VCCMPHY_SENSE: TH139.1(TP-1) UH1.K47
VCCSA_SENSE: PRZ11.1 RC15.1 UC1.M38
VCCSENSE: PRZ25.1 RC10.1 UC1.AG37
VCCSENSE_VGA: PRV38.1 UG1.L4
VCCSENSE_VGA_S: TG12.1(TP-1) UG1.U1
VDD_DDR: PCM16.1 PRM2.1 PRM4.2 PUM1.11
VDDP_DDR: PCM7.2 PDM3.1 PRM5.2 PUM1.12
VIN_3V_LCDVDD: CV1.2 LV2.2 UV1.4
VSSGT_SENSE: PRZ33.2 RC13.1 UC1.AH37
VSSIO_SENSE: TC93.1(TP-1) UC1.J14
VSSMPHY_SENSE: TH138.1(TP-1) UH1.K46
VSSSA_SENSE: PRZ9.1 RC16.1 UC1.M37
VSSSENSE: PRZ27.1 RC11.1 UC1.AG38
VSSSENSE_VGA: PRV19.1 UG1.L5
VSSSENSE_VGA_S: TG13.1(TP-1) UG1.U2
7237_FB: PCP8.2 PRP4.2 PRP5.1 PUP1.4
81215_ALERT: PRZ19.1 PUZ1.41
81215_SCLK: PRZ17.1 PUZ1.42
81215_SDIO: PRZ21.1 PUZ1.40
81215_VR_HOT: PRZ14.1 PUZ1.39
+2546PWR: CS7.1 CS22.1 CS107.1 CS110.1 CS111.1 RS9.1 US2.1 US3.5
+CR_VDD_3V3: CR1.1 CR4.1 JCR2.6 UR1.12
+EC_VCCA: CK3.1 LK1.2 UK1.67
+FB_PLLAVDD: CG7.1 CG9.1 CG10.1 CG11.1 CG12.1 LG3.2 UG1.H17 UG1.K27 UG1.U27
+GPU_PLLVDD: CG3.1 CG4.1 CG5.1 CG6.1 CG42.1 CG124.1 CG194.1 CG195.1 CG215.1 CG216.1 LG1.1 UG1.AB8 UG1.AD7 UG1.AD8 UG1.AE8 UG1.AF7 UG1.H26
+LAN_REGOUT: LL2.1 UL1.24
+LAN_VDD_1V0: CL8.1 CL11.1 CL12.1 CL13.1 CL14.1 CL15.1 CL23.1 CL26.1 CL27.1 LL2.2 UL1.3 UL1.8 UL1.22 UL1.30
+LAN_VDD_3V3: CL5.1 CL9.1 CL10.1 CL16.1 CL19.1 CL20.1 CL29.1 DM12.5 DM13.5 JL33.2 LED4.2 LED5.2 RL15.1 RL56.2 UL1.11 UL1.23 UL1.32 UL2.1
+LCDVDD: CV2.1 CV3.1 CV4.1 CV46.1 CV47.1 JEDP1.11 JEDP1.12 JEDP1.13 JEDP1.14 LV3.2 RV49.1 RV52.1
+MIC2_VREFO: RA4.1 UA1.28
