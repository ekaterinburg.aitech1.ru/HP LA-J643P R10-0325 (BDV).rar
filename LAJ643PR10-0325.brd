# Allegro board LAJ643PR10-0325.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+2.5V: length 8.2
  BOTTOM w0.305: JDIMM1.257 170.03,51.5 170.37,51.84 171.28,51.84 171.88,51.23 171.88,50.44 v2(172.22,50.1) ; JDIMM1.259 170.52,51.09 170.74,51.3 171.07,51.3 171.3,51.07 171.3,50.1 v2(171.76,49.64)
  vias: v2(111.98,26.41) v2(112.54,26.42) v2(113.1,26.42) v2(113.66,26.41) v2(170.68,37.36) v2(171.15,37.87) v2(174.07,39.2) v2(174.07,38.61) v2(174.07,38.03) v2(174.61,47.09) v2(174.6,46.53) v2(174.6,45.97) v2(174.6,45.41) v3(174.08,48.42)
+2.5VP: length 14.8
  TOP w0.127: PC2506.1 v1(113.81,16)
  TOP w0.254: PC2506.1 113.01,15.23 113.01,14.22 112.67,13.88 v2(112.05,13.88) ; v2(106.02,13.31) PR2506.1 105.62,13.96 105.62,13.93 105.15,13.46 104.74,13.46 104.46,13.74 104.46,14.69 PC2504.1
  BOTTOM w0.254: v2(106.02,13.31) 111.48,13.31 v2(112.05,13.88)
+3.3V_HDA: length 8
  TOP w0.254: RH117.1 208.45,15.22 v1(208.45,15.96) 208.47,15.99 208.47,17.45 207.57,18.35 RH163.2 206.96,18.69 206.71,18.95 206.71,18.95 206.46,19.21 206.46,19.82 CH64.1 206.72,20.09 206.96,20.09 v2(207.22,20.34)
  BOTTOM w0.254: UH1.BB14 208.08,20.34 v2(207.22,20.34)
+3V_1.8V_PGPPA: length 30.3
  TOP w0.254: 197.12,10.09 195.92,11.3 RH67.2
  TOP w0.381: RH257.2 194.27,9.51 194.39,9.62 ; 194.39,9.62 RH64.1 ; 194.39,9.62 195.01,9.62 RH255.2 195.01,8.61 195.32,8.3 195.91,8.3 196.37,8.76 196.37,9.34 198.47,11.45 198.47,12.22 198.09,12.6 RH155.2 197.57,12.72 197.57,14.83 197.16,15.24 RH143.2 196.93,15.42 197.71,16.2 v1(197.71,16.48) 197.71,17 197.2,17.5 197.2,18.64 198.04,19.48 RH181.2 198.07,19.86 198.18,19.96 RH169.2 198.11,20.43 197.57,20.98 197.57,21.77 197.07,22.26 197.07,23.28 197.31,23.52 RH44.2 197.77,23.97 198.59,24.79 v2(198.73,24.79) 199.19,25.25 RH150.1
  BOTTOM w0.254: UH1.AN32 198.82,24.7 v2(198.73,24.79)
+3V_1.8V_PGPPD: length 2.8
  TOP w0.381: v2(204,24.11) 204.2,23.9 RH141.2 204.75,24.03 RH148.1
  BOTTOM w0.305: UH1.AN24 203.31,24.8 203.52,24.59 v2(204,24.11)
+3V_1.8V_PGPPEF: length 12.4
  TOP w0.508: CH33.1 197.7,27.33 v2(197.7,27.77) ; CH33.1 RH147.1 195.41,27.07 194.9,27.59 194.9,28.01 194.32,28.59 191.86,28.59 v1(191.56,28.88) 191.08,29.36 RH140.2 190.2,29.33 RH191.2 ; CH33.1 196.94,27.58 v2(196.94,27.8)
  BOTTOM w0.254: v2(197.7,27.77) UH1.AE35 ; UH1.AE36 v2(196.94,27.8)
+3V_1.8V_PGPPHK: length 15.8
  TOP w0.508: v2(196.94,30.31) 195.76,31.49 193.84,31.49 193.49,31.14 RH146.1 192.9,31.14 191.64,32.41 CH32.1 191.57,32.43 v2(190.5,32.43) 190.23,32.71 v1(190.23,33.16) RH139.2
  BOTTOM w0.254: UH1.AC35 197.06,30.31 v2(196.94,30.31) UH1.AC36
  BOTTOM w0.356: RH99.2 187.36,32.31 186.96,32.71 RH203.2 RH202.2
  BOTTOM w0.508: v2(190.5,32.43) 190.38,32.31 RH100.1 RH99.2
+3V_GSEN: length 20.8
  TOP w0.254: U9.9 178.21,48.25 178.92,48.96 C5247.2 ; C5246.2 177.71,48.73 v1(177.71,48.61) U9.10
  TOP w0.381: v2(177.1,50.06) 177.87,49.3 C5246.2 ; v2(179.22,42.77) 179.04,42.96 R5801.1 178.18,43.53 R5798.2
  TOP w0.508: D511.1 181.39,48.74 180.78,49.35 R5247.2 C5245.2 179.63,49.3 C5247.2 C5246.2
  IN2 w0.381: v2(179.22,42.77) 178.01,42.77 176.98,43.8 176.98,49.94 v2(177.1,50.06)
+3V_LDO3V3: length 6.9
  TOP w0.203: UU4.9 42.95,42.86 42.71,43.09
  TOP w0.254: 42.71,43.09 41.95,43.86 39.84,43.86 39.58,44.12 39.58,44.74 RU65.1
  TOP w0.508: RU65.1 38.64,45.05 QT2.3
+3V_LID: length 711.8
  TOP w0.254: RK33.1 107.64,27.43 R125.2 R13.2 108.12,26.12 108.88,25.36 U4019.8 108.88,24.08 108.74,23.94 107.58,23.94 105.65,25.87 104.78,25.87 103.59,27.06 99.43,27.06 98.27,25.9 98.27,19 102.14,15.14 v2(102.14,14.24)
  TOP w0.381: R5242.1 204.38,129.94 203.92,130.41 203.92,132.61 v2(205.19,133.88) 205.95,134.64 D508.1 205.95,135.7 206.11,135.86 C395.1 208.49,136.37 U7.2
  TOP w0.508: v2(281.52,13.17) 281.83,13.49 PR21.2 ; PR18.1 273.11,18.44 v2(272.81,18.14) ; v2(171.2,27.33) 173.93,27.33 176.84,24.42 176.84,19.09 177.91,18.02 RH92.2 ; v2(162.72,26.58) 162.92,26.77 163.19,26.77 163.26,26.71 163.38,26.71 163.74,26.36 163.74,23.41 v1(163.83,23.33) 163.83,22.42 165.02,21.22 165.02,20.38 172.63,12.78 172.78,12.78 173.52,12.04 175.13,12.04 177.73,9.44 184.44,9.44 186.47,7.41 190.28,7.41 v2(191.07,8.2) ; v2(11.5,121.07) 11.62,121.07 R5243.1
  IN1 w0.381: v2(188.79,78.61) 189.18,78.61 189.43,78.87 189.43,80.55 189.02,80.96 189.02,83.56 186.16,86.43 185.54,86.43 177.38,94.59 177.38,100.21 177.38,100.21 177.38,102.74 175.95,104.17 175.95,106.15 174.73,107.38 174.73,107.67 171.8,110.59 169.52,110.59 168.86,111.25 168.86,115.9 173.51,120.55 177.86,120.55 181.36,124.05 181.36,127.23 180.45,128.14 180.45,130.51 182.63,132.69 182.63,134.09 183.72,135.18 183.72,135.62 v2(183.25,136.09)
  IN1 w0.508: v2(245.9,5.52) 244.18,5.52 243.06,6.64 240.61,6.64 240.05,6.08 234.7,6.08 232.05,8.73 232.05,9.41 230.88,10.58 228.39,10.58 226.35,8.54 226.35,8.2 223.51,5.35 193.93,5.35 v2(191.07,8.2)
  IN2 w0.381: v2(276.19,39.19) 276.19,39.4 275.87,39.72 272.68,39.72 272.51,39.55 262.62,39.55 261.27,40.91 260.48,40.91 260.43,40.85 260.33,40.75 258.17,40.75 257.75,41.17 255.66,41.17 255.47,41.36 255.29,41.36 254.31,42.34 249.9,42.34 249.02,43.22 245.54,43.22 243.59,41.27 240.47,41.27 240.12,40.91 238.74,40.91 238.36,41.29 238.36,42.7 237.87,43.19 232.45,43.19 231.3,42.04 225.94,42.04 218.31,49.67 196.34,49.67 196.29,49.72 195.28,49.72 189.93,55.07 189.93,68.61 188.91,69.63 188.91,70.77 189.76,71.62 189.76,73.12 188.74,74.13 188.74,78.56 v2(188.79,78.61)
  IN2 w0.508: v2(21.89,65.41) 21.89,66.15 22.42,66.68 22.42,72.92 21.61,73.73 21.61,75.52 20.53,76.6 20.53,85.37 19.13,86.76 19.13,99.67 18.41,100.39 18.41,116.75 17.79,117.37 17.79,119.04 16.71,120.12 14.79,120.12 13.95,120.97 11.59,120.97 v2(11.5,121.07) ; v2(245.9,5.52) 246.59,6.21 248.86,6.21 249.5,5.57 275.43,5.57 281.52,11.66 v2(281.52,13.17) ; v2(51.34,38.7) 52.77,37.27 52.77,36.49 53.93,35.33 53.93,28.85 58.58,24.21 60.79,24.21 61.32,23.69 61.32,23.11 66.24,18.18 74.91,18.18 76.11,16.98 99.04,16.98 101.78,14.24 v2(102.14,14.24)
  IN3 w0.508: v2(272.81,18.14) 273.99,18.14 278.96,13.17 v2(281.52,13.17) ; v2(21.89,65.41) 21.27,64.79 21.27,63.11 22.7,61.68 22.7,57.72 24,56.41 26.76,56.41 28.43,54.74 30.41,54.74 31.44,53.71 32.19,53.71 33.23,52.66 34.85,52.66 35.5,52.02 35.5,50.63 40.24,45.9 40.56,45.9 41.44,45.02 41.44,44.24 43.65,42.02 43.67,42.02 ; 49.65,40.57 49.91,40.57 51.34,39.15 v2(51.34,38.7) ; v2(171.2,27.33) 170.4,26.53 167.28,26.53 166.7,27.11 166.7,27.14 166.43,27.41 164.71,27.41 164.67,27.45 163.94,27.45 163.94,27.44 163.93,27.44 163.9,27.41 163.56,27.41 v2(162.72,26.58) 162.21,27.09 161.05,27.09 160.79,26.83 150.25,26.83 148.98,25.57 140.91,25.57 139.31,27.17 137.81,27.17 136.66,26.01 135.82,26.01 133.69,23.87 133.69,23.2 131.94,21.45 131.94,20.51 132.95,19.51 132.95,18.87 134.55,17.27 134.55,16.62 134.15,16.22 133.59,16.22 132.36,14.99 129.06,14.99 127.53,16.52 124.72,16.52 124.32,16.12 122.53,16.12 121.94,16.71 115.93,16.71 115.71,16.5 111.56,16.5 110.99,15.93 104.48,15.93 103.56,15.01 102.79,15.01 102.14,14.35 v2(102.14,14.24)
  BOTTOM w0.381: v2(276.19,39.19) 276.55,38.83 276.55,29.33 276.76,29.12 276.76,25.23 274.83,23.3 274.83,20.16 v2(272.81,18.14) ; v2(205.19,133.88) 203.73,133.88 203,133.16 200.21,133.16 196.92,136.44 183.61,136.44 v2(183.25,136.09)
+3V_PCH_PRIM: length 343.1
  TOP w0.254: 208.64,9.12 208.64,8.33 208.87,8.1 RH230.2 ; 208.64,9.12 QC10.5 207.71,9.12 RH231.2 206.3,8.79 206.3,9 205.81,9.5 RH226.2 205.24,9.5 205.05,9.31 QC7.2 ; 208.64,9.12 QC10.2 ; RH179.1 206.28,17.17 207.01,16.43 v2(207.4,16.43)
  TOP w0.381: v2(173.28,24.18) 173.28,23.09 172.6,22.4 172.6,19.02 v2(172.95,18.67) ; v2(21.4,5.72) 22.16,5.72 R5219.2 ; v2(126.37,14.11) 126.37,10.79 v2(126.97,10.2) ; RH223.2 202.39,13.74 v2(202.14,13.49) 201.63,13.99 RH222.2
  TOP w0.508: 187.3,32.79 188.7,34.19 RH139.1 ; 187.3,32.79 188.24,31.85 188.24,30.12 189.01,29.36 RH140.1 ; 187.3,32.79 186.9,32.39 186.9,31.89 186.56,31.54 185.2,31.54 184.71,31.06 RH215.2 ; 204.59,7.39 204.59,7.85 203.13,9.31 QC7.5 202.38,9.31 202.14,9.55 202.14,10.22 202.72,10.8 RH227.2 202.72,12.9 v2(202.14,13.49) 201.5,12.85 198.73,12.85 198.2,13.37 v2(198.2,13.61) ; v2(196.78,13.74) 196.93,13.89 RH143.1 ; 205.91,7.39 205.91,7.88 206.28,8.25 RH231.2 ; RH218.2 RH219.2 RH221.2 ; RH91.1 203.15,34.3 v2(203.39,34.53) ; RH217.2 RH216.2 ; 206.2,25.3 206.84,25.93 209.25,25.93 RH35.1 210.01,26.69 RH36.1 211.53,27.32 C5278.2 213.36,26.52 214.2,25.68 RH38.1 RH37.1 RH33.1 RH34.1 RH178.1 RH213.1
  IN1 w0.254: v2(216.46,8) 214.81,9.65 209.68,9.65 208.82,10.51 207.59,10.51 206.77,11.34 206.77,11.69 204.26,14.2 202.85,14.2 v2(202.14,13.49)
  IN1 w0.381: v2(209.73,14.84) 208.98,14.84 v2(207.4,16.43)
  IN1 w0.508: v2(203.39,34.53) 203.39,33.78 204.35,32.81 205.61,32.81 207.53,30.89 207.53,28.92 205.89,27.27 205.89,25.47 v2(205.24,24.83)
  IN2 w0.381: v2(126.97,10.2) 126.97,9.46 125.58,8.07 91.1,8.07 89.12,10.04 75.73,10.04 72.42,13.35 66.64,13.35 66.25,12.96 62.72,12.96 59.41,9.65 46.07,9.65 41.97,5.55 21.57,5.55 v2(21.4,5.72) ; v2(172.95,18.67) 172.88,18.74 169.45,18.74 167.99,17.27 154.16,17.27 152.9,16.01 151.03,16.01 149.9,14.87 144.22,14.87 142.92,13.57 135.51,13.57 134.41,14.67 133.6,14.67 133.23,15.05 132.07,15.05 131.7,14.67 126.93,14.67 v2(126.37,14.11)
  IN3 w0.254: v2(269.28,21.37) 269.23,21.32 269.23,18.4 268.88,18.05 264.17,18.05 263.35,17.22 258.51,17.22 258.15,17.58 236.99,17.58 236.54,17.12 235.41,17.12 234.6,16.31 226.36,16.31 223.81,13.77 223.81,13.31 221.82,11.32 221.14,11.32 219.44,9.62 219.44,9.09 218.1,7.74 216.72,7.74 v2(216.46,8)
  BOTTOM w0.254: v2(193.59,24.22) 193.2,23.83 UH1.AT44 ; v2(269.28,21.37) 269.28,21.82 267.7,23.4 PR1801.1 ; v2(205.24,24.83) 205.22,24.8 UH1.AN21
  BOTTOM w0.305: 196.55,14.25 196.55,13.89 196.7,13.74 v2(196.78,13.74) ; v2(202.14,13.49) RH224.2 RH225.2 202.91,14.21 RH95.1 RH97.1 RH194.1
  BOTTOM w0.356: v2(201.38,24.19) 201.77,24.19 UH1.AP26 ; v2(198.2,13.61) 198.2,13.87 198.56,14.23 RH63.1 ; UH1.AN26 201.9,24.78 v2(201.38,24.78)
  BOTTOM w0.381: v2(179.24,30.12) 178.24,30.12 173.28,25.17 v2(173.28,24.18)
  vias: v2(183.3,25.96) v2(183.73,26.4) v2(184.13,26.8) v2(209.73,15.43) v2(216.48,19.56) v2(217.01,19.39) v3(182.05,27.85)
+3V_PHVC: length 2.7
  TOP w0.33: RH90.2 209.94,20.04 v1(209.94,20.63) 209.94,21.07 v2(209.87,21.13)
  BOTTOM w0.305: UH1.AW9 209.94,21.13 v2(209.87,21.13)
+3V_PHVLDO: length 1.7
  BOTTOM w0.305: v2(211.51,21.4) 211.23,21.4 UH1.AY8 v2(211.03,20.73) 211.03,20.16 UH1.BB7
  vias: v1(210.24,18.79)
+3V_SMBUS: length 71.5
  TOP w0.381: v2(128.61,6.85) 128.61,7.48 D514.1 D510.1 ; D517.1 111.71,25.76 111.35,26.12 111.35,26.71 111.89,27.24 113.95,27.24 114.4,26.79 116.26,26.79 116.36,26.89 v2(117.25,26.89) 117.25,25.61 v1(117.1,25.45) 116.31,24.67 116.31,20.21 114.93,18.83 114.93,17.55 v2(115.36,17.12) ; RH232.2 144.79,26.42 v2(144.55,26.18) 144.24,26.49 RH233.2
  BOTTOM w0.381: v2(128.61,6.85) 128.61,7.65 127.39,8.87 125.94,8.87 124.61,10.19 120,10.19 116.13,14.06 116.13,16.35 v2(115.36,17.12) ; v2(144.55,26.18) 143.98,25.6 136.34,25.6 136.25,25.51 136.2,25.51 135.8,25.12 134.49,25.12 134.26,25.34 132.43,25.34 132.27,25.5 131.4,26.37 124.21,26.37 124.21,26.37 123.89,26.37 123.67,26.16 122.73,26.16 122.1,26.16 121.4,25.45 118.68,25.45 117.48,26.65 117.25,26.88 v2(117.25,26.89)
+3V_SPI: length 60.5
  TOP w0.508: v2(184,32.9) 185.48,34.39 185.48,36.9 188.18,39.6 v2(188.18,43.12) v3(188.18,44.18) v2(185.16,47.2) ; RH98.2 RH138.2 v2(183.75,24.79)
  IN2 w0.381: v2(193.01,24.3) 191.81,24.3 190.35,25.77 189.84,25.77 188.94,24.88 187.94,24.88 187.38,24.31 184.22,24.31 v2(183.75,24.79)
  BOTTOM w0.254: UH1.AN44 193.01,24.68 v2(193.01,24.3)
  BOTTOM w0.508: RH4.2 180.44,52.47 179.98,52.93 179.98,53.62 180.43,54.06 182.12,54.06 ; v2(184,32.9) 184.42,32.48 184.42,29.2 182.52,27.3 182.52,25.33 183.07,24.79 v2(183.75,24.79) 183.75,24.34 RH175.1 ; RH3.2 188.37,43.31 v2(188.18,43.12) ; 182.12,54.06 182.33,53.86 CH2.1 183.18,53.36 183.35,53.54 UH2.8 ; 182.12,54.06 182.56,54.5 185.16,54.5 185.49,54.17 185.49,47.53 v2(185.16,47.2)
+3V_TBTC_PDLDO: length 99.6
  TOP w0.381: v2(56.71,46.94) 56.71,43.62 55.52,42.43 53.62,42.43 RU51.1
  TOP w0.457: RU65.2 40.18,45.97 40.7,45.44 RU66.1
  TOP w0.508: v2(36.44,37.77) 36.28,37.77 35.51,38.53 35.51,42.45 36.01,42.95 RU67.1 36.28,43.1 37.47,44.29 37.47,46.93 QT2.1 38.31,47.78 CU71.1 39.37,47.17 39.89,46.65 RU65.2 ; v2(57.32,30.27) 57.56,30.27 v3(58.05,30.75) v2(58.64,31.34)
  IN3 w0.381: v2(58.64,31.34) 59.07,30.91 60.09,30.91 60.34,30.65 63.92,30.65 64.3,31.03 64.3,32.17 63.48,32.99 63.48,39.7 64.86,41.08 64.86,43.96 63.2,45.62 56.87,45.62 56.71,45.78 v2(56.71,46.94)
  BOTTOM w0.508: v2(36.44,37.77) 36.44,37.76 37.29,36.92 39.3,36.92 40.38,35.84 41.43,35.84 42.35,34.92 44.49,34.92 45.38,35.81 45.93,35.81 46.44,36.32 46.44,36.62 47.34,37.53 51.71,37.53 52.37,36.87 52.37,35.83 53.58,34.62 53.58,30.5 54.13,29.95 ; 54.13,29.95 RU68.1 RU69.1 RU70.1 ; 54.13,29.95 57,29.95 v2(57.32,30.27) ; v2(58.64,31.34) 58.64,30.8 58.83,30.6 RU71.1 59.06,29.33 59.06,29.07 59.63,28.5 59.63,27.08 60.84,25.87 60.84,24.86 60.4,24.43 60.4,23.64 60.74,23.31 CU72.1 61.14,23.53 61.14,24.18 61.56,24.6 UU5.8
+3V_USB2: length 20
  TOP w0.127: v3(186.05,32.84) 185.37,32.17 RH263.1
  TOP w0.406: RH263.1 184.62,31.91 184.13,31.42 v2(183.81,31.42)
  TOP w0.508: RH91.2 203.03,32.51 203.03,31.95 v2(202.89,31.81)
  IN2 w0.508: 198.34,29.06 197.11,29.06 195.5,30.67 184.56,30.67 v2(183.81,31.42)
  BOTTOM w0.254: UH1.V23 v2(202.89,31.81)
+3VALW: length 419.2
  TOP w0.356: RH260.2 203.52,8.04 v2(203.45,8.11)
  TOP w0.381: v2(191.99,8.22) 191.87,8.22 191.28,8.82 190.15,8.82 187.53,11.43 v2(186.85,11.43)
  TOP w0.457: v2(139.03,26.18) 139.36,26.5 RK13.2 139.72,26.5 RK12.2
  TOP w0.508: v2(11.75,124.1) 11.34,123.7 D1.2 8.34,123.06 v2(8.76,122.64) ; C388.1 84.84,13.33 v2(84.57,13.07) ; v2(40.44,48.49) 40.66,48.49 41.24,47.91 RU53.2 ; 182.28,32.18 182.29,32.17 RH263.2 ; PR2504.1 103.61,16.57 103.56,16.62 102.96,16.62 101.75,17.84 101.75,19.17 102.69,20.11 103.53,20.11 103.54,20.1 ; DM5.5 89.63,10.49 v2(90.18,11.04) ; RH162.1 186.39,12.16 186.85,11.71 v2(186.85,11.43)
  TOP w0.762: 54.23,39.04 54.23,38.13 54.17,38.07 54.17,31.5 v2(55.05,30.62) 57.27,28.4 61.77,28.4 62.85,29.48 64.07,29.48 64.48,29.07 64.48,27.71 61.09,24.33 61.09,21.17 59.28,19.35 58.6,19.35 57.94,18.69 57.94,17.01 57.93,16.99
  TOP w1.016: 183.96,40.52 183.96,35.6 182.06,33.7 182.06,33.21
  IN1 w0.381: v2(270.28,48.29) 264.43,48.29 263.54,49.18 263.54,54.01 261.09,56.46 243.69,56.46 242.77,55.54 v2(232.88,55.54)
  IN1 w0.508: v2(193.96,13.71) 192.04,13.71 189.76,11.43 v2(186.85,11.43)
  IN2 w0.508: v2(51.68,42.5) 50.08,44.1 49.01,44.1 48.6,44.52 ; 43.98,45.34 43.34,44.69 42.36,44.69 41.78,45.28 41.78,46.32 40.84,47.27 40.84,48.1 v2(40.44,48.49) 39.79,47.85 38.89,47.85 38.19,48.54 38.19,49.51 34.76,52.94 33.57,52.94 33.31,53.21 32.69,53.21 31.92,53.98 31.19,53.98 30.69,53.47 28.26,53.47 27.82,53.92 27.82,54.98 27.5,55.3 27.5,57.63 27.15,57.98 23.34,57.98 22.58,58.74 22.58,61.72 19.85,64.46 19.85,64.91 19.34,65.42 19.34,66.01 19.86,66.52 19.86,70.23 20.1,70.46 20.1,72.19 18.15,74.14 18.15,75.43 17.44,76.14 17.44,82.91 17.22,83.13 17.22,83.82 17.2,83.84 17.2,84.35 17.21,84.36 17.21,84.41 17.83,85.03 17.83,99.17 v2(17.35,99.64)
  IN2 w1.016: 172.5,102.79 174.15,101.14 174.15,92 179.89,86.26 179.89,79.6 181.97,77.52 181.97,68.02 184.54,65.45 184.54,62.05 182.16,59.68 178.71,59.68 178.14,59.1 178.14,54.38 180.05,52.47 180.94,52.47 182,51.41 188.09,51.41 190.01,49.49 190.01,48.08 185.55,43.62 185.55,43.34
  IN3 w0.254: v2(241.8,21.95) 241.26,22.49 241.26,23.14 241.87,23.74 241.87,26.28 242.02,26.44 242.82,26.44 243.12,26.74 243.12,27.57 243.45,27.9 245.64,27.9 247.57,29.83 247.57,32.77 249.41,34.62 251.64,34.62 252.74,33.52 252.74,32.94 253.14,32.54 253.63,32.54 v2(253.96,32.86)
  IN3 w0.381: v2(139.03,26.18) 139.03,25.79 138.37,25.13 136.45,25.13 134.66,23.34 134.66,18.51 135.41,17.76 135.41,15.41 134.67,14.67 133.7,14.67 v2(133.26,14.23)
  IN3 w0.508: v2(17.35,99.64) 17.35,105.89 15.81,107.43 15.81,111.91 15.3,112.43 15.3,113.56 15.81,114.07 15.81,116.5 15.21,117.1 15.21,119.49 12.88,121.82 10.96,121.82 10.41,122.37 9.02,122.37 v2(8.76,122.64) ; v2(104.32,20.6) 101.27,20.6 98.19,23.67 98.19,24.84 97.83,25.19 96.93,25.19 96.66,24.93 95.31,24.93 92.6,22.22 v2(92.6,21.91)
  BOTTOM w0.254: PR303.1 253.55,33.58 253.96,33.17 v2(253.96,32.86) ; PR1004.1 241.25,21.95 v2(241.8,21.95)
  BOTTOM w0.305: JPWR1.5 v2(11.75,124.1) ; v2(193.96,13.71) 193.97,13.72 193.97,14.15 RH12.1
  BOTTOM w0.381: v2(191.99,8.22) 192.16,8.05 198.25,8.05 198.73,8.53 203.03,8.53 v2(203.45,8.11) ; 269.91,39.7 271.58,39.7 272.35,40.47 272.35,45.2 270.28,47.27 v2(270.28,48.29) ; PRV29.1 232.65,55.31 v2(232.88,55.54)
  BOTTOM w0.457: PRH9.1 v2(179.86,101.19)
  BOTTOM w0.508: UL2.5 60.13,12.85 CL28.1 59.24,13.84 57.63,15.44 v2(57.19,15.44) ; JTP1.8 85.2,13.28 84.99,13.07 v2(84.57,13.07) ; v2(51.68,42.5) 51.68,42.5 53.01,41.16 53.01,36.09 54.22,34.89 54.22,33.97 55.05,33.14 v2(55.05,30.62) ; v2(46.92,20.47) 46.31,20.47 RR1.1 ; PRM8.1 v2(92.6,21.91)
  vias: v2(56.57,15.44) v2(57.51,16.14) v2(97.41,13.55) v2(97.71,13.04) v2(97.97,13.59) v2(98.29,13.12) v2(104.96,20.6) v2(105.53,20.6) v2(106.09,20.6) v2(118.51,20.7) v2(119.07,20.71) v2(172.24,104.51) v2(172.24,103.94) v2(173.92,24.81) v2(174.34,14.25) v2(174.37,23.54) v2(174.76,23.94) v2(174.97,14.87) v2(174.97,14.26) v2(179.56,32.66) v2(181.04,32.81) v2(181.04,32.26) v2(181.4,106.79) v2(181.9,105.46) v2(183.12,43.22) v2(184.04,42.39) v2(236.46,25.54) v2(236.48,24.99) v2(244.19,21.7) v2(244.19,21.12) v2(244.77,21.7) v2(244.77,21.12) v2(245.36,21.7) v2(245.36,21.12) v2(245.94,21.7) v2(245.94,21.12) v2(246.52,21.7) v2(246.52,21.12) v2(247.11,21.7) v2(247.11,21.12) v2(268.02,40.7) v2(268.05,41.26) v2(268.42,41.68) v2(268.6,41.14) v2(268.57,40.58) v2(268.99,41.69) v2(269.13,40.56) v2(269.16,41.13) v2(269.55,41.68) v2(269.73,41.16) v2(269.71,40.57) v2(270.22,40.81) v2(270.42,20.69) v2(270.42,20.14) v2(270.42,19.58) v2(270.42,19.02) v2(271,20.69) v2(271,20.14) v2(271,19.58) v2(271,19.02) v2(303.98,8.52) v2(303.97,7.92) v2(304.4,10.63) v2(304.5,8.1) v2(305.06,8.88) v2(305.06,8.28) v2(305.06,7.67) v3(174.4,18.74) v3(174.41,16.08) v3(174.45,21.85)
+3VALW_DSW: length 13.9
  TOP w0.508: RH47.2 187.3,14.7 RH162.2 187.3,13.56 187.24,13.5 v1(187.24,12.93) 187.24,12.51 187.81,11.94 RH171.2 188.19,11.96 RH211.1 ; RH211.1 189.03,10.97 189.59,10.41 RH45.2 ; RH211.1 RH41.2 189.03,13.49 v2(188.8,13.71)
  BOTTOM w0.508: v2(188.8,13.71) CH34.1 188.8,15.14 189.32,15.65 189.32,17.43 189.44,17.55
+3VALW_EC: length 363.7
  TOP w0.254: RK7.2 152.48,10.08 152.22,9.82 UK1.33 ; CK2.1 139.86,6.63 140.44,7.21 UK1.9 ; v2(136.68,23.89) 136.72,23.85 UK1.96 ; UK1.124 134.24,11.42 133.84,11.02 133.33,11.02 133.1,10.79 CK8.1 ; v2(144.84,5) 144.84,6.52 145.64,7.32 UK1.22
  TOP w0.381: RK2.2 152.48,26.55 152.39,26.47 LK1.1 150.81,26.47 v2(150.52,26.18) ; v2(140.72,5) 140.72,5.81 140.2,6.34 CK2.1 ; v2(150,5.1) 150.18,5.28 150.18,6.11 149.94,6.35 CK1.1 ; RK21.1 131.74,19.74 131.66,19.81 130.97,19.81 ; v2(173.33,15.06) 172.18,15.06 168.07,19.17 168.07,23.73 v2(165.39,26.41) ; RG200.2 219.98,63.08 220.98,62.07 220.98,61.37 222.62,59.74 224.42,59.74 224.96,60.28 231.33,60.28 231.85,59.76 232.28,59.34 232.28,58.39 232.53,58.13 233.11,58.13 233.48,57.76 233.48,54.94 232.97,54.42 232.97,50.9 233.77,50.1 233.77,49.15 234.61,48.31 234.61,47.27 235.03,46.85 235.03,45.49 236.43,44.09 v3(238.08,44.09) 238.14,44.09 239.79,45.74 241.44,45.74 243.99,43.2 247.51,43.2 248.48,44.16 248.48,44.79 249.04,45.35 253.2,45.35 254.44,44.12 255.62,44.12 256.13,43.61 258.36,43.61 258.77,43.2 260.54,43.2 264.37,47.04 273.08,47.04 277.49,42.63 v2(277.49,42.16)
  TOP w0.508: v2(133.75,10.18) 133.74,10.19 133.67,10.19 CK8.1 ; RK1.2 129,12.63 v2(129.94,13.57) ; PR9.1 131.62,17.93 130.85,18.7 v2(130.85,18.95) 130.85,19.69 130.97,19.81 130.66,20.12 126.39,20.12 125.69,20.82 125.04,20.82 123.53,22.34 123.53,23.98 v2(123.35,24.16) ; PR10.1 130.7,24.47 v2(130.45,24.22) ; RK32.1 110.41,26.25 110.96,25.7 v2(110.96,24.99) ; CK1.1 149.7,6.59 153.05,9.93 RK7.2
  IN2 w0.381: v2(173.33,15.06) 173.69,15.42 175.28,15.42 175.6,15.1 175.6,14.16 175.95,13.8 180.7,13.8 182.21,12.29 184.41,12.29 185.88,10.82 187.3,10.82 187.71,11.23 190.3,11.23 191.12,12.05 197.31,12.05 197.58,12.32 200.4,12.32 201.02,12.94 209.34,12.94 209.83,13.43 210.82,13.43 211.14,13.12 216.89,13.12 221.76,17.99 221.76,18.27 222.46,18.97 222.46,24.19 228.75,30.48 236.79,30.48 239.06,30.48 239.45,30.87 240.5,30.87 247.07,30.87 247.79,30.15 252.94,30.15 255.93,27.16 273.48,27.16 273.6,27.28 v2(277.44,27.28)
  IN2 w0.508: v2(140.72,5) 141.34,5.63 144.47,5.63 144.84,5.26 ; 144.84,5.26 145.39,5.81 149.56,5.81 150,5.37 v2(150,5.1) ; 144.84,5.26 v2(144.84,5)
  BOTTOM w0.381: v2(277.49,42.16) 277.7,41.95 277.7,37.3 277.13,36.72 277.13,29.57 277.44,29.26 v2(277.44,27.28) ; v2(150.52,26.18) 150.78,26.18 151.25,25.71 151.31,25.71 151.61,25.4 156.4,25.4 156.41,25.38 156.73,25.38 157.16,25.38 158.07,25.38 158.08,25.39 160.74,25.39 160.76,25.4 163.22,25.4 163.84,26.03 164.7,26.03 165.09,26.41 v2(165.39,26.41)
  BOTTOM w0.508: v2(130.85,18.95) 130.85,18.63 131.23,18.25 131.23,16.98 130.91,16.66 130.91,15.46 129.94,14.5 v2(129.94,13.57) 129.94,12.7 132.47,10.18 v2(133.75,10.18) 135.87,10.18 140.72,5.33 v2(140.72,5) ; v2(110.96,24.99) 114.59,24.99 114.89,25.29 116.92,25.29 118.11,24.09 123.22,24.09 123.22,24.09 123.28,24.09 v2(123.35,24.16) 125.74,24.16 125.84,24.06 129.72,24.06 129.88,24.22 v2(130.45,24.22) 130.95,24.22 131.11,24.06 131.79,24.06 131.87,23.98 133.7,23.98 133.93,23.75 136.36,23.75 136.5,23.89 v2(136.68,23.89) 137.02,24.23 146.06,24.23 146.98,24.23 147.66,24.92 149.73,24.92 150.45,25.64 150.45,26.18 v2(150.52,26.18)
+3VALWP: length 12.8
  IN3 w0.381: v2(249.41,19.62) 250.4,20.61 250.4,27.24 v2(251.92,28.76)
  BOTTOM w0.254: PR304.2 252.49,28.76 v2(251.92,28.76) 251.92,29.45 251.72,29.64 PU301.14
  vias: v1(242.87,16.85) v2(241.66,20.43) v2(241.66,19.88) v2(241.66,19.32) v2(241.66,18.76) v2(241.66,18.2) v2(242.24,20.43) v2(242.24,19.88) v2(242.24,19.32) v2(242.24,18.76) v2(242.24,18.2)
+3VB_1.8V:
  vias: v2(268.43,19.9)
+3VDS_AUDIO: length 27.3
  TOP w0.203: UA1.18 298.76,21.03 299.13,20.67 299.36,20.67
  TOP w0.254: 299.36,20.67 300.1,20.67 300.17,20.6
  TOP w0.381: v2(293.26,15) 293.25,15.01 RA26.1 ; 300.17,20.6 300.33,20.44 300.33,20.07 300.31,20.04 CA3.1 CA4.1 301.48,19.71 v1(302.18,19.01) v2(302.98,18.21) ; RA25.1 LA1.1 289.51,12.27 v2(289.59,12.35)
  IN3 w0.381: v2(289.59,12.35) 290.91,13.67 291.29,13.67 292.62,15 v2(293.26,15) 293.26,14.65 293.57,14.34 300.67,14.34 303.23,16.9 303.23,17.96 v2(302.98,18.21)
+3VL: length 617.1
  TOP w0.305: 273.09,15.77 272.82,15.77 272.15,16.44
  TOP w0.381: Q80.2 16.73,121.42 16.73,120.05 17.01,119.77 v2(17.01,118.75) ; v2(205.94,133.75) 205.95,133.74 D508.2 ; PR16.1 284.18,17.21 v2(283.53,17.86) ; R295.2 131.58,11.64 131.02,11.09 131.02,9.68 130.77,9.44 D510.2 129.46,9.29 129.25,9.5 129.25,10.37 RK1.1 ; 272.15,16.44 271.75,16.85 v3(271.75,18.72) v2(273.49,20.46)
  TOP w0.457: RH234.2 RH235.2 141.51,26.49 v2(141.19,26.18)
  TOP w0.508: v2(42.73,47.39) 42.73,47.41 42.72,47.42 42.72,47.53 42.38,47.87 RU52.2 ; v2(105.88,22.82) 104.93,23.77 Q32.2 ; v2(128.25,10.2) 128.67,10.62 RK1.1 ; v2(167.72,27.33) 167.72,27.2 167.66,27.14 167.66,26.06 169.38,24.33 169.38,19.89 173.96,15.31 173.96,14.82 173.56,14.42 173.56,13.65 174.01,13.2 176.26,13.2 DH1.3 177.93,11.55 178.71,10.78 179.91,10.78 180.15,11.02 v2(180.15,11.36) ; v2(181.69,45.62) 182.38,46.31 D511.2
  IN1 w0.381: v2(168.37,110.81) 168.35,110.83 168.35,116.11 173.3,121.06 173.73,121.06 177.64,121.06 180.85,124.26 180.85,127.01 179.93,127.93 179.93,130.72 182.11,132.91 182.11,134.3 183.16,135.35 v2(183.16,135.4)
  IN2 w0.381: v2(174.62,44.78) 175.05,44.78 175.55,45.28 175.55,48.37 175.86,48.67 175.86,60.04 175.21,60.69 175.21,67.31 175.34,67.43 175.34,68.95 179.54,73.16 179.54,76.99 175.23,81.31 175.23,83.38 175,83.61 175,84.79 172.25,87.54 172.25,97.24 171.53,97.97 171.53,101.81 171.28,102.06 171.28,106.17 169.78,107.67 169.78,109.4 v2(168.37,110.81) ; v2(18.62,75.88) 18.02,76.48 18.02,80.32 18.88,81.18 18.88,82.4 17.81,83.47 v2(17.81,84.1) 18.41,84.7 18.41,99.56 17.82,100.15 17.82,114.98 16.34,116.47 16.34,118.43 16.66,118.75 v2(17.01,118.75)
  IN2 w0.508: v2(18.62,75.88) 18.8,75.7 18.8,74.43 20.75,72.48 20.75,70.19 20.51,69.96 20.51,66.34 20.59,66.26 20.59,64.64 23.24,61.99 23.24,59.01 23.61,58.63 27.66,58.63 29.23,57.06 30.52,57.06 32.08,55.5 32.78,55.5 33.65,54.63 34.56,54.63 35.31,53.88 35.31,53.74 35.32,53.73 35.32,53.35 36.09,52.59 36.12,52.59 36.27,52.43 37.32,52.43 37.47,52.59 37.82,52.59 38.01,52.46 38.2,52.27 38.21,52.27 39.97,51.06 40.6,50.66 41.16,50.3 41.38,50.07 41.38,48.76 42.73,47.41 v2(42.73,47.39) 42.75,47.39 43.05,47.1 44.93,47.1 45.25,46.78 46.21,46.78 46.4,46.59 46.94,46.59 47.38,46.15 47.38,45.73 47.74,45.37 50.06,45.37 53.02,42.41 55.84,42.41 56.84,43.41 66.99,43.41 68.7,45.11 v2(77.01,45.11) ; 253.57,23.52 270.43,23.52 v2(273.49,20.46) ; v2(252.03,24.84) 252.03,26.13 249.88,28.28 241.93,28.28 241.33,28.28 240.25,29.36 237.81,29.36 229.22,29.36 225.05,25.18 225.05,20.15 225.32,19.88 225.32,17.89 224.05,16.62 v2(224.05,15.2) 222.97,14.13 222.97,13.62 221.08,11.73 216.1,11.73 215.15,10.78 211.24,10.78 210.36,9.9 207.91,9.9 207.42,10.39 206.58,10.39 206.35,10.15 203.75,10.15 203.46,10.44 197.99,10.44 197.31,9.77 192.29,9.77 192.28,9.76 189.74,9.76 188.78,8.79 182.29,8.79 180.15,10.92 v2(180.15,11.36)
  IN3 w0.381: v2(283.53,17.86) 283.01,18.37 278.84,18.37 276.2,21.01 274.03,21.01 v2(273.49,20.46)
  IN3 w0.508: v2(174.62,44.78) 174.94,44.46 179.4,44.46 180.56,45.62 v2(181.69,45.62) ; v2(77.01,45.11) 77.65,45.74 80.1,45.74 81.12,46.76 82.33,46.76 82.93,47.36 90.27,47.36 96.66,40.96 96.66,28.75 102.59,22.82 v2(105.88,22.82) 107.57,22.82 108.25,23.5 112.26,23.5 112.73,23.97 114.18,23.97 115.28,25.06 118.99,25.06 119.96,26.03 v2(119.96,26.03)
  BOTTOM w0.381: v2(205.94,133.75) 205.45,133.26 203.91,133.26 203.29,132.64 200.04,132.64 196.79,135.89 183.86,135.89 183.37,135.4 v2(183.16,135.4) ; v2(224.05,15.2) 224.25,15.2 226.83,12.62 PRB44.1 ; v2(17.81,84.1) 17.61,83.89 RS43.1
  BOTTOM w0.508: v2(105.88,22.82) 105.88,22.66 108.58,19.96 116.97,19.96 119.21,17.72 119.21,12.66 120.49,11.37 127.07,11.37 v2(128.25,10.2) ; v2(18.62,75.88) 18.31,75.56 17.77,75.56 17.36,75.97 RS17.2 ; v2(174.62,44.78) 174.78,44.62 174.78,42.16 173.38,40.76 173.38,39.12 173.08,38.81 172.96,38.7 172.96,37.77 173.84,36.89 173.84,36.18 174.63,35.39 174.63,33.15 171.48,30 171.48,29.43 171.48,29.42 171.48,29.3 169.5,27.33 v2(167.72,27.33) 167.59,27.33 167.58,27.34 161.07,27.34 160.56,26.83 160.56,26.76 160.29,26.49 157.62,26.49 157.62,26.49 157.19,26.49 157.19,26.49 156.87,26.49 156.57,26.79 156.54,26.81 151.71,26.81 151.41,27.11 151.18,27.34 149.67,27.34 149.33,27 149.11,27 149.11,27 147.39,27 147.2,26.8 142.8,26.8 142.17,26.18 v2(141.19,26.18) 140.44,26.18 139.8,26.82 136.73,26.82 136.37,26.45 136.37,26.45 136.01,26.09 135.96,26.09 135.56,25.69 134.73,25.69 134.5,25.92 132.67,25.92 131.64,26.95 124.45,26.95 123.65,26.95 123.43,26.73 122.97,26.73 120.66,26.73 v2(119.96,26.03)
  vias: v2(252.38,24.3)
+3VL_RTC: length 18.9
  TOP w0.356: v2(190.18,19.1) 190.15,19.07 189.69,19.07 CH26.1 CH84.1 188.09,19.2 187.68,19.61 186.8,19.61 RH32.1
  TOP w0.508: DH1.1 179.99,13.38 179.66,13.71 CH27.1 179.66,15.94 181.49,17.77 v1(182.34,17.77) 185.65,17.77 186.24,17.17 RH6.1 RH31.1 RH32.1
  BOTTOM w0.254: UH1.BD49 190.55,19.04 v2(190.18,19.1) 190.19,19.25 UH1.BC49
+3VL_TBTC: length 4.4
  TOP w0.203: CU70.1 42.14,45.97 42.14,44.83 42.52,44.46 UU4.5
  TOP w0.508: RU53.1 RU52.1 42,46.95 CU70.1
+3VLP: length 1.2
  BOTTOM w0.127: v1(253.38,27.98) 252.95,27.54 PC310.1
+3VS: length 809.7
  TOP w0.254: v2(202.52,16.2) 202.52,16.49 201.5,17.5 RH53.2 RH96.1 ; RC377.2 204.86,13.22 QC8.2
  TOP w0.305: QC8.5 204.59,15.52 205.16,16.09 205.16,16.1 ; v2(56.84,16.3) 56.96,16.42 56.96,17.2 RM6.1
  TOP w0.381: RG111.1 235.66,51.41 RG113.1 235.66,51.05 235.78,50.93 235.78,50.6 236.34,50.04 237.32,50.04 v2(237.36,50) 237.36,49.86 237.89,49.33 237.89,48.81 236.81,47.74 236.17,47.74 235.73,47.3 235.73,45.76 236.23,45.26 v2(236.27,45.26) ; RD21.1 146.79,29.77 149.89,29.77 150.4,30.27 150.4,31.94 v2(150.31,32.03) 149.67,32.67 149.67,37.38 RD2.1 ; v2(225.81,11.63) 226.1,11.92 226.1,12.42 226.56,12.88 QC9.5 QC9.2 ; 178.76,126.17 178.06,126.87 178.06,129.47 177.48,130.05 175.38,130.05 175.17,130.26 PRZ18.1 ; R5247.1 180.75,50.26 181.22,50.74 182.63,50.74 183.65,49.72 183.65,47.63 185.83,45.44 v2(185.83,40.77) ; R5220.1 v2(17.48,5.76) ; 205.16,16.1 RC376.2 205.16,17.11 v2(205.27,17.22) 204.93,17.56 RH79.2 RH81.2 RH82.1 ; RK14.1 144.02,5.09 v2(143.93,5) ; UH3.5 218.91,8.28 CH1.1 ; CD61.2 167.48,39 167.75,38.73 CD60.2 ; v2(168.84,51.59) 168.86,51.59 168.99,51.46 CD2.2 CD102.2 169.42,52.52 CD1.2
  TOP w0.508: CH1.1 v2(220.05,8.66) 220.35,8.66 220.68,8.99 220.68,10.61 222.03,11.96 222.03,15.98 221.57,16.44 218.98,16.44 218.13,17.3 RH209.1 ; 26.47,66.19 23.86,66.19 RV21.1 22.13,64.3 20.12,62.3 20.12,57.86 CV33.1 21.09,57.76 v2(22,57.76) ; 26.47,66.19 CV31.1 28.43,66.19 28.79,65.83 v2(29.02,65.83) ; 26.47,66.19 26.47,66.93 25.98,67.42 25.34,67.42 25.23,67.3 23.61,67.3 22.26,68.65 22.26,71.21 14.64,78.84 14.64,79.47 v2(14,80.11) ; v2(32.44,61.29) 31.63,60.48 RV35.1 RV34.1 ; 66.83,42.77 65.35,42.77 64.83,42.24 64.83,40.98 C5251.1 C5254.1 64.64,39.27 64.6,39.23 U12.6 ; 66.83,42.77 67.96,41.64 67.96,37.91 67.77,37.72 R5807.1 ; 66.83,42.77 v3(68.72,44.66) 71.17,47.11 72.01,47.11 v2(72.22,47.33) ; v2(200.49,13.55) RH206.1 RH208.1 RH205.1 RH207.1 ; RU57.1 43.47,37.74 RU58.1 44.47,37.53 44.47,36.3 44.81,35.95 45.34,35.95 ; v2(177.87,67.77) 177.64,68 177.64,68.8 183.74,74.89 184.4,74.89 187.24,77.74 v2(188.1,77.74) 188.1,78.04 187.97,78.18 187.97,80.24 187.96,80.24 187.96,82.35 v2(188.22,82.6) ; LA1.2 287.57,9.66 v2(287.57,5.61) 287.02,5.61 286.31,6.32 279.68,6.32 v2(278.7,5.34) ; RC377.2 204.86,12.35 204.23,11.72 v2(204.23,11.3) ; RE1.1 274.08,43.15 v2(274.08,42.54) ; v2(181.34,122.5) 181.34,122.63 180.99,122.97 Q7.2 ; v2(100.55,26.55) 100.55,26.27 100.16,25.87 99.1,25.87 98.78,25.55 98.78,23.37 100.56,21.59 100.56,17.44 103.94,14.06 103.94,13.51 105.39,12.06 109.54,12.06 109.86,11.75 113.83,11.75 115.18,10.4 116.46,10.4 116.66,10.59 121.28,10.59 v2(123.14,8.73) ; v2(300.23,12.49) 300.92,13.18 QWL1.2 ; v2(235.79,54.98) 236.11,54.98 v2(237.98,56.85) ; 45.34,35.95 45.74,36.35 v2(45.74,36.59) RU61.1 ; 45.34,35.95 45.97,35.33 47.64,35.33 48.16,35.84 48.91,35.84 49.93,34.83 49.93,25.54 49.1,24.71 49.1,22.18 48.45,21.53 46.74,21.53 45.86,20.64 45.86,17.63 v2(47.29,16.2) ; Q7.5 178.4,122.97 v2(178.06,122.63) 177.18,123.51 177.18,124.6 178.76,126.17 R5285.2 180.38,126.17 R5284.2 ; v2(214.08,7.77) 214.36,8.05 RH78.2 RH76.2 RH228.2 RH229.2 ; v6(296.4,15.96) 296.61,16.17 RA54.1 ; RD19.1 166.84,37.39 166.87,37.37 167.76,37.37 RD20.1 167.75,37.38 CD60.2 168.35,38.24 RD1.1 ; R5247.1 180.57,50.49 179.7,51.35 178.82,51.35 v2(178.68,51.21) 178.54,51.36 175.03,51.36 174.72,51.66 174.02,51.66 170.44,55.24 169.35,55.24 168.59,54.48 168.59,53.36 CD1.2 168.51,52.86 168.13,52.47 168.13,50.98 167.27,50.12 167.27,42.57 167.34,42.51 RD4.1
  IN1 w0.508: v2(200.49,13.55) 200.49,12.18 197.53,9.22 v2(197.53,8.89) ; v2(204.23,11.3) 204.23,9.71 205.29,8.65 v2(205.29,7.88)
  IN2 w0.508: v2(202.52,16.2) 202.52,16.44 203.15,17.07 203.15,17.34 203.76,17.96 204.53,17.96 v2(205.27,17.22) ; v2(178.06,122.63) 178.19,122.5 v2(181.34,122.5)
  IN3 w0.381: v2(168.01,40.01) 167.59,39.59 167.59,37.92 167.12,37.45 152.02,37.45 150.31,35.74 v2(150.31,32.03) ; v2(124.12,90.39) 125.42,90.39 125.75,90.71 127.89,90.71 128.38,90.23 130.27,90.23 130.76,90.73 131.56,90.73 132.99,92.15 135.64,92.15 136.3,91.49 137.05,91.49 137.65,92.09 141.24,92.09 141.64,91.69 142.54,91.69 144.2,93.36 161.08,93.36 161.96,94.23 166.35,94.23 167.85,95.74 169.64,95.74 v2(170.09,96.19)
  IN3 w0.457: v2(200.49,13.55) 200.49,13.79 202.52,15.82 v2(202.52,16.2)
  IN3 w0.508: v2(309.58,42.57) 309.03,43.11 299.97,43.11 297.31,45.77 281.6,45.77 278.98,43.15 274.64,43.15 274.08,42.59 v2(274.08,42.54) 274.08,41.65 272.14,39.71 265.47,39.71 ; v2(262.56,40.48) 262.55,40.47 262.36,40.66 258.84,40.66 257.94,39.76 257.94,37.82 256.85,36.73 255.86,36.73 254.29,38.3 251.96,38.3 250.33,39.93 245.24,39.93 244.23,38.93 239.97,38.93 238.37,40.53 238.37,43.38 237.28,44.47 237.28,45.88 237.58,46.18 237.58,47.19 237.36,47.4 v2(237.36,50) 236.27,51.09 236.27,51.92 236.64,52.29 236.64,52.87 235.79,53.73 v2(235.79,54.98) ; v2(188.22,82.6) 187.96,82.86 187.96,85.25 187.21,86 185.68,86 v2(175.86,95.83) 175.86,97.3 174.82,98.33 174.82,103.62 173.69,104.76 v2(173.69,105.11) 173.69,105.11 173.69,105.66 174.57,106.54 174.57,109.42 179.82,114.66 179.82,117.91 178.06,119.67 v2(178.06,122.63) ; v2(14.49,118.98) 14.49,118.4 14.56,118.33 14.56,116.8 15.16,116.2 15.16,114.34 14.65,113.83 14.65,112.16 15.16,111.64 15.16,107.16 16.36,105.96 16.36,82.47 v2(14,80.11)
  BOTTOM w0.203: UV2.1 22.51,59.08 22,58.57 ; 28.06,65.22 UV2.24
  BOTTOM w0.254: JIO1.6 309.2,43.25 309.58,42.87 v2(309.58,42.57)
  BOTTOM w0.305: JDIMM1.255 169.52,51.25 169.19,51.59 v2(168.84,51.59) ; CV274.1 180.68,122.14 UC3.1 ; v2(200.49,13.55) 200.87,13.93 200.87,14.15 200.94,14.23 ; v2(168.01,40.01) 167.7,39.7 167.7,39.2 168.03,38.87 JDIMM2.255
  BOTTOM w0.356: RH154.1 RH94.1
  BOTTOM w0.381: R1.1 36.66,14.37 v2(36.15,14.37) ; RH164.1 RH170.2 187,28.97 186.42,29.54 186.42,33.31 186.42,33.32 186.42,33.38 185.61,34.18 185.61,36.13 185.8,36.33 185.8,40.74 v2(185.83,40.77) ; RG106.1 234.19,43.65 234.22,43.67 234.22,43.7 234.61,44.1 UG10.5 235.67,44.65 v2(236.27,45.26) 235.37,45.26 235,45.63 235,46.73 RG108.1 ; v2(237.98,56.85) 237.97,56.84 PRW1.1
  BOTTOM w0.508: RV135.2 178.14,120.6 177.93,120.8 177.93,122.5 v2(178.06,122.63) ; v2(100.55,26.55) 100.55,30.2 99.54,31.21 99.54,35.45 101.42,37.33 101.42,51.05 102.29,51.92 106.44,51.92 108.48,53.97 109.66,53.97 112.2,56.51 164.57,56.51 165.73,55.34 170.81,55.34 174.78,51.37 178.52,51.37 v2(178.68,51.21) 178.68,51.37 178.45,51.61 178.45,54.61 178.68,54.85 178.68,57.31 176.51,59.48 176.51,65.63 177.87,66.99 v2(177.87,67.77) ; v2(45.74,36.59) 45.74,38.72 RE3.1 ; RC43.1 123.33,86.36 123.33,89.6 v2(124.12,90.39) ; v2(173.69,105.11) 173.69,104.68 PRF2.1 ; RV38.1 15.31,120.04 QV1.2 14.97,119.46 v2(14.49,118.98) ; RR15.2 45.36,14.63 v2(44.75,14.02) ; RA3.1 296.18,16.18 v6(296.4,15.96) 296.89,15.96 297.32,15.53 297.32,15.41 v2(300.23,12.49) 299.98,12.25 292.17,12.25 290.36,10.43 290.36,7.1 288.87,5.61 v2(287.57,5.61) ; UG11.5 186.04,77.76 186.07,77.74 v2(188.1,77.74) ; CV274.1 181.34,121.54 v2(181.34,122.5) 181.34,128.79 180.48,129.64 RV136.1 ; RG14.1 235.79,56.24 v2(235.79,54.98) ; QR2.2 v2(49.81,15.42) ; RV23.1 RV14.1 ; RV23.1 31.63,61.09 32.24,61.09 v2(32.44,61.29) ; RV23.1 RV26.1 ; RG392.2 185.91,82.19 186.45,82.73 188.1,82.73 v2(188.22,82.6) ; v2(170.09,96.19) 170.45,95.83 v2(175.86,95.83) ; RV16.1 29.02,64.97 v2(29.02,65.83) 28.79,65.83 28.33,66.29 CV32.1 28.06,66.21 28.06,65.22 ; 22,58.57 v2(22,57.76)
  vias: v2(29.21,58.07) v2(29.6,57.67) v2(35.64,16.03) v2(35.64,15.39) v2(35.64,14.76) v2(35.94,57.5) v2(36.15,15.64) v2(36.15,15.01) v2(36.34,57.12) v2(72.85,47.47) v2(76.98,20.54) v2(77.58,20.55) v2(246.12,8.91) v2(246.12,8.33) v2(246.12,7.74) v2(263.03,40.85) v2(263.51,40.44) v2(263.85,40.91) v2(264.14,40.44) v2(264.46,41.24) v2(264.63,40.71) v2(265.02,41.27) v2(265.57,41.25) v2(276.79,24.46) v2(277.32,25.05) v2(277.35,24.46) v2(277.6,25.58) v2(277.88,25.04) v2(277.91,24.46) v2(278.57,7.8) v2(278.57,7.21) v2(278.57,6.63) v2(279.02,24.32) v2(278.96,23.76) v2(279.48,23.98)
+3VS_CAMERA: length 19.6
  TOP w0.254: v2(66.64,41.7) 66.5,41.56 R5806.2
  TOP w0.508: U12.1 64.6,34.9 64.65,34.85 C5253.1 C5255.1 64.65,33.12 64.62,33.1 C5274.2 64.62,31.67 v3(65,31.29) 65.47,31.29 v2(65.78,31.59)
  IN3 w0.254: v2(66.64,41.7) 66.64,41.37 63.94,38.67 63.94,33.43 v2(65.78,31.59)
  BOTTOM w0.254: JEDP1.10 65.55,31.37 v2(65.78,31.59)
+3VS_CR: length 17.5
  TOP w0.127: v2(46.92,19.71) 46.52,19.31 v1(46.52,19.28)
  IN1 w0.508: v2(38.54,15.14) 38.98,15.14 39.63,15.78 39.63,18.4 40.14,18.91 43.91,18.91 44.56,19.56 46.77,19.56 v2(46.92,19.71)
  BOTTOM w0.203: UR1.11 38.43,16.26 38.28,16.41 CR2.1
  BOTTOM w0.508: RR2.1 46.31,19.71 v2(46.92,19.71) ; v2(38.54,15.14) 38.03,14.63 R1.2 37.83,15.49 CR7.1 CR2.1
+3VS_MUX: length 28
  TOP w0.127: v1(37.46,55.17) 37.37,55.08 RT6.2
  TOP w0.203: UT11.28 30.08,54.03 29.64,54.47 ; UT11.6 32.15,46.44 32.33,46.26 32.33,45.31 v2(32.47,45.17) ; UT11.1 30.15,47.5 v2(29.85,47.19)
  TOP w0.305: RT807.2 30.76,56.47 30.52,56.72 29.64,56.72 v2(29.38,56.45)
  TOP w0.381: v2(29.85,47.19) 29.85,47.33 29.44,47.74 28.33,47.74 28.02,47.43 27.35,47.43 27.06,47.14 27.06,45.51 27.28,45.29 RT814.1 27.65,44.59 28.02,44.22 28.63,44.22 29.44,45.03 RT847.1 ; 29.64,54.47 29.35,54.76 CT271.1 27.72,54.56 27.86,54.42 RT859.2 27.92,54.13 v2(28.52,54.13)
  IN3 w0.457: v2(32.47,45.17) 30.44,47.19 v2(29.85,47.19)
  BOTTOM w0.381: RT813.1 v2(29.85,47.19) RT856.1 29.86,47.8 29.86,47.84 CT273.1 CT272.1 28.87,48.4 28.35,48.92 28.35,49.05 28.11,49.29 RT850.1
  vias: v2(26.18,50.82) v2(34.08,53.63) v2(34.68,53.61)
+3VS_SSD:
  vias: v2(18.67,2.92) v2(19.23,2.94) v2(19.79,2.96) v2(20.41,2.96) v2(30.14,2.93) v2(30.71,2.89) v2(31.27,2.92) v2(31.83,2.94) v2(35.99,2.72) v2(36.55,2.75) v2(36.74,12.26) v2(36.74,11.68) v2(37.11,2.77) v2(37.32,12.26) v2(37.32,11.68) v2(37.89,12.16) v2(37.89,11.57) v3(21.65,3.05) v3(24.22,3.05) v3(29.52,2.92)
+3VS_TPM: length 24.6
  TOP w0.203: CTT2.1 127.55,17.93 127.15,17.93 126.88,17.66 UT1.22
  TOP w0.254: CTT323.1 124.02,13 UT1.14 ; 119.73,14.86 120.04,15.16 UT1.8 ; CTT4.1 119.11,19.16 119.58,19.16 120.08,18.66 UT1.1
  TOP w0.381: CTT2.1 127.55,18.43 v2(127.19,18.43)
  TOP w0.508: CTT323.1 123.41,12.98 123.31,12.88 119.52,12.88 ; CTT1.1 119.38,13.99 119.73,14.35 119.73,14.86
  IN3 w0.508: v2(127.19,18.43) 127.19,18.76 126.73,19.21 120.45,19.21 118.71,17.46 117.29,17.46 v2(117.11,17.64)
  vias: v1(116.82,16.53)
+3VS_WLAN: length 1.9
  TOP w0.508: v2(306.61,12.74) 307.13,12.22 QWL2.1 ; v2(305.52,14.27) 305.52,14.76 305.35,14.92 RWL4.1
  vias: v2(308.44,7.55) v2(308.45,6.93) v2(308.67,23.77) v2(308.74,23.14) v2(309.08,7.89) v2(309.08,7.26) v2(309.08,6.62) v2(309.23,23.69) v2(309.25,24.25) v3(308.69,8.48) v3(310.35,8) v3(312.06,7.97)
+5V_HDMI: length 4.6
  TOP w0.508: v2(19.13,114.7) 18.19,114.7 16.87,116.03 UV4.3
  BOTTOM w0.508: RV27.2 RV28.2 v2(19.13,114.7)
  vias: v3(17.16,117.38)
+5V_TYPEC: length 6.9
  TOP w0.127: v3(13.77,46.35) 13.19,46.94 DU13.2
  TOP w0.254: JUSBC1.B9 6.44,53.69 JUSBC1.A4 7.7,53.69 7.98,53.97 8.67,53.97 v2(8.77,53.87) ; JUSBC1.B4 6.44,51.19 JUSBC1.A9 7.73,51.19 7.97,50.95 8.64,50.95 v2(8.67,50.98)
  vias: v2(9.42,53.85) v2(9.4,50.97) v2(10.02,45.74) v2(10.75,46.02) v2(11.1,47.4) v2(11.1,46.68) v2(11.41,46.02) v2(12.12,45.72) v2(36.3,42.1) v2(36.3,41.52) v2(36.3,40.93) v2(36.3,40.35) v2(36.3,39.76) v2(36.3,39.18)
+5V_TYPEC_L:
  vias: v1(42.18,39.99)
+5VALW: length 166.8
  TOP w0.127: v2(258.61,37.87) 259.06,37.42 v3(259.1,37.42)
  TOP w0.203: UC4.4 254.31,38.01 254.56,37.75 254.56,37.11 CC389.1 254.21,37.11 254.21,37.46 v2(254.09,37.58) ; CU73.1 49.58,38.03 48.81,38.03 48.52,38.33 48.52,39.19 48.34,39.36 UU4.25
  TOP w0.254: PUG1.4 119.84,95.4 119.97,95.53 119.97,96.19 PCG6.1 ; v2(48.97,38.51) 49.33,38.51 CU73.1
  TOP w0.305: CC402.1 111.65,87.34 111.74,87.43 UC6.3 ; v2(107.15,89.98) 107.99,89.98 109.25,88.72 v3(109.25,88.36)
  TOP w0.356: CC402.1 CC407.1 110.22,87.34 109.25,88.3 v3(109.25,88.36)
  TOP w0.381: v2(75.68,31.67) 75.68,31.1 RV51.1 ; PRV34.2 230.54,52.32 231.31,52.32 231.93,52.94 231.93,54.17 231.48,54.62 v2(231.48,54.68) 231.48,54.68 PRV32.1
  TOP w0.508: PRZ56.1 v2(165.24,124.93) ; PCG6.1 119.79,96.9 119.54,97.15 118.27,97.15 v2(117.66,96.55)
  IN1 w0.508: 107.13,92.57 107.13,90 v2(107.15,89.98) ; 107.13,92.57 114.14,92.57 115.11,93.54 115.11,95.59 115.44,95.91 117.03,95.91 v2(117.66,96.55) ; 107.13,92.57 107.13,103.91 110.45,107.23 113.51,107.23 119.72,113.43 121.81,113.43 122.31,113.94 125.83,117.46 125.83,120.99 122.3,124.52 122.3,133.32 124.76,135.78 131.82,135.78 v2(132.24,136.19)
  IN2 w0.508: v2(222.44,61.22) 222.69,61.22 222.77,61.3 223.79,61.3 224.95,60.14 228.46,60.14 230.49,58.1 230.83,58.1 231.86,57.07 231.86,55.06 v2(231.48,54.68)
  IN3 w0.508: v2(254.09,37.58) 255.59,36.08 257.12,36.08 258.65,37.62 258.65,37.87 v2(258.61,37.87)
  BOTTOM w0.254: 153.37,135.98 153.23,135.84 PUZ2.4 ; 145.75,135.98 145.61,135.84 PUZ3.4 ; 160.85,134.12 PUA1.4 ; 138.13,135.98 137.99,135.84 PUZ4.4 ; PCW3.1 241.95,51.04 PUW1.7 ; 130.76,135.98 130.63,135.84 PUZ5.4
  BOTTOM w0.356: PCW14.1 PCW13.1 243.09,49.34 PCW12.1
  BOTTOM w0.381: 243.74,51.7 243.74,51.38 243.09,50.73 PCW14.1 242.51,50.49 PCW3.1
  BOTTOM w0.508: PRZ72.1 162.56,134.21 162.21,134.57 162.21,134.82 ; PRV27.1 221.79,61.22 v2(222.44,61.22) ; v2(268.47,42.92) 267.66,43.73 265.23,43.73 263.12,41.62 262.83,41.62 262,40.79 260.84,40.79 260.18,40.13 260.18,38.79 260.41,38.57 260.41,38.06 260.34,38 260.34,37.93 259.99,37.58 259.48,37.58 259.25,37.81 258.78,37.81 258.65,37.93 258.65,37.87 v2(258.61,37.87) ; 162.21,134.82 v2(161.63,134.82) PCA6.1 160.85,134.81 160.85,134.12 ; 162.21,134.82 163.05,135.66 163.86,135.66 PRZ47.1 ; 153.37,135.98 153.51,136.12 PCZ39.1 v2(154.77,136.12) ; PRM4.1 85.58,24.95 PRM5.1 84.06,26.46 v2(83.29,26.46) ; 130.76,135.98 130.9,136.12 PCZ67.1 132.16,136.12 v2(132.24,136.19) ; v2(147.17,136.17) 146.56,136.17 PCZ53.1 145.89,136.12 145.75,135.98 ; v2(244.38,54.3) 243.74,53.67 243.74,53.25 243.74,53.24 243.74,51.7 ; v2(139.55,136.14) 138.92,136.14 PCZ60.1 138.27,136.12 138.13,135.98
  vias: v2(23.26,82.18) v2(23.27,81.56) v2(23.82,82.19) v2(23.83,81.56) v2(40.12,40.74) v2(40.71,41.34) v2(40.71,40.74) v2(41.29,41.34) v2(41.29,40.74) v2(41.88,40.74) v2(68.58,12.54) v2(68.58,11.9) v2(69.09,12.79) v2(69.09,12.16) v2(69.09,11.52) v2(69.59,12.54) v2(69.59,11.9) v2(70.1,12.79) v2(70.1,12.16) v2(70.1,11.52) v2(70.61,12.54) v2(70.61,11.9) v2(71.12,12.79) v2(71.12,12.16) v2(71.11,11.58) v2(71.63,12.54) v2(71.63,11.9) v2(72.13,12.79) v2(72.13,12.16) v2(72.12,11.58) v2(73.16,36.02) v2(73.18,35.43) v2(77.31,37.41) v2(77.33,36.82) v2(77.34,36.17) v2(77.9,37.41) v2(77.93,36.82) v2(77.93,36.17) v2(78.51,37.41) v2(78.54,36.82) v2(78.55,36.25) v2(180.02,106.88) v2(305.47,45.86) v2(306.12,45.86) v2(306.12,45.23) v2(306.73,45.86) v2(306.73,45.23) v2(307.34,45.86) v2(307.34,45.23) v2(310.95,42.49) v2(311.56,42.49) v2(312.16,42.48) v3(270.85,45.45) v6(268.34,44.79) v6(268.37,45.4) v6(268.68,45.93) v6(268.95,44.79) v6(268.98,45.4) v6(269.3,45.92) v6(269.61,45.4) v6(269.58,44.79) v6(269.91,45.93) v6(270.22,45.4) v6(270.19,44.79) v6(270.8,44.79)
+5VALWP: length 17.9
  TOP w0.254: v2(77.45,11.07) 77.45,11.33 77.07,11.71 74.2,11.71 72.22,13.69 65.36,13.69 64.1,12.43 v2(64.1,12.19)
  BOTTOM w0.254: PU302.8 76.53,10.36 76.74,10.56 76.94,10.56 v2(77.45,11.07) 77.82,11.45 PR312.2
  vias: v1(65.73,10.32) v2(62.84,10.26) v2(62.84,8.99) v2(62.84,7.72) v2(64.17,10.26) v2(64.17,8.99) v2(64.17,7.72) v2(64.86,12.19) v2(65.31,6.19) v2(65.31,5.56) v2(65.5,12.19) v2(65.95,6.19) v2(65.95,5.56) v2(66.13,12.19) v2(66.58,6.19) v2(66.58,5.56) v2(67.22,6.19) v2(67.22,5.56) v2(67.85,6.19) v2(67.85,5.56)
+5VL: length 94.2
  IN2 w0.508: v2(24.29,75.92) 23.25,75.92 22.35,75.02 22.35,74.09 23.31,73.12 23.31,71.18 23.9,70.59 23.9,70.07 24.24,69.73 24.24,66.22 24.75,65.71 27.25,65.71 29.14,63.82 29.14,59.8 29.64,59.3 30.38,59.3 30.68,59.6 31.96,59.6 32.83,58.73 32.83,57.68 33.39,57.12 33.39,56.73 34.19,55.93 35.12,55.93 35.97,55.09 36.21,54.85 36.82,54.85 40.71,52.18 40.73,52.17 45.56,49.34 46.12,48.79 46.27,48.56 46.94,47.89 47.14,47.89 47.83,47.8 48.7,47.5 49.16,47.34 49.16,47.34 49.93,47.06 50.37,46.9 50.61,46.66 52.46,44.81 56.4,44.81 56.66,45.07 66.18,45.07 v6(66.21,45.04)
  IN3 w0.508: v2(75.9,20.51) 75.44,20.51 71.15,24.8 71.15,25.45 67.59,29.02 67.59,42.19 66.8,42.98 66.8,44.45 v6(66.21,45.04)
  vias: v2(79.16,13.18) v2(79.79,13.21) v3(78.38,13.68)
+5VLP: length 3
  BOTTOM w0.127: v1(80.4,14.09) 80.4,11.78 80.01,11.39 79.82,11.39
+5VS: length 166.6
  TOP w0.508: v2(243.98,39.54) 247.19,39.54 249.44,41.79 v2(249.44,44.39) ; LA2.2 289.26,26.19 DA1.1 287.64,24.56 v3(285.57,24.56) 284.13,24.56 283.05,23.48 283.05,20.35 285.1,18.3 v2(285.1,16.79) ; RE2.1 v2(273.17,42.54)
  IN2 w0.508: v2(261.26,42.98) 260.59,42.98 260.49,43.08 260.32,43.08 260.1,43.3 260.04,43.3 259.29,44.04 259.02,44.04 258.97,44.09 249.74,44.09 v2(249.44,44.39)
  IN2 w1.016: 78.28,29.24 74.4,29.24 73.23,30.41 58.98,30.41 ; 24.58,50.59 24.41,50.42 23.58,50.42 20.14,53.87 20.14,60.49 16.92,63.71 16.92,65.42 17.61,66.11 17.61,66.32 18.69,67.4 18.69,69.58 18.08,70.19 18.08,71.33 16.93,72.48 16.93,74.95 16.18,75.7 16.18,81.31 15.79,81.7 15.79,84.77 16.55,85.53 16.55,96.08 15.67,96.96 15.67,111.62 16.03,111.99
  BOTTOM w0.203: CG337.1 244.55,40.24 244.02,40.77 UG27.4
  BOTTOM w0.381: v2(243.98,39.54) 243.98,39.71 244.15,39.88 CG337.1
  BOTTOM w0.508: RG214.2 237.87,36.9 238.75,37.78 242.91,37.78 243.98,38.85 v2(243.98,39.54) ; v2(38.14,46.05) 38.29,45.9 JFAN2.1 ; CE3.1 27.03,46.28 26.84,46.47 25.96,46.47 25.03,47.41 v2(25.03,49.48) ; 31.92,44.74 32.2,44.46 35.48,44.46 36.58,43.36 38.16,43.36 RE4.1 ; R23.1 219.74,11.5 219.29,11.04 v2(218.93,11.04) ; R24.1 210.7,12.46 v2(210.36,12.8)
  BOTTOM w1.016: 274.66,15.25 277.85,15.25 278.56,15.97 279.29,15.97 280.13,16.81 284.28,16.81
  vias: v2(16.17,112.96) v2(16.75,112.96) v2(55.26,40.3) v2(55.26,39.7) v2(56.69,32.29) v2(56.7,31.69) v2(96.25,24.12) v2(96.84,24.12) v2(97.07,11.8) v2(97.24,24.55) v2(97.62,11.75) v2(98.18,11.83) v2(201.21,11.06) v2(201.8,11.05) v2(205.7,11.38) v2(206.24,11.53) v2(259.33,15.63) v2(259.92,15.63) v2(260.5,15.63) v2(261.09,15.63) v2(261.64,43.45) v2(261.67,15.63) v2(262.13,43.77) v2(262.13,43.19) v2(262.25,15.63) v2(262.69,43.76) v2(262.69,43.18) v2(263.25,43.78) v2(263.25,43.2) v2(263.82,43.77) v2(263.82,43.18) v2(275.75,45.4) v2(276.03,44.89) v2(276.33,45.4) v2(276.61,44.89) v2(285.74,16.79)
+5VS_AVDD: length 8.5
  TOP w0.203: v2(293.83,25.17) 294.02,24.99 UA1.33 ; CA11.1 290.4,22.86 291.03,22.23 UA1.40
  TOP w0.356: CA11.1 290.4,23.75 CA12.2
  TOP w0.508: CA12.2 290.4,23.8 LA2.1 v2(291.18,24.79)
  IN1 w0.508: v2(293.83,25.17) 293.26,24.6 291.65,24.6 291.46,24.79 v2(291.18,24.79)
+5VS_HDD1:
  vias: v2(248.52,12.93) v3(246.32,13.47) v3(247.16,15.11) v3(248.01,13.47)
+5VS_KBL: length 0.9
  TOP w0.127: v3(214.84,11.34) 214.38,11.8 v2(214.38,12.08)
+5VS_PVDD: length 5.5
  TOP w0.203: 289.87,21.64 290.07,21.83 UA1.41 ; CA22.1 290.99,18.64 290.99,19.28 291.55,19.83 UA1.46
  TOP w0.381: CA21.1 289.36,21.12 289.87,21.64
  vias: v1(288.88,20)
+16.8V_BATT: length 57.8
  TOP w0.381: v2(242.21,14.99) 240.72,14.99 PRB06.2
  IN1 w0.381: v2(242.21,14.99) 242.14,14.93 v2(236.15,14.93)
  BOTTOM w0.381: PDB01.3 235.54,7.84 233.94,9.45 233.94,13.06 235.8,14.93 v2(236.15,14.93)
  BOTTOM w0.508: PL13.2 272.3,5.12 272.01,4.83 260.42,4.83 259.81,5.43 250.45,5.43 249.84,4.82 245.73,4.82 244.36,6.2 242.4,6.2 241.64,5.44 237.17,5.44 236.06,6.55 236.06,7.19 PDB01.3
  vias: v1(272.71,8.02) v2(269.73,9.58) v2(269.73,8.85) v2(269.73,8.09) v2(270.49,9.58) v2(270.49,8.85) v2(270.49,8.09) v2(271.25,9.61) v2(271.25,8.85) v2(271.25,8.09)
+16.8V_BATT+: length 2.3
  TOP w0.127: v3(282.12,9.26) v2(280.99,9.26) v3(279.81,9.26)
  vias: v2(275.2,8.02) v2(275.2,7.44) v2(275.79,8.02) v2(275.79,7.44) v3(274.97,6.84)
+16.8V_BATT_CHG:
  vias: v1(264.89,5.95)
+19V_ADPIN:
  vias: v3(277.66,36.46) v3(278.31,38.02) v3(279.38,36.74)
+19V_P1: length 8.3
  TOP w0.508: PQB02.3 264.64,38.36 264.98,38.02 PRB02.2 265.4,38.33 265.73,38.66 265.77,38.66 265.79,38.68 267.03,38.68 v1(267.37,38.34) 267.82,37.89 267.82,36.74 267.38,36.29 PCB02.1 ; PRB04.1 266.1,31.9
+19V_P2:
  vias: v1(261.17,32.79)
+19V_VIN: length 77.9
  TOP w0.127: PCB01.1 v3(267.96,28.06)
  TOP w0.381: v2(246.75,5.47) 247.45,4.76 249.81,4.76 250.42,5.37 259.97,5.37 260.58,4.76 275.04,4.76 277.12,6.85 277.12,20.26 273.5,23.88 273.5,26.85 274.89,28.24 276.44,28.24 276.83,28.62 276.83,29.94 276.33,30.44
  BOTTOM w0.381: v2(246.75,5.47) 246.75,5.77 245.02,7.5 244.02,7.5 243.45,6.93 242.31,6.93 241.4,6.02 237.41,6.02 236.84,6.59 PDB01.2 236.06,8.49 235.62,8.49 234.54,9.57 PRB10.1
  vias: v3(274.82,31.74) v3(274.86,33.74)
+19VB: length 225
  TOP w0.381: v2(19,84.86) 19,84.48 18.17,83.64 RS39.2
  TOP w0.508: RS40.1 18.24,78.23 v2(18.61,77.87)
  TOP w1.524: 186.68,95.04 182.44,95.04 180.47,97.01 172.57,97.01 170.39,94.83 ; 173.22,64.37 173.22,66.57 170.4,69.39 170.4,77.76 174.03,81.39 176.19,81.39
  TOP w7.62: 107.55,62.65 169.26,62.65
  IN1 w1.524: 169.58,92.33 169.58,92.32 177.39,84.51 177.39,83.78
  IN2 w0.508: v2(19,84.86) 19,83.11 19.64,82.47 19.64,80.91 18.61,79.88 v2(18.61,77.87) 18.61,77.74 19.89,76.45 19.89,74.26 21.77,72.37 21.77,66.95 21.24,66.42 21.24,65.14 21.84,64.54 22.95,64.54 23.58,63.91 28.14,63.91 28.49,63.55 28.49,59.27 29.08,58.68 29.46,58.68 29.69,58.44 29.7,58.44 30.32,57.82 30.68,57.82 32.35,56.15 33.05,56.15 33.92,55.28 34.83,55.28 35.97,54.14 35.97,53.62 36.36,53.24 36.39,53.24 36.54,53.08 37.05,53.08 37.2,53.24 38.02,53.24 39.55,52.19 39.72,52.02 40.33,51.6 40.95,51.2 41.57,50.81 42.03,50.34 42.03,49.03 42.67,48.39 43.02,48.04 43.32,47.75 45.27,47.75 45.59,47.43 46.48,47.43 46.67,47.24 47.1,47.24 47.68,47.16 48.49,46.89 50.02,46.33 50.34,46.01 52.19,44.16 62.58,44.16 62.68,44.06 66.72,44.06 68.43,45.76 80.18,45.76 81.42,47.01 81.42,47.68 82.57,48.82 v2(83.91,48.82)
  BOTTOM w0.254: v2(83.28,13.08) 83.25,13.08 79.93,16.4 79,16.4 77.27,14.66 76.97,14.66 PR306.1
  vias: v1(185.41,55.22) v2(81.9,19.98) v2(82.31,20.39) v2(82.31,19.57) v2(82.73,19.98) v2(82.73,19.15) v2(83.14,19.57) v2(83.14,18.74) v2(83.55,19.15) v2(83.55,18.33) v2(83.97,18.74) v2(88.25,42.98) v2(88.25,42.39) v2(88.83,42.98) v2(88.83,42.39) v2(89.42,42.98) v2(89.42,42.39) v2(90,42.98) v2(90,42.39) v2(90.59,42.98) v2(90.59,42.39) v2(168.33,94.41) v2(168.84,94.14) v2(168.88,94.71) v2(176.26,83.09) v2(176.7,82.67) v2(177.32,82.65) v2(242.56,30.27) v2(243.15,30.27) v2(243.73,30.27) v2(244.31,30.26) v2(248.73,38.18) v2(249.31,38.76) v2(249.31,38.18) v2(249.9,38.76) v2(249.9,38.18) v2(250.48,38.76) v2(250.48,38.18) v2(266.55,12.73) v2(266.6,11.71) v2(266.81,13.26) v2(266.81,12.23) v2(267.11,12.73) v2(267.16,11.71) v2(267.37,13.26) v2(267.37,12.23) v2(267.68,12.74) v2(267.74,11.71) v2(267.93,12.24) v2(267.97,13.26) v2(268.25,12.73) v2(268.51,12.22) v6(185.91,93.85) v6(185.9,93.24) v6(186.61,93.85) v6(186.62,93.23)
