# Allegro board LAJ643PR10-0325.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GPU_DPE_N1_C: length 2.4
  TOP w0.127: CT19.2 35.74,50.06 35.63,50.06 35.39,50.3 34.16,50.3 34.08,50.38 UT11.13
GPU_DPE_N2: length 241.7
  TOP w0.127: v2(37.29,51.39) 37.36,51.46 37.58,51.46 37.71,51.33 37.71,51.09 37.47,50.85 37.06,50.85 36.71,51.2 36.71,51.21 36.6,51.32 36.59,51.32 CT21.1
  IN1 w0.135: v2(37.29,51.39) 37.29,50.95 36.5,50.15 36.5,50.15 36.44,50.09 36.44,47.56 37.29,46.71 37.29,45.77 39.29,43.78 39.29,40.17 41.42,38.03 41.79,38.03 42.44,37.39 49.41,37.39 50.77,36.02 50.77,35.65 52.14,34.29 52.14,31.78 52.77,31.15 52.77,30.08 56.34,26.5 60.71,26.5 61.27,25.94 61.27,23.07 65.87,18.47 79.97,18.47 83.56,14.88 86.69,14.88 88.9,12.67 91.36,12.67 92.38,11.65 95.77,11.65 96.39,12.27 100.14,12.27 100.61,11.79 109.09,11.79 110.2,12.9 118.56,12.9 121.49,15.84 128.24,15.84 128.88,15.2 131.97,15.2 132.81,16.04 134.7,16.04 135.2,15.54 138.12,15.54 138.67,16.08 141.44,16.08 142.63,17.28 149.84,17.28 151.65,19.1 171.03,19.1 183.28,31.34 183.28,36.02 183.77,36.52 183.77,39.31 187.52,43.06 187.52,43.54 188.37,44.39 188.37,50.52 193.11,55.26 193.11,61.92 193.33,62.14 193.33,68.97 193.89,69.53 193.89,70.62 196.51,73.25 200.94,73.25 201.97,74.28 201.97,76.54 201.63,76.89 201.15,76.89 201.09,76.95 v2(201.09,76.95)
  BOTTOM w0.107: UG1.AC3 v2(201.09,76.95)
GPU_DPE_N2_C: length 2.3
  TOP w0.127: UT11.16 35.35,51.58 35.49,51.43 35.59,51.43 CT21.2
GPU_DPE_N3: length 229.4
  TOP w0.127: CT24.1 38.99,52.98 40.96,51.01 40.96,50.16 40.77,49.97 v2(40.77,49.82)
  IN1 w0.135: v2(40.77,49.82) 41.05,49.54 41.05,49.21 42,48.26 42.97,48.26 44.44,46.78 46.05,46.78 47.29,45.54 49.75,45.54 50.57,44.72 50.57,42.58 54.75,38.4 54.75,37.28 56.1,35.93 56.1,34.08 57.59,32.6 57.59,31.13 58.04,30.68 62.75,30.68 69.35,24.07 70.47,24.07 71.33,23.21 72.64,23.21 73.02,22.82 83.57,22.82 87.55,18.84 87.58,18.84 88.33,18.84 90.25,16.92 107.35,16.92 107.79,16.49 108.18,16.49 108.93,17.24 112.43,17.24 113.13,17.93 113.4,18.2 116.56,18.2 117.21,18.85 118.16,18.85 119.96,20.65 127.92,20.65 128.42,21.14 132.32,21.14 132.82,20.65 134.22,20.65 135.55,21.98 139.15,21.98 140.5,23.33 164.77,23.33 164.93,23.17 169.39,23.17 177.23,31 177.23,31.68 179.04,33.49 179.04,38.25 179.79,39 179.79,40.99 183.57,44.77 183.57,45.2 184.38,46.02 184.38,52.66 188.32,56.59 188.32,58.83 189.13,59.64 189.13,63.91 189.36,64.14 189.36,70.8 189.51,70.96 189.51,72.3 189.72,72.51 189.72,72.51 194.96,77.75 195.76,77.75 195.99,77.97 196.39,77.97 196.61,77.75 197.01,77.75 197.45,78.19 198.5,78.19 198.72,78.41 199.13,78.41 199.35,78.19 199.75,78.19 199.97,78.41 200.38,78.41 200.6,78.19 201,78.19 201.12,78.3 201.12,78.53 v2(201.09,78.55)
  BOTTOM w0.107: UG1.AC5 v2(201.09,78.55)
GPU_DPE_N3_C: length 2.3
  TOP w0.127: CT24.2 35.5,52.74 v4(34.84,52.74) 34.3,52.74 34.26,52.78 UT11.19
GPU_DPE_P0: length 228.5
  TOP w0.127: v2(39.22,48.55) 39.17,48.6 38.9,48.6 38.81,48.51 37.35,48.51 37,48.17 36.16,48.17 CT3.1
  IN1 w0.135: v2(39.22,48.55) 39.3,48.64 39.45,48.64 39.54,48.55 39.54,48.19 41.83,45.89 41.83,44.61 43.59,42.86 43.59,40.61 44.05,40.15 50.58,40.15 53.19,37.55 53.19,36.64 54.54,35.28 54.54,32.9 55.83,31.62 55.83,30.61 57.31,29.12 62.07,29.12 68.68,22.5 69.82,22.5 71.38,20.94 72.35,20.94 72.64,21.23 82.89,21.23 86.83,17.29 87.68,17.29 89.62,15.35 101.07,15.35 101.22,15.2 106.81,15.2 107.08,14.93 108.83,14.93 109.58,15.68 113.08,15.68 113.74,16.34 118.54,16.34 119.52,17.33 119.52,18.02 120.42,18.92 128.39,18.92 128.9,19.43 131.84,19.43 132.55,18.71 134.71,18.71 136.28,20.27 146.36,20.27 147.7,21.61 170.04,21.61 180.61,32.18 180.61,37.42 181.36,38.16 181.36,40.31 185.12,44.08 185.12,44.54 185.94,45.36 185.94,52.01 190.69,56.76 190.69,62.91 190.92,63.14 190.92,69.98 191.07,70.13 191.07,71.66 195.28,75.87 197.08,75.87 197.65,75.31 198.98,75.31 199.39,75.72 199.39,76.12 199.87,76.6 200.11,76.6 200.29,76.41 v2(200.29,76.15)
  BOTTOM w0.107: UG1.AD2 v2(200.29,76.15)
GPU_DPE_P0_C: length 2.3
  TOP w0.127: CT3.2 35.39,48.33 35.12,48.33 34.63,48.82 34.3,48.82 34.26,48.78 UT11.9
GPU_DPE_P1: length 236.2
  TOP w0.127: v2(39.29,49.87) 39.03,50.13 38.9,50.13 38.48,49.71 v4(37.36,49.71) 36.61,49.71 CT5.1
  IN1 w0.135: v2(200.29,75.35) 200.29,75.54 200.54,75.79 200.69,75.79 200.77,75.71 200.77,75.52 200.74,75.49 200.74,75.18 200.38,74.82 195.44,74.82 191.92,71.3 191.92,70.43 192.03,70.31 192.03,69.9 191.76,69.63 191.76,62.79 191.53,62.56 191.53,56.41 186.79,51.66 186.79,45.01 185.97,44.19 185.97,43.72 182.2,39.96 182.2,37.46 181.55,36.81 181.55,31.83 170.41,20.69 147.99,20.69 146.18,18.89 142.05,18.89 140.8,17.64 131.9,17.64 131.36,17.09 129.19,17.09 128.59,17.69 121.14,17.69 118.29,14.83 109.93,14.83 108.89,13.79 106.77,13.79 106.42,14.14 105.49,14.14 104.7,13.35 101.51,13.35 100.36,14.5 95.94,14.5 94.79,13.35 92.88,13.35 92,14.22 89.55,14.22 87.33,16.44 84.22,16.44 80.6,20.06 68.96,20.06 68.48,20.54 68.48,21.51 66.8,23.19 66.06,23.19 64.42,24.83 64.42,25.57 61.72,28.27 56.8,28.27 54.34,30.72 54.34,31.78 53.7,32.42 53.7,34.93 52.34,36.29 52.34,36.94 49.99,39.29 45.69,39.29 45.35,38.95 43.14,38.95 42.75,39.34 42.75,42.46 40.9,44.3 40.9,45.51 38.05,48.36 38.05,49.51 38.84,50.3 39.28,50.3 39.36,50.22 39.36,49.94 v2(39.29,49.87)
  BOTTOM w0.107: UG1.AD1 v2(200.29,75.35)
GPU_DPE_P1_C: length 2.4
  TOP w0.127: UT11.12 v4(34.84,49.98) 35.26,49.98 35.5,49.74 35.68,49.74 CT5.2
GPU_DPE_P2: length 241.7
  TOP w0.127: v2(38.23,51.41) 38.03,51.2 38.03,50.96 37.6,50.53 36.93,50.53 36.51,50.95 CT20.1
  IN1 w0.135: v2(38.23,51.41) 38.23,51.73 37.98,51.92 37.82,51.92 37.71,51.82 37.71,50.87 36.85,50 36.85,50 36.8,49.95 36.8,47.71 37.65,46.86 37.65,45.92 39.64,43.92 39.64,40.32 41.57,38.39 41.94,38.39 42.59,37.74 49.55,37.74 51.13,36.16 51.13,35.8 52.5,34.43 52.5,31.93 53.12,31.3 53.12,30.23 56.49,26.86 60.86,26.86 61.63,26.09 61.63,23.21 66.01,18.82 80.12,18.82 83.71,15.24 86.83,15.24 89.05,13.02 91.51,13.02 92.53,12 95.62,12 96.25,12.62 100.28,12.62 100.76,12.15 108.94,12.15 110.05,13.26 118.41,13.26 121.35,16.2 128.39,16.2 129.03,15.56 131.82,15.56 132.66,16.4 134.85,16.4 135.35,15.9 137.98,15.9 138.52,16.44 141.29,16.44 142.49,17.63 149.69,17.63 151.51,19.45 170.88,19.45 182.92,31.49 182.92,36.17 183.42,36.66 183.42,39.46 187.17,43.21 187.17,43.69 188.01,44.54 188.01,50.67 192.75,55.41 192.75,62.07 192.97,62.29 192.97,69.12 193.53,69.68 193.53,70.77 196.36,73.6 200.79,73.6 201.61,74.43 201.61,76.4 201.48,76.53 201.23,76.53 201.09,76.4 v2(201.09,76.15)
  BOTTOM w0.107: UG1.AC2 v2(201.09,76.15)
GPU_DPE_P2_C: length 2.3
  TOP w0.127: UT11.15 34.19,51.18 34.27,51.26 v4(34.84,51.26) 35.22,51.26 35.36,51.12 35.58,51.12 CT20.2
GPU_DPE_P3: length 229.6
  TOP w0.127: v2(40.2,50.05) 40.4,50.05 40.64,50.29 40.64,50.88 40.52,51 40.32,51 39.96,51.37 39.96,51.57 39.62,51.9 39.4,51.9 39.06,52.24 39.06,52.46 38.86,52.66 v4(37.72,52.66) 36.87,52.66 36.81,52.6 36.81,52.33 36.71,52.23 36.44,52.23 CT22.1
  IN1 w0.135: v2(40.2,50.05) 40.35,49.9 40.35,49.64 40.7,49.3 40.7,49.06 41.86,47.9 42.82,47.9 44.3,46.43 45.9,46.43 47.14,45.18 49.6,45.18 50.21,44.57 50.21,42.44 54.39,38.25 54.39,37.13 55.75,35.78 55.75,33.94 57.23,32.45 57.23,30.98 57.89,30.32 62.6,30.32 69.21,23.71 70.32,23.71 71.18,22.85 72.49,22.85 72.87,22.47 83.43,22.47 87.2,18.7 87.41,18.49 88.18,18.49 90.1,16.57 107.2,16.57 107.64,16.13 108.33,16.13 109.08,16.88 112.58,16.88 113.28,17.57 113.54,17.84 116.71,17.84 117.36,18.5 118.31,18.5 120.1,20.3 128.07,20.3 128.56,20.79 132.18,20.79 132.67,20.3 134.37,20.3 135.69,21.62 139.29,21.62 140.64,22.97 164.62,22.97 164.79,22.81 169.54,22.81 177.59,30.85 177.59,31.53 179.4,33.34 179.4,38.11 180.14,38.85 180.14,40.84 183.92,44.62 183.92,45.06 184.74,45.88 184.74,52.51 188.67,56.44 188.67,58.68 189.49,59.5 189.49,63.76 189.72,63.99 189.72,70.65 189.87,70.81 189.87,72.16 190.07,72.36 195.11,77.39 197.16,77.39 197.6,77.83 201.01,77.83 v2(201.09,77.75)
  BOTTOM w0.107: UG1.AC4 v2(201.09,77.75)
GPU_DPE_P3_C: length 2.2
  TOP w0.127: UT11.18 34.26,52.38 34.3,52.42 35.67,52.42 CT22.2
GPU_EVENT#: length 98.3
  TOP w0.127: v2(219.8,19.26) v1(221.06,19.26) 221.49,19.26 222.82,17.93 v2(223.27,17.93) ; DG243.1 223.76,63.55 221.69,63.55 221.37,63.23 221.37,61.53 222.78,60.12 224.25,60.12 224.81,60.68 225.28,60.68 225.29,60.67 226.19,60.67 226.9,61.38 227.37,61.38 228.08,60.67 231.76,60.67 233.29,59.14 233.29,58.74 233.87,58.15 233.87,54.78 233.36,54.26 233.36,52.45 v2(233.65,52.15)
  TOP w0.135: v2(199.93,22.33) 200.03,22.22 200.51,22.22 RH186.1
  IN1 w0.127: v2(219.8,19.26) 219.72,19.34 218.99,19.34 218.62,18.97 215.57,18.97 215.1,19.45 214.42,19.45 213.91,18.93 211.67,18.93 211.61,19 209.45,19 208.6,19.86 207.02,19.86 206.71,20.18 206.71,20.79 206.04,21.45 206.04,23.09 205.97,23.17 205.97,23.28 204.01,25.25 201.09,25.25 200.59,24.75 200.59,22.66 200.27,22.33 v2(199.93,22.33)
  IN3 w0.127: v2(223.27,17.93) 222.43,18.76 222.43,27.8 226.05,31.41 226.05,34.03 233.68,41.67 233.68,47.24 234.13,47.69 234.13,48.45 233.59,48.99 233.59,49.98 234.15,50.54 234.15,51.66 v2(233.65,52.15)
GPU_EVENT#_1: length 24.1
  TOP w0.127: v2(213.23,74.36) 213.12,74.25 213.12,72.63 217.08,68.67 220.32,68.67 220.83,68.15 222.11,68.15 v1(223.62,66.63) 224.15,66.1 DG243.2 224.15,65.06 RG400.2
  BOTTOM w0.109: v2(213.23,74.36) 213.23,74.42 211.87,75.78 211.87,79.4 UG1.L6
GPU_EVENT#_R: length 6.2
  TOP w0.127: v1(201.85,21.98) 202.05,21.78 202.52,21.78 202.74,22 202.74,22.56 v2(202.57,22.72)
  TOP w0.135: RH192.2 RH186.2 202.39,22.91 v2(202.57,22.72)
  BOTTOM w0.127: v2(202.57,22.72) 202.72,22.57 202.72,21.95 202.53,21.75 UH1.AW26
GPU_HDMI_CTRLCLK: length 269.6
  TOP w0.127: v2(17.83,68.43) 17.3,68.43 16.62,69.11 16.62,70.26 v1(17.83,71.48) 18.34,71.98 19.59,71.98 19.97,71.6 19.97,70.48 RV36.1 20.15,69.32 QV2.4
  IN1 w0.127: v2(58.99,25.16) 56.11,25.16 51.66,29.6 51.66,30.69 49.95,32.41 49.95,34.11 49.54,34.51 49.54,35.43 49.06,35.92 48.07,35.92 47.57,35.41 45.08,35.41 44.49,36 39.49,36 37.91,37.58 37.91,43.12 34.62,46.41 31.6,46.41 31.45,46.26 28.49,46.26 28.03,46.73 27.64,46.73 26.17,48.2 23.34,48.2 23.14,47.99 20.81,47.99 19.95,48.85 19.95,62.04 17.28,64.71 17.28,68.19 17.52,68.43 v2(17.83,68.43)
  IN2 w0.127: v2(58.99,25.16) 59.03,25.2 59.03,25.85 57.5,27.38 57.5,27.85 55.91,29.44 55.91,32.55 56.91,33.55 62.55,33.55 63.09,34.1 63.09,40.02 63.66,40.59 67.14,40.59 68.99,42.44 78.12,42.44 78.33,42.64 80.66,42.64 83.11,45.09 84.9,45.09 87.05,47.24 87.05,51.84 92.99,57.78 v2(92.99,59.45) ; v2(198.58,76.94) 197.8,76.15 193.54,76.15 v2(192.75,76.94)
  BOTTOM w0.127: v2(192.75,76.94) 192.1,76.94 191.6,76.45 186.77,76.45 185.47,75.15 183.19,75.15 177.49,80.86 174.54,80.86 159.53,65.84 101.25,65.84 94.87,59.45 v2(92.99,59.45) ; UG1.AG3 v2(198.58,76.94)
GPU_HDMI_CTRLDAT: length 259.1
  TOP w0.127: QV2.1 18,67.21 RV37.1 17.79,67.25 v2(17.79,67.81) 17.1,67.81 v1(16.97,67.94)
  IN1 w0.127: v2(58.61,25.61) 58.42,25.42 56.22,25.42 51.92,29.71 51.92,30.8 50.21,32.51 50.21,34.21 49.81,34.62 49.81,35.54 49.15,36.2 47.98,36.2 47.46,35.67 45.19,35.67 44.6,36.26 39.6,36.26 38.17,37.69 38.17,43.23 34.73,46.68 31.49,46.68 31.34,46.52 28.6,46.52 28.14,46.99 27.75,46.99 26.28,48.46 23.24,48.46 23.03,48.26 20.91,48.26 20.21,48.96 20.21,62.32 19.6,62.93 19.6,64.76 19.21,65.15 19.21,66.39 v2(17.79,67.81)
  IN2 w0.127: v2(198.59,76.13) 198.24,75.78 193.49,75.78 192.86,76.41 192.21,76.41 v2(191.97,76.18) ; v2(92.51,58.94) 92.51,57.68 86.79,51.95 86.79,47.36 84.78,45.36 83,45.36 80.55,42.91 78.22,42.91 78.01,42.71 68.87,42.71 67.03,40.86 63.55,40.86 62.82,40.13 62.82,34.21 62.43,33.82 56.8,33.82 55.64,32.66 55.64,29.28 57.23,27.69 57.23,27.27 58.61,25.88 v2(58.61,25.61)
  BOTTOM w0.127: UG1.AG2 v2(198.59,76.13) ; v2(92.51,58.94) 94.72,58.94 101.36,65.58 159.63,65.58 174.65,80.6 177.38,80.6 183.09,74.89 185.58,74.89 186.87,76.19 191.97,76.19 v2(191.97,76.18)
GPU_HDMI_TX0N: length 196.5
  BOTTOM w0.076: 197.54,75.11 197.54,75.13 197.46,75.21 197.46,75.96 197.8,76.3 197.8,77.54 197.33,78.01 UG1.AH4
  BOTTOM w0.102: 197.54,75.11 197.54,74.84 196.56,73.86 187.69,73.86 186.2,72.36 179.78,72.36 177.97,70.55 168.75,70.55 161.46,63.26 113.71,63.26 105.4,54.96 100.89,54.96 94.71,48.78 90.71,48.78 90.07,49.41 82.72,49.41 75.62,46.29 75.61,46.28 74.17,45.6 74.16,45.59 74.11,45.57 72.65,44.88 71.4,44.88 69.88,43.36 63.38,43.36 62.44,44.3 52.79,44.3 52.25,44.3 50.06,46.49 48.33,47.13 46.63,47.13 46.43,47.33 46.25,47.33 45.14,47.33 43.68,48.79 43.68,49.46 42.78,50.37 41.82,50.37 40.95,51.24 40.32,51.24 37.47,54.1 36.67,54.1 35.91,54.85 33.71,54.85 33.43,54.57 30.66,54.57 v5(29.92,53.83) 29.49,53.41 26.42,53.41 25.31,54.52 24.71,54.52 24.25,54.97 24.25,55.33 CV39.1
GPU_HDMI_TX0N_C: length 2.2
  BOTTOM w0.102: UV2.45 24.86,57.79 24.92,57.73 24.92,57.5 24.36,56.95 24.36,56.69 CV39.2
GPU_HDMI_TX0P: length 196.4
  BOTTOM w0.076: 197.24,75.04 197.24,75.13 197.31,75.21 197.31,76.03 197.65,76.36 197.65,77.47 197.35,77.77 197.02,77.77 196.92,77.67 196.92,77.47 197.05,77.34 UG1.AH3
  BOTTOM w0.102: CV38.1 24.64,55.5 24.56,55.42 24.56,55.1 24.84,54.82 25.44,54.82 26.54,53.71 v5(27.25,53.71) 29.36,53.71 30.53,54.88 33.31,54.88 33.59,55.16 36.04,55.16 36.79,54.4 37.59,54.4 40.45,51.55 41.07,51.55 41.95,50.67 42.91,50.67 43.98,49.59 43.98,48.92 45.27,47.63 46.38,47.63 46.38,47.63 46.56,47.63 46.76,47.43 48.38,47.43 50.23,46.75 52.38,44.61 52.71,44.61 62.57,44.61 63.51,43.66 69.75,43.66 71.27,45.18 72.58,45.18 73.98,45.85 73.99,45.86 74.03,45.87 75.48,46.56 82.66,49.72 90.2,49.72 90.83,49.08 94.58,49.08 100.76,55.26 105.28,55.26 113.58,63.56 161.33,63.56 168.62,70.85 177.84,70.85 179.66,72.67 186.07,72.67 187.57,74.17 196.43,74.17 197.24,74.97 197.24,75.04
GPU_HDMI_TX0P_C: length 2.2
  BOTTOM w0.102: UV2.44 25.26,57.77 25.22,57.73 25.22,57.38 24.67,56.82 24.67,56.72 CV38.2
GPU_HDMI_TX1N: length 190.2
  BOTTOM w0.076: UG1.AJ2 196.31,76.71 196.24,76.71 196.15,76.62 196.15,76.34 196.28,76.21 196.68,76.21 196.94,75.94 196.95,75.88 197,75.47 196.78,75.25 196.73,75.2 196.73,75.09 196.72,75.08
  BOTTOM w0.102: 196.72,75.08 196.14,74.5 191.35,74.5 191.19,74.66 187.49,74.66 186.13,73.3 179.72,73.3 177.67,71.26 168.4,71.26 161.18,64.04 101.97,64.04 95.23,57.3 92.24,57.3 89.16,54.65 85.56,51.92 83.58,50.82 81.65,49.82 72.38,45.59 71.06,45.59 69.54,44.07 63.68,44.07 62.74,45.01 52.54,45.01 50.44,47.12 48.47,47.85 46.95,47.85 44.71,50.09 41.61,52.04 40.53,52.04 40.01,52.56 37.83,54.75 37.74,54.81 36.96,54.81 36.21,55.56 33.42,55.56 33.14,55.28 v5(31.06,55.28) 30.36,55.28 29.67,54.59 26.57,54.59 26.16,55 26.16,55.33 CV37.1
GPU_HDMI_TX1N_C: length 2
  BOTTOM w0.102: CV37.2 26.31,56.73 26.31,56.88 26.14,57.04 26.14,57.71 26.06,57.78 UV2.42
GPU_HDMI_TX1P: length 190.1
  BOTTOM w0.076: 196.5,75.29 196.61,75.29 196.84,75.53 196.8,75.87 196.61,76.06 196.22,76.06 196,76.28 196,76.68 196.18,76.86 196.36,76.86 196.48,76.98 UG1.AJ3
  BOTTOM w0.102: 196.5,75.29 196.01,74.8 191.48,74.8 191.32,74.96 187.36,74.96 186,73.61 179.59,73.61 177.55,71.56 168.27,71.56 161.06,64.35 101.85,64.35 95.1,57.6 92.12,57.6 88.97,54.89 85.4,52.18 83.43,51.09 81.51,50.09 72.31,45.9 70.93,45.9 69.41,44.37 63.8,44.37 62.86,45.32 52.67,45.32 50.6,47.38 48.52,48.15 47.08,48.15 44.9,50.33 41.7,52.35 40.66,52.35 40.14,52.87 38.03,54.98 37.84,55.12 37.09,55.12 36.33,55.87 33.29,55.87 33.01,55.59 30.24,55.59 29.54,54.9 v5(28.41,54.9) 26.7,54.9 26.47,55.12 26.47,55.4 26.57,55.5 CV36.1
GPU_HDMI_TX1P_C: length 2
  BOTTOM w0.102: CV36.2 26.61,56.68 26.61,57 26.45,57.17 26.45,57.71 26.44,57.71 26.44,57.75 26.46,57.78 UV2.41
GPU_HDMI_TX2N: length 185.4
  BOTTOM w0.102: UG1.AJ1 196.33,75.59 196.33,75.43 196,75.09 191.86,75.09 191.57,75.38 187.21,75.38 185.91,74.09 182.75,74.09 177.55,79.3 174.48,79.3 167.04,71.86 167.04,70.96 160.86,64.78 101.69,64.78 94.95,58.04 91.82,58.04 91.71,57.93 91.18,57.4 90.55,56.83 90.2,56.49 90.08,56.38 90.07,56.37 88.72,55.21 86.63,53.63 86.52,53.56 86.06,53.27 84.64,52.24 83.41,51.59 82.97,51.31 82.95,51.3 81.33,50.46 79.74,49.73 79.52,49.64 79.15,49.5 72.14,46.35 70.73,46.35 70.1,45.72 55.13,45.72 54.31,46.54 52.02,46.54 50.76,47.81 48.19,48.7 48.14,48.76 48.13,48.76 47.53,49.36 47.01,49.88 44.77,51.01 43.11,51.94 41.74,52.8 40.78,52.8 39.53,54.05 38.3,55.28 38.05,55.47 37.98,55.52 37.26,55.52 v5(36.94,55.84) 36.5,56.27 33.12,56.27 32.9,56.05 32.33,56.05 31.78,56.59 31.55,56.59 CV35.1
GPU_HDMI_TX2N_C: length 4.5
  BOTTOM w0.102: CV35.2 30.21,56.58 29.97,56.58 29.63,56.92 v5(28.03,56.92) 27.6,56.92 27.31,57.21 27.31,57.73 27.26,57.78 UV2.39
GPU_HDMI_TX2P: length 185.4
  BOTTOM w0.102: UG1.AK1 195.98,75.74 196.03,75.7 196.03,75.55 195.87,75.4 191.99,75.4 191.7,75.69 187.08,75.69 185.78,74.39 182.88,74.39 177.67,79.6 174.36,79.6 166.74,71.98 166.74,71.08 160.74,65.08 101.56,65.08 94.82,58.34 91.7,58.34 91.5,58.15 90.97,57.62 90.34,57.05 89.95,56.68 89.95,56.68 89.86,56.6 88.53,55.44 86.46,53.88 85.89,53.52 84.48,52.5 83.26,51.85 82.81,51.57 82.8,51.56 81.2,50.73 79.62,50.01 79.41,49.93 79.04,49.78 76.58,48.68 72.08,46.66 70.6,46.66 69.97,46.03 55.26,46.03 54.44,46.85 52.15,46.85 50.92,48.07 48.36,48.96 48.32,49.01 48.31,49.01 47.74,49.58 47.19,50.13 44.91,51.28 43.27,52.2 41.83,53.11 40.9,53.11 38.58,55.43 38.58,55.45 38.5,55.52 38.5,55.52 38.23,55.71 38.08,55.83 37.38,55.83 36.63,56.58 v5(34.65,56.58) 33,56.58 32.77,56.35 32.45,56.35 31.91,56.9 31.48,56.9 31.33,57.05 CV34.1
GPU_HDMI_TX2P_C: length 4.5
  BOTTOM w0.102: CV34.2 30.59,57.17 30.59,57.01 30.46,56.88 30.1,56.88 29.76,57.22 v5(29.27,57.22) 27.73,57.22 27.62,57.33 27.62,57.7 27.66,57.74 UV2.38
GPU_HDMI_TXCN: length 202.4
  BOTTOM w0.076: 199.54,75.49 199.54,75.51 199.47,75.59 199.47,77.55 199.21,77.81 197.99,77.81 197.81,77.99 197.81,78.2 197.92,78.32 198.01,78.32 UG1.AG4
  BOTTOM w0.102: CV41.1 22.49,55.19 22.49,54.46 22.99,53.96 24.1,53.96 25.36,52.7 29.79,52.7 30.95,53.86 33.73,53.86 34.01,54.14 v5(34.7,54.14) 35.24,54.14 36.7,52.68 37.86,52.68 40.02,50.52 40.66,50.52 41.54,49.64 42.44,49.64 42.96,49.12 42.96,48.5 44.84,46.62 46.14,46.62 46.34,46.42 48.2,46.42 49.67,45.87 53.27,42.27 55.65,42.27 56.02,42.65 70.27,42.65 71.74,44.12 72.82,44.12 77.37,46.26 81.42,47.99 94.93,47.99 101.17,54.24 105.76,54.24 114.02,62.5 161.77,62.5 169.1,69.83 178.26,69.83 180.03,71.6 186.44,71.6 187.91,73.07 192.45,73.07 192.73,73.35 196.78,73.35 198.21,74.79 199.04,74.79 199.54,75.29 199.54,75.49
GPU_HDMI_TXCN_C: length 2.6
  BOTTOM w0.102: CV41.2 22.51,56.75 22.51,57.01 23.04,57.53 23.39,57.53 23.66,57.8 UV2.48
GPU_HDMI_TXCP: length 202.4
  BOTTOM w0.076: 199.24,75.49 199.24,75.51 199.31,75.59 199.31,77.49 199.15,77.66 197.92,77.66 197.65,77.93 197.65,78.26 197.86,78.47 198.4,78.47 198.46,78.53 198.46,78.66 UG1.AG5
  BOTTOM w0.102: 199.24,75.49 199.24,75.42 198.91,75.09 198.08,75.09 196.65,73.66 192.6,73.66 192.32,73.38 187.79,73.38 186.31,71.91 179.9,71.91 178.13,70.14 168.98,70.14 161.64,62.8 113.89,62.8 105.63,54.54 101.05,54.54 94.8,48.3 81.36,48.3 77.24,46.54 72.75,44.42 71.61,44.42 70.14,42.95 55.9,42.95 55.52,42.57 53.4,42.57 49.84,46.14 48.25,46.72 46.46,46.72 46.26,46.92 44.97,46.92 43.26,48.63 43.26,49.25 42.56,49.95 41.67,49.95 40.79,50.82 40.15,50.82 37.99,52.98 36.83,52.98 35.36,54.45 33.88,54.45 33.6,54.17 v5(32.58,54.17) 30.83,54.17 29.66,53 25.49,53 24.22,54.27 23.12,54.27 22.8,54.59 22.8,55.23 CV40.1
GPU_HDMI_TXCP_C: length 2.6
  BOTTOM w0.102: UV2.47 24.06,57.77 23.87,57.57 23.52,57.22 23.16,57.22 22.82,56.88 22.82,56.66 CV40.2
GPU_I2C_8409_CLK: length 15.6
  TOP w0.127: RV41.2 23,66.24 v1(23.34,66.59) 23.56,66.81 v2(25.6,66.81) ; RV34.2 30.11,59.71 v2(29.91,59.91)
  IN1 w0.127: v2(29.91,59.91) 29.95,59.91 30.36,60.33 30.36,60.73 29.87,61.22 29.51,61.22 29.3,61.43 29.3,63.59 27.84,65.06 27.84,65.77 26.79,66.81 v2(25.6,66.81)
  BOTTOM w0.127: v2(29.91,59.91) 29.88,59.88 UV2.34
GPU_I2C_8409_DAT: length 21.1
  TOP w0.127: v2(29.86,60.5) 29.88,60.48 RV35.2 ; RV42.2 18.72,70.53 v2(18.98,70.79) 19.32,70.79 v1(19.61,71.08)
  IN1 w0.127: v2(18.98,70.79) 18.98,69.5 20.03,68.45 22.48,66 27.24,66 27.57,65.66 27.57,64.95 29.04,63.48 29.04,61.32 v2(29.86,60.5)
  BOTTOM w0.127: v2(29.86,60.5) 29.7,60.5 29.48,60.28 UV2.33
GPU_OVERT#: length 343.1
  TOP w0.127: v2(144.06,9.81) 144.07,9.79 144.07,9.68 144.44,9.31 UK1.19 ; v2(278.62,11.92) 278.62,12.77 278.24,13.15 278.24,15.25 279.72,16.73 v1(279.72,20.85) 279.72,21.5 278.2,23.02 278.2,24.01 278.34,24.15 278.34,26.47 280.03,28.16 281.35,28.16 283.37,30.19 291.96,30.19 292.48,30.7 292.48,34.93 291.95,35.45 v2(290.59,35.45)
  IN2 w0.127: v2(190.28,82.78) 190.56,82.5 190.56,81.11 191.09,80.59 191.09,79.14 190.84,78.89 190.84,77.55 190.33,77.04 190.33,75.51 191.78,74.06 191.78,71.08 191.19,70.49 191.19,69.89 191.51,69.57 191.51,55.37 192.44,54.44 194.06,52.82 195.83,51.05 196.84,51.05 196.89,51 220.95,51 223.91,48.04 231.39,48.04 231.55,47.88 232.51,47.88 232.92,47.48 234.02,47.48 234.77,48.22 234.77,48.75 235.06,49.04 235.99,49.04 237.74,47.29 v2(238.18,47.29) 238.66,47.29 239.02,46.93 239.02,44.5 239.9,43.62 249.18,43.62 249.53,43.27 254.4,43.27 255.16,42.5 256.11,42.5 256.27,42.35 260.19,42.35 260.43,42.1 260.43,41.93 260.87,41.49 260.92,41.49 261.11,41.3 261.43,41.3 261.82,40.91 262.39,40.91 263.23,41.74 266.97,41.74 267.35,41.36 267.35,40.52 267.92,39.95 272.35,39.95 272.62,40.23 279.93,40.23 280.55,39.6 284.33,39.6 286.68,37.25 289.83,37.25 290.59,36.49 v2(290.59,35.45)
  IN3 w0.127: v2(278.62,11.92) 277.69,11.92 275.53,14.09 275.53,14.9 274.62,15.81 265,15.81 263.76,14.57 257.99,14.57 257.15,15.41 245.97,15.41 245.05,14.49 241.05,14.49 240.56,14.98 238.27,14.98 236.63,13.34 234.7,13.34 233.94,12.58 231.2,12.58 230.08,11.47 227.99,11.47 225.82,9.3 v2(225.36,9.3)
  BOTTOM w0.127: v2(225.36,9.3) 225.51,9.16 225.51,6.98 223.64,5.11 168.91,5.11 168.14,5.89 168.14,8.73 166.55,10.32 164.11,10.32 162.63,11.8 152.44,11.8 149.5,8.85 145.1,8.85 144.14,9.81 v2(144.06,9.81) ; v2(238.18,47.29) 238.18,46.42 237.77,46.02 237.77,45.52 236.57,44.32 236.57,43.66 235.79,42.87 DG7.1 ; QG1.3 185.12,83.51 185.53,83.11 RG392.1 185.77,83.11 185.84,83.18 188.42,83.18 188.83,82.78 v2(190.28,82.78)
GPU_PEX_RST_HOLD#: length 34.6
  TOP w0.102: v2(207.75,81.02) 208.18,80.59 208.18,79.98 208.34,79.81 208.81,79.81 209.06,79.57 209.06,78.65 209.84,77.86 209.84,77.33 209.96,77.21 209.96,76.54 211.71,74.79 213.38,74.79 213.64,74.52 213.64,74.17 213.95,73.86
  TOP w0.127: 213.95,73.86 213.95,72.54 216.53,69.96 222.2,69.96 223.28,68.88 v1(223.39,68.88) 223.54,68.88 225.75,66.67 225.75,63.58 225.15,62.98 224.63,62.98 224.41,63.19 222.17,63.19 RG38.2
  BOTTOM w0.127: UG1.T8 v2(207.75,81.02)
GPUCORE_EN: length 7.7
  BOTTOM w0.254: QG17.5 236.54,40.1 RG105.1 237.32,40.66 DG5.1 237.11,41.55 DG4.2 236.99,42.22 236.98,42.23 DG7.2 236.98,43.46 236.97,43.48 UG10.4 237.05,44.18 RG103.1
GPUCORE_EN#: length 5.7
  BOTTOM w0.127: QG16.2 234.71,38.26 234.93,38.48 235.73,38.48 235.89,38.32 QG17.3 235.89,37.13 RG214.1 ; RG214.1 236.54,37.31 QG17.2 ; RG214.1 v1(236.13,35.88)
GS_SDO_SA0: length 4.9
  TOP w0.127: v1(180.99,42.47) 180.29,43.17 180.29,44.02 179.89,44.42 R5802.1 179.07,44.42 R5801.2
  TOP w0.254: U9.3 178.71,45.15 179.04,44.82 R5801.2
GSEN_I2CLK: length 1.7
  TOP w0.254: R5800.2 177.26,45 177.71,45.44 U9.1
GSEN_I2DAT: length 2.6
  TOP w0.254: R5799.2 180.77,45.14 v1(180.32,45.59) 179.94,45.97 U9.4
GSPI0_MOSI: length 4.7
  BOTTOM w0.102: UH1.BE30 200.37,18.75 200.37,18.18 200.45,18.11 200.45,16.74
  BOTTOM w0.127: RH94.2 201.51,15.19 200.45,16.25 200.45,16.74
GSPI1_MOSI: length 3.2
  TOP w0.127: RH96.2 202.27,19.2 202.15,19.31 202.15,20.57 v1(202.27,20.69) 202.57,20.99 v2(202.57,21.14)
  BOTTOM w0.127: UH1.BA26 202.42,20.99 v2(202.57,21.14)
H_CPUPWRGD: length 230.3
  TOP w0.127: v2(212.7,29.19) v3(212.1,29.19)
  IN2 w0.127: v2(212.7,29.19) 212.2,29.68 210.54,29.68 210.04,30.18 210.04,31 210.1,31.06 210.1,31.9 209.54,32.46 208.75,32.46 208.5,32.7 208.5,33.31 208.02,33.79 207.66,33.79 207.32,34.13 207.32,36.44 206.53,37.23 206.53,38.32 206.19,38.66 204.94,38.66 204.44,39.15 201.57,39.15 201.43,39.29 200.54,39.29 200.1,38.86 197.88,38.86 197.29,38.26 196.8,38.26 196.34,38.72 194.63,38.72 193.69,37.78 193.69,36.96 192.05,35.32 188.79,35.32 188.56,35.55 186.66,35.55 185.49,34.37 185.49,32.87 184.95,32.33 183.62,32.33 179.93,28.65 176.18,28.65 171.64,24.11 164.17,24.11 164.02,23.95 152.05,23.95 151.18,23.09 142.28,23.09 141.99,23.38 137.65,23.38 136.77,22.49 134.67,22.49 134.08,23.09 132.95,23.09 131.91,22.05 128.88,22.05 128.64,21.81 116.96,21.81 116.29,21.14 112.64,21.14 109.57,24.21 107.75,24.21 106.63,25.32 v2(106.63,25.57)
  IN3 w0.127: 114.14,88.36 115.85,88.36 120.12,92.63 120.12,94.21 121.26,95.34 121.26,98.47 122.2,99.41 122.2,100.6 121.24,101.56 121.24,102.26 121.87,102.89 122.76,102.89 v2(124.16,104.29) ; 114.14,88.36 112.54,86.76 ; 114.14,88.36 113.32,87.54 112.54,86.76 ; 112.54,86.76 111.15,85.36 arc(109.74,83.38) 109.06,81.05 arc(109.02,80.63) 109.01,80.21 arc(109.01,80.06) 109.01,79.92 109.01,79.16 103.13,73.29 103.13,72.62 102.65,72.14 102.65,70.83 101.23,69.41 101.23,68.29 99.84,66.91 99.22,65.78 98.81,65.02 98.03,63.61 98.03,59.68 98.37,59.34 98.37,56.92 97.61,56.16 97.61,46.94 98.86,45.69 98.86,44.42 100.28,43 100.28,36.51 99.52,35.75 99.52,32.09 102.36,29.25 102.78,29.25 105.25,26.78 106.03,26.78 106.63,26.18 v2(106.63,25.57)
  BOTTOM w0.102: UC1.BT31 127.19,104.59 125.09,104.59 124.78,104.29 v2(124.16,104.29)
  BOTTOM w0.127: v2(212.7,29.19) 213.06,28.83 UH1.AE3 ; CC157.2 v2(124.16,104.29)
H_PECI: length 274.1
  TOP w0.127: RK17.2 131.03,12.71 129.86,11.55 v2(129.86,10.18) ; v2(218.89,27.17) 219.18,27.17 220.71,25.64 220.71,24.56 219.09,22.94 218.7,22.94 218.3,22.54 218.3,21.43 219.05,20.68 v1(223.54,20.68) 225.11,19.11 225.11,15.68 224.11,14.67 224.11,10.16 219.01,5.06 174.87,5.06 174.22,5.72 173.34,5.72 173.07,5.99 172.64,5.99 171.54,7.08 171.17,7.08 167.31,10.95 156.42,10.95 154.75,9.29 154.75,8.65 151.91,5.8 v2(151.91,5.11)
  IN2 w0.127: v2(129.86,10.18) 130.91,9.13 131.76,9.13 133.36,7.53 149.97,7.53 151.91,5.59 v2(151.91,5.11)
  IN3 w0.127: v2(125.35,106.98) 125.35,106.48 124.36,105.48 123.96,105.48 122.3,103.83 121.57,103.83 120.09,102.36 120.09,95.4 119.18,94.48 119.18,92.98 115.42,89.22 113.78,89.22 110.48,85.92 arc(109.24,84.31) 108.43,82.44 107.89,81.31 106.67,80.08 103.33,80.08 102.66,79.41 102.66,74.04 102.27,73.64 102.27,72.98 101.78,72.49 101.78,71.19 100.36,69.77 100.36,69.06 99.51,68.21 99.22,67.64 98.46,66.27 97.8,65.14 97.17,64.18 97.17,59.43 96.59,58.86 96.59,57.59 95.85,56.85 95.85,54.9 95.85,43.6 97.29,42.16 97.29,29.01 99.2,27.09 101.54,27.09 102.05,26.58 102.05,26.09 v2(103.17,24.97)
  BOTTOM w0.127: UC1.BT34 125.91,106.21 125.35,106.77 v2(125.35,106.98) ; RH13.2 218.79,27.07 v2(218.89,27.17) ; v2(129.86,10.18) 129.11,9.43 126.17,9.43 124.84,10.75 120.23,10.75 116.69,14.29 116.69,18.79 116.17,19.31 108.31,19.31 104.68,22.95 104.68,23.76 103.47,24.97 v2(103.17,24.97)
H_PLTRST_CPU#: length 255.1
  TOP w0.127: v2(103.09,80.78) 103.95,81.63 107.31,81.63 109.23,83.56 109.23,86.24 105.51,89.96 v2(105.51,91.95) ; v2(211.88,27.98) 211.88,28.26 211.57,28.57 210.98,28.57 CH81.1 210.69,28.95 210.14,29.5 210.14,30.19 v2(210.47,30.51)
  IN1 w0.127: v2(103.09,80.78) 103.09,74.23 103.45,73.87 103.45,70.15 97.75,64.45 97.75,59.68 96.95,58.88 96.95,58.35 v2(97.05,58.25)
  IN2 w0.127: v2(106.16,26.04) 106.16,26.23 106.71,26.78 107.61,26.78 112.82,21.57 116.11,21.57 116.8,22.26 125.56,22.26 126.2,22.9 128.01,22.9 128.42,22.48 131.73,22.48 132.77,23.52 134.26,23.52 134.85,22.93 136.59,22.93 137.47,23.81 142.17,23.81 142.46,23.52 151.01,23.52 151.87,24.38 163.84,24.38 163.99,24.54 171.46,24.54 176,29.08 179.62,29.08 183.27,32.72 183.27,33.89 185.36,35.98 188.74,35.98 188.97,35.75 191.87,35.75 193.26,37.14 193.26,37.96 194.25,38.95 196.51,38.95 196.69,39.14 199.98,39.14 200.43,39.59 201.75,39.59 201.84,39.5 204.67,39.5 205.19,38.99 206.33,38.99 206.96,38.35 206.96,37.49 208.3,36.15 208.3,34.33 209,33.63 209.43,33.63 211,32.06 211,31.04 v2(210.47,30.51)
  IN3 w0.127: v2(105.51,91.95) 105.51,93.82 105.8,94.11 105.8,104.59 107.57,106.35 111.9,106.35 119.19,113.65 119.19,114.66 v2(119.11,114.74) ; v2(106.16,26.04) 105.61,25.49 104.7,25.49 102.23,27.95 101.82,27.95 98.02,31.75 98.02,42.04 96.29,43.78 96.29,56.67 97.05,57.43 v2(97.05,58.25)
  BOTTOM w0.127: v2(211.88,27.98) UH1.AG5 ; UC1.BP35 128.29,107.37 127.07,107.37 127,107.45 126.08,107.45 124.03,109.5 CH80.1 122.92,113.13 121.29,114.75 119.12,114.75 v2(119.11,114.74)
H_PM_DOWN: length 5.4
  BOTTOM w0.102: UC1.BP31 128.29,105.01 126.31,105.01 ; v1(124.58,104.82) 124.44,104.82 124.08,105.18 RC22.2
  BOTTOM w0.127: 126.31,105.01 126.12,104.82 v1(124.58,104.82)
H_PM_DOWN_R: length 258
  TOP w0.127: v2(212.45,28.08) 213.35,28.98 RH14.2 ; v2(104.86,80.76) 105.3,81.2 107.49,81.2 109.66,83.38 109.66,86.42 105.95,90.13 v2(105.95,91.08)
  IN1 w0.127: v2(105.95,91.08) 106.51,91.64 106.51,104.16 110.19,107.85 113.25,107.85 118.75,113.35 v2(118.75,113.95) ; v2(97.51,58.83) 98.18,59.5 98.18,64.27 103.88,69.98 103.88,73.78 105.57,75.47 105.57,79.53 104.86,80.23 v2(104.86,80.76)
  IN2 w0.127: v2(212.45,28.08) 212.55,28.08 213.49,29.02 213.49,30.43 209.26,34.66 209.26,35.63 209.45,35.82 209.45,36.27 209.22,36.5 208.57,36.5 207.43,37.64 207.43,38.4 206.44,39.39 205.4,39.39 204.93,39.85 202.1,39.85 201.93,40.02 200.38,40.02 199.73,39.37 196.6,39.37 196.41,39.18 193.87,39.18 193.42,38.73 192.59,38.73 191.97,39.35 191.37,39.35 190.65,38.64 190.65,36.92 189.92,36.19 189.15,36.19 188.86,36.47 185.23,36.47 182.82,34.05 182.82,32.89 179.44,29.51 175.82,29.51 171.28,24.97 163.81,24.97 163.66,24.82 151.69,24.82 150.83,23.95 142.64,23.95 142.28,24.31 136.5,24.31 136.14,23.95 132.59,23.95 131.55,22.91 128.6,22.91 128.19,23.33 125.89,23.33 125.25,22.69 116.62,22.69 115.93,22.01 113,22.01 107.79,27.21 106.53,27.21 v2(105.67,26.35)
  IN3 w0.127: v2(105.67,26.35) 105.24,25.92 104.88,25.92 102.41,28.39 102,28.39 98.66,31.73 98.66,36.11 99.41,36.86 99.41,42.65 98,44.06 98,45.33 96.74,46.58 96.74,56.51 97.51,57.28 v2(97.51,58.83)
  BOTTOM w0.102: UH1.AE2 213.19,28.16 212.53,28.16 v2(212.45,28.08)
  BOTTOM w0.127: RC22.1 119.77,105.18 119.33,105.61 v1(119.33,106.03) 119.33,108.05 122.48,111.2 122.48,112.85 121.02,114.31 119.11,114.31 v2(118.75,113.95)
H_PM_SYNC: length 4.8
  BOTTOM w0.102: UH1.AF3 213.33,27.91 214.02,28.6 216.61,28.6 RH15.1
H_PM_SYNC_R: length 243.5
  IN2 w0.127: v2(218.89,27.76) 217.94,28.71 217.94,33.32 218.27,33.65 218.27,35.58 219.3,36.6 219.3,39.86 215.76,43.4 214.25,43.4 213.03,44.62 212.51,44.62 212.31,44.83 211.99,44.83 211.82,44.99 198.04,44.99 197.44,45.59 197.25,45.59 195.98,45.59 194.17,43.77 190.08,43.77 187.26,40.96 187.26,40.62 186.56,39.92 182.26,39.92 179.94,37.6 178.42,37.6 172.2,31.38 171.35,31.38 169.13,29.16 163.57,29.16 163.35,29.37 150.06,29.37 149.65,28.97 144.85,28.97 144.37,28.48 143.41,28.48 142.81,29.08 141.55,29.08 140.95,28.48 124.45,28.48 122.87,26.9 118.59,26.9 118.18,27.32 116.78,27.32 116.48,27.62 116.48,28.06 116.04,28.49 114.24,28.49 113.56,29.18 108.7,29.18 107.17,27.65 106.35,27.65 v2(105.06,26.35)
  IN3 w0.127: v2(125.94,106.98) 125.94,106.45 124.54,105.05 124.13,105.05 122.48,103.4 121.75,103.4 120.52,102.18 120.52,95.22 119.61,94.31 119.61,92.77 115.63,88.79 113.96,88.79 110.79,85.62 arc(109.32,83.55) 108.61,81.11 108.61,81.11 arc(108.59,80.88) 108.58,80.64 108.58,80.21 arc(108.57,80.07) 108.57,79.92 108.57,79.34 102.7,73.47 102.7,72.8 102.21,72.31 102.21,71.01 100.8,69.59 100.8,68.47 99.49,67.17 98.84,65.99 98.43,65.23 97.6,63.72 97.6,59.5 97.94,59.16 97.94,57.1 97.18,56.33 97.18,46.76 98.43,45.51 98.43,44.24 99.85,42.82 99.85,36.69 99.09,35.93 99.09,31.91 102.18,28.82 102.59,28.82 v2(105.06,26.35)
  BOTTOM w0.127: RH15.2 218.37,27.76 v2(218.89,27.76) ; UC1.BM34 129.55,106.62 126.3,106.62 v2(125.94,106.98)
H_PROCHOT#: length 307.2
  TOP w0.127: RK8.2 130.25,22.57 RK9.2 129.92,22.58 CK12.1 128.19,23.16 QK1.1 127.41,23.95 125.05,23.95 123.08,25.91 121.84,25.91 120.36,27.39 v2(120.36,27.76) ; v2(108.46,88.76) 108.46,88.23 110.1,86.6 110.1,83.2 107.64,80.74 v2(105.47,80.74)
  IN1 w0.127: v2(120.36,27.76) 119.97,27.37 119.24,27.37 119.19,27.31 116.77,27.31 116.49,27.03 113.92,27.03 113.76,26.87 104.76,26.87 103.87,27.77 101.79,27.77 97.16,32.4 97.16,41.56 94.53,44.2 94.53,47.14 95.66,48.27 95.66,52.69 98.61,55.64 98.61,64 104.31,69.71 104.31,73.61 106.01,75.3 106.01,79.76 105.47,80.29 v2(105.47,80.74) ; v2(108.46,88.76) 111.45,88.76 112,89.31 114.43,89.31 121.09,95.97 v2(121.09,99.64)
  IN2 w0.127: v2(245.34,37.47) 222.97,37.47 214.95,45.49 200.27,45.49 198.48,45.49 197.49,46.47 195.1,46.47 194.99,46.58 194.2,46.58 194.02,46.4 192.43,46.4 192.23,46.6 190.53,46.6 187.12,43.19 187.12,42.65 185.25,40.79 181.31,40.79 180.49,39.96 178.71,39.96 176.19,37.44 173.69,37.44 172.52,36.27 172.52,33.77 168.77,30.02 163.93,30.02 163.71,30.24 149.7,30.24 149.29,29.83 144.45,29.83 143.96,29.35 143.77,29.35 143.17,29.94 141.19,29.94 140.59,29.35 124.09,29.35 123.42,28.68 120.89,28.68 120.36,28.15 v2(120.36,27.76)
  IN3 w0.127: v2(245.34,37.47) 245.05,37.18 233.77,37.18 228.47,31.88 228.47,30.41 224.85,26.79 224.85,21.4 226.35,19.89 226.35,18.09 v2(225.86,17.59)
  BOTTOM w0.127: RC42.2 RC18.1 120.22,100.5 v2(121.09,99.64) ; v2(225.86,17.59) 225.86,15.28 226.77,14.36 PRB17.1
H_PROCHOT#_CPU: length 8.7
  BOTTOM w0.102: UC1.BR30 127.64,103.64 127.12,103.64 127.1,103.66 125.64,103.66 125.2,103.22 124.56,103.22 124.31,102.97 122.2,102.97 RC42.1
  BOTTOM w0.127: RC42.1 v1(121.14,102.93)
H_PROCHOT#_EC: length 13.3
  TOP w0.127: UK1.103 134.49,19.82 134.38,19.93 134.37,19.93 133.9,20.4 133.9,20.41 133.89,20.41 133.89,21.22 133.13,21.98 v1(133.13,21.99) 133.12,21.99 132.36,22.75 132.36,23.49 132,23.85 131.14,23.85 130.79,23.49 RK9.1 129.85,23.49 129.5,23.84 128.82,23.84 127.97,24.69 QK1.2
H_THERMTRIP#: length 16
  TOP w0.127: v2(162.54,104.96) 163.03,104.47 163.03,103.62 164.13,102.52 164.51,102.52 164.74,102.75 166.52,102.75 167.14,103.36 167.14,103.96 167.38,104.2 167.75,104.2 170.13,101.82 RC45.2
  BOTTOM w0.127: v2(162.54,104.96) UC1.J31
HDA_BIT_CLK: length 10.1
  BOTTOM w0.089: 211.03,14.72 210.41,15.34 210.41,15.79 209.3,16.9 209.3,17.79 209.03,18.06 209.03,18.87 209.02,18.88 209.02,19.36 UH1.BD11
  BOTTOM w0.127: 211.03,14.72 211.68,14.07 v1(212.88,14.07) 214.94,14.07 RH245.1
HDA_BIT_CLK_R: length 93.3
  TOP w0.135: v2(299.48,15.77) 299.48,15.77 CA15.1 299.28,16.61 298.76,17.14 298.76,19.15 298.47,19.43 UA1.14
  IN1 w0.203: v2(278.72,16.86) 278.72,16.86 278.72,16.77 277.92,15.98 276.13,15.98 275.3,16.81 263.87,16.81 263.37,16.31 257.33,16.31 257.1,16.53 237.61,16.53 237.25,16.89 235.03,16.89 233.78,15.63 226.58,15.63 225.97,16.25 222.77,16.25 221.67,15.14 221.19,15.14 v2(221.07,15.26)
  IN3 w0.216: v2(278.72,16.86) 278.76,16.81 282.36,16.81 283.87,15.31 286.16,15.31 286.67,14.8 288.89,14.8 289.39,15.31 291.07,15.31 292.29,16.53 293.72,16.53 294.05,16.86 298.39,16.86 v2(299.48,15.77)
  BOTTOM w0.196: RH245.2 217.17,13.87 CH66.2 218.33,15.02 219.51,15.02 219.75,15.26 v2(221.07,15.26)
HDA_RST#: length 8.8
  BOTTOM w0.102: 211.52,14.89 211.18,15.24 211.18,16.05 210.9,16.33 210.9,17.28 210.02,18.16 210.02,18.8 UH1.BE10
  BOTTOM w0.127: 211.52,14.89 v1(211.71,14.7) 211.98,14.44 214.8,14.44 214.99,14.63 RH244.1
HDA_RST#_R: length 88.6
  TOP w0.196: QA2.3 290.94,12.88 288.04,12.88 287.79,12.63 287.79,12.38 284.95,9.54 282.63,9.54 282.39,9.78 278.82,9.78 v1(277.99,10.62) 277.88,10.73 277.88,15.4 278.2,15.72 278.2,17.18 v2(278.09,17.3)
  IN1 w0.203: v2(221.43,15.73) 222.53,16.83 226.21,16.83 226.64,16.41 233.72,16.41 234.79,17.47 237.5,17.47 237.85,17.12 257.34,17.12 257.57,16.89 263.09,16.89 263.58,17.39 271.41,17.39 272.62,18.6 274.57,18.6 274.82,18.85 275.61,18.85 277.16,17.3 v2(278.09,17.3)
  BOTTOM w0.196: v2(221.43,15.73) 221.28,15.87 219.83,15.87 219.38,15.42 218.58,15.42 CH69.2 218.07,15.77 216.93,14.63 RH244.2
HDA_SDIN0: length 105.3
  TOP w0.135: v2(289.56,9.03) 290.42,9.03 290.79,9.39 291.01,9.39 293.99,12.37 v1(296.5,12.37) 297.12,12.37 300.06,15.31 300.36,15.31 300.49,15.44 300.49,16.96 300.2,17.25 RA12.2
  IN1 w0.127: v2(209.94,16.88) 212.05,14.77 212.05,13.49 212.37,13.17 212.77,13.17 213.15,13.54 215.48,13.54 216.11,12.92 221.22,12.92 221.65,13.35 223.33,13.35 224.06,14.09 224.06,14.09 224.58,14.61 226.26,14.61 226.55,14.32 233.81,14.32 235.02,15.53 236.9,15.53 236.95,15.58 256.71,15.58 256.95,15.34 257.28,15.34 257.88,14.74 263.31,14.74 264.42,15.85 274.91,15.85 277.64,13.12 278.94,13.12 283.04,9.03 v2(289.56,9.03)
  BOTTOM w0.122: v2(209.94,16.88) 209.66,17.16 209.66,17.73 209.26,18.13 UH1.BE11
HDA_SDIN0_R: length 4.5
  TOP w0.127: 299.64,19.79 299.64,19.27 299.33,18.96 v1(299.33,18.74) 299.33,18.04 CA93.1 RA12.1
  TOP w0.135: 299.64,19.79 299.32,20.12 298.75,20.12 298.64,20.23 UA1.16
HDA_SDIN1: length 3.3
  BOTTOM w0.127: UH1.BF10 209.62,18.16 210.62,17.16 210.62,16.17 210.77,16.01 TH119.1
HDA_SDOUT: length 13.4
  TOP w0.196: RH196.1 212.96,12.22 RH118.2 212.93,13.29 v2(212.54,13.68) 211.33,13.68 QH2.3
  BOTTOM w0.089: UH1.BF12 208.82,18.23 208.82,17.91 209,17.73 209,16.78 210.13,15.65 210.13,15.12 210.63,14.62
  BOTTOM w0.127: 210.63,14.62 211.57,13.68 v2(212.54,13.68) 213.81,13.68 214.08,13.42 v1(214.08,13.4) 214.85,13.4 RH246.1
HDA_SDOUT_R: length 93.2
  TOP w0.135: v2(299.81,20.19) 299.65,20.35 298.96,20.35 298.68,20.63 UA1.17
  IN1 w0.203: v2(220.72,14.79) 220.94,14.56 221.91,14.56 223.01,15.66 225.73,15.66 226.7,14.69 233.66,14.69 234.86,15.89 236.75,15.89 236.8,15.95 256.86,15.95 257.1,15.71 257.52,15.71 258.13,15.1 263.15,15.1 264.27,16.22 275.06,16.22 275.89,15.39 278.16,15.39 279.3,16.53 v2(279.3,17.41)
  IN3 w0.216: v2(279.3,17.41) 282.61,17.41 284.12,15.9 290.82,15.9 292.37,17.45 297.83,17.45 299.81,19.44 v2(299.81,20.19)
  BOTTOM w0.196: RH246.2 CH68.2 218.65,13.94 219.45,13.94 v1(220.06,14.56) 220.29,14.79 v2(220.72,14.79)
HDA_SPKR: length 105.1
  TOP w0.127: v2(283.95,28.88) 283.95,27.89 284.51,27.33 v1(285.01,27.33) 286.97,27.33 CA28.1
  TOP w0.196: v2(201.35,22.46) 201.35,21.8 201.88,21.27 201.88,19.35 201.5,18.97 RH53.1
  IN2 w0.127: v2(283.95,28.88) 279,28.88 278.52,29.36 276.02,29.36 275.57,28.9 265.59,28.9 264.09,30.4 259.11,30.4 255.8,33.71 252.98,33.71 252.63,33.36 252.63,32.48 252.44,32.29 248.68,32.29 247.97,33 239.62,33 238.95,33 238.76,33.19 227.47,33.19 219.05,24.77 219,24.77 218.06,24.77 217.07,23.79 216.7,23.79 215.8,22.88 215.8,22.48 215.26,21.93 214.91,21.93 214.7,22.14 210.9,22.14 210.29,21.52 210.29,20.96 209.23,19.9 207.09,19.9 206.33,19.14 204.55,19.14 204.17,19.52 204.17,21.11 203.65,21.63 202.19,21.63 v2(201.35,22.46)
  BOTTOM w0.127: v2(201.35,22.46) 200.57,21.68 UH1.AW29
HDA_SYNC: length 4.3
  BOTTOM w0.089: 209.33,15.26 v1(209.33,15.89) 208.57,16.64 UH1.BG13
  BOTTOM w0.135: RH247.1 209.67,14.21 209.33,14.55 209.33,15.26
HDA_SYNC_R: length 103.7
  TOP w0.135: v2(299.13,19.68) 298.77,19.68 298.62,19.83 UA1.15
  IN1 w0.203: v2(226.2,20.64) 226.16,20.61 226.16,18.08 227.41,16.83 233.57,16.83 234.62,17.88 237.66,17.88 238.02,17.53 257.51,17.53 257.74,17.3 262.92,17.3 263.41,17.8 271.24,17.8 272.45,19 274.4,19 274.65,19.26 275.78,19.26 277.28,17.76 278.41,17.76 v2(278.71,17.46)
  IN3 w0.216: v2(278.71,17.46) 278.71,17.61 278.97,17.87 282.74,17.87 284.29,16.32 290.65,16.32 292.2,17.87 297.32,17.87 v2(299.13,19.68)
  BOTTOM w0.196: v2(226.2,20.64) 224.34,20.64 v1(223.47,19.77) 221.85,18.15 221.85,13.98 220.98,13.1 CH67.2 219.74,12.34 214.99,12.34 214.33,13 213.76,13 213.58,13.18 211,13.18 RH247.2
HDDHALT_LED#: length 148.9
  TOP w0.127: v2(278.23,18.21) v3(278.23,18.85)
  IN1 w0.127: v2(204.42,16.08) 204.79,16.08 209.79,11.08 216.36,11.08 218.04,9.4 218.61,9.4 v2(220.03,7.98)
  IN3 w0.127: v2(278.23,18.21) 278.23,18.34 276.6,19.96 272.66,19.96 270.41,17.71 264.31,17.71 263.48,16.89 258.36,16.89 258,17.25 237.28,17.25 236.83,16.79 235.55,16.79 234.74,15.98 226.49,15.98 224.15,13.63 224.15,13.17 220.63,9.66 220.63,8.58 v2(220.03,7.98)
  BOTTOM w0.127: RH194.2 205.09,15.41 v2(204.42,16.08) 204.25,16.08 203.29,17.03 203.29,18.51 UH1.BE23 ; JIO1.7 308.12,42.75 307.6,42.23 307.6,41.68 307.28,41.36 303.3,41.36 302.79,40.85 293.85,40.85 292.58,42.12 292.58,43.09 291.42,44.25 282.48,44.25 278.72,40.49 278.72,37.5 277.58,36.36 277.58,29.76 278.59,28.75 278.59,25.5 279.95,24.15 279.95,23.83 278.23,22.11 v2(278.23,18.21)
HDMI_1.2V_EN: length 14.7
  TOP w0.127: v3(32.86,59.38) 33.44,58.81 v2(33.44,58.41)
  TOP w0.254: UV3.1 26.11,55.48 26.48,55.85 RV30.1 27,55.79 28.83,55.79 v2(28.94,55.89)
  IN1 w0.254: v2(28.94,55.89) 28.92,55.87 28.59,55.87 28.24,56.23 28.24,58.06 29.34,59.16 30.22,59.16 30.68,59.62 32.01,59.62 32.83,58.8 33.05,58.8 v2(33.44,58.41)
  BOTTOM w0.254: v2(33.44,58.41) 33.03,58.01 33.03,57.82 RV11.1
HDMI_EQ: length 9.1
  TOP w0.127: v2(19.12,64.65) v1(19.48,64.28) 19.86,63.9 RV22.2 20.66,63.9 RV21.2
  IN3 w0.127: v2(21.98,60.44) 21.82,60.44 21.38,60.88 21.38,61.7 19.12,63.96 v2(19.12,64.65)
  BOTTOM w0.127: UV2.5 22.22,60.68 v2(21.98,60.44)
HDMI_HPD_GPU#: length 38.1
  IN1 w0.127: v2(218.03,66.12) 219.38,66.12 220.73,67.47 222.84,67.47 225.34,64.97 227.42,64.97 228.36,64.03 232.52,64.03 232.91,64.41 v2(233.38,64.41)
  IN3 w0.127: v2(206.84,77.75) 206.84,77.27 212.54,71.57 213.81,71.57 217.2,68.18 217.2,66.68 217.76,66.12 v2(218.03,66.12)
  BOTTOM w0.102: UG1.U3 206.48,77.4 v2(206.84,77.75)
  BOTTOM w0.127: v1(233.53,65.02) 233.38,64.87 v2(233.38,64.41) 233.7,64.41 233.82,64.29 QG55.1 234.78,64.67 RG180.2
HDMI_I2C_ADDR: length 1.9
  BOTTOM w0.127: UV2.31 29.47,61.08 29.57,61.18 30.26,61.18 30.33,61.1 RV23.2
HDMI_ID: length 2.1
  BOTTOM w0.127: UV2.32 29.44,60.68 29.68,60.92 30.04,60.92 30.62,60.34 RV26.2
HDMI_PRE: length 2.7
  TOP w0.127: v1(29.75,63.76) v2(29.75,63.12) 29.29,62.66 RV25.2
  BOTTOM w0.127: v2(29.75,63.12) 29.31,62.68 UV2.27
HDMI_SRC_HPD: length 268.9
  IN2 w0.127: v2(26.9,57.37) 26.9,55.25 27.26,54.89 27.26,53.82 28.07,53.01 30.88,53.01 31.38,53.52 31.73,53.52 32.5,52.75 33.12,52.75 33.38,52.48 34.49,52.48 34.56,52.41 34.64,52.41 34.89,52.16 34.89,52.08 37.6,49.38 37.6,48.49 38.7,47.39 39.02,47.39 42.37,44.04 44.03,44.04 44.25,44.26 44.6,44.26 44.85,44.01 45.29,44.01 45.54,44.26 45.89,44.26 46.27,43.88 46.74,43.88 47.6,43.01 49.03,43.01 49.4,42.64 49.81,42.64 50.51,41.95 56.03,41.95 57.03,42.95 67.18,42.95 68.89,44.65 77.2,44.65 77.85,45.3 80.52,45.3 82.08,46.86 v2(82.08,47.36) ; v2(234.6,49.56) 234.5,49.46 234.5,48.33 233.91,47.74 233.03,47.74 232.63,48.15 231.66,48.15 231.51,48.31 224.02,48.31 221.06,51.27 197,51.27 196.95,51.32 195.95,51.32 194.33,52.93 192.56,54.71 191.78,55.48 191.78,69.96 v2(191.61,70.13)
  IN3 w0.127: v2(233.55,61) 233.89,60.65 233.89,53.88 233.83,53.82 233.83,53.46 235.37,51.91 235.37,50.33 v2(234.6,49.56)
  BOTTOM w0.127: UG28.1 237.57,62.39 237.16,62.79 236.32,62.79 235.31,61.79 RG114.2 234.8,60.6 233.94,60.6 v2(233.55,61) ; v2(26.9,57.37) 26.86,57.41 UV2.40 ; v2(191.61,70.13) 191.52,70.04 186.57,70.04 185.52,71.09 v1(183.48,71.09) 180.22,71.09 178.46,69.34 169.31,69.34 161.98,62 114.22,62 105.96,53.74 101.38,53.74 95.14,47.5 82.21,47.5 v2(82.08,47.36)
HDMICONN_HPD_LS: length 76.7
  IN1 w0.203: v2(12.75,117.73) 12.79,117.78 13.14,117.78 14.79,116.13 14.79,113.74 13.58,112.53 13.58,107.31 14.71,106.18 14.71,98.57 16.46,96.83 16.46,75.25 18.52,73.19 18.52,69.53 22.36,65.7 26.27,65.7 v2(26.86,65.1)
  BOTTOM w0.127: v2(26.86,65.1) v1(26.86,65.61)
  BOTTOM w0.203: JHDMI1.19 10.75,116.4 11.45,117.1 13.65,117.1 14.66,116.09 DV1.9 DV1.1 16.73,116.09 17.61,116.96 RV29.1 17.61,117.02 17.06,117.56 16.52,117.56 16.51,117.56 QV1.1 15.82,117.7 12.91,117.7 12.87,117.73 v2(12.75,117.73) ; UV2.21 v2(26.86,65.1)
HDMICONN_SCL_LS: length 72.4
  TOP w0.127: RV39.2 22.07,67.5 v2(21.16,68.4) ; v2(14.22,115.74) v1(15.02,115.74)
  IN1 w0.127: v2(17.71,116.36) 17.71,113.02 15.28,110.59 15.28,98.8 17.02,97.06 17.02,75.49 20.11,72.4 20.11,70.59 21.54,69.16 21.54,68.78 v2(21.16,68.4) ; v2(14.22,115.74) 13.39,116.57 12.03,116.57 11.52,116.05 11.52,114.92 JHDMI1.15
  BOTTOM w0.127: v2(17.71,116.36) 17.66,116.3 17.66,115.64 RV27.1 17.19,115.59 17.18,115.58 DV1.2 DV1.8 14.38,115.58 v2(14.22,115.74) ; v2(21.16,68.4) 22.42,67.15 22.42,65.25 21.59,64.42 21.59,62.1 22.22,61.48 UV2.7
HDMICONN_SCL_LS_R: length 4.1
  TOP w0.127: QV2.3 20.64,66.35 20.75,66.24 RV41.1 RV39.1 21.16,67.41 20.58,67.99 v1(20.58,69.1)
HDMICONN_SDA_LS: length 67.1
  TOP w0.127: v2(14.2,114.37) v1(15.04,114.37) ; RV40.2 17.93,70.36 v2(18.98,71.42)
  IN1 w0.127: JHDMI1.16 12.58,114.37 v2(14.2,114.37) ; v2(21.12,68.99) 19.46,70.65 19.46,70.94 v2(18.98,71.42) 18.82,71.58 18.82,73.32 16.76,75.38 16.76,96.95 15.01,98.7 15.01,112.54 16.56,114.09 v2(16.82,114.09)
  BOTTOM w0.127: UV2.8 22.19,61.88 21.85,62.21 21.85,64.31 22.68,65.14 22.68,67.72 21.41,68.99 v2(21.12,68.99) ; v2(14.2,114.37) 14.42,114.58 DV1.7 DV1.4 17.07,114.58 17.19,114.7 RV28.1 17.61,114.26 17.44,114.09 v2(16.82,114.09)
HDMICONN_SDA_LS_R: length 2.8
  TOP w0.127: v1(16.97,69.55) 17.43,69.08 RV40.1 RV42.1 18.85,68.95 QV2.6
HGATE_1.35VSDGPUP: length 16.3
  IN3 w0.762: 241.28,52.03 241.68,52.43 244.22,52.43 246.61,54.82 250.49,54.82 252.09,53.22 255.79,53.22
  BOTTOM w0.127: v2(240.37,50.89) 240.37,50.89
  vias: v2(240.79,51.36) v2(257.14,53.82) v2(257.15,53.24)
HP_OUT_L: length 5.9
  BOTTOM w0.254: JIO1.31 308.26,30.75 307.96,30.45 308.15,30.25 JIO1.32
  BOTTOM w0.381: LA9.1 304.25,29.61 CA96.1 305.27,29.61 v2(305.58,29.93) 305.77,29.93 306.29,30.45 307.96,30.45
HP_OUT_R: length 5.8
  BOTTOM w0.254: JIO1.35 308.31,28.75 308.04,29.02 308.26,29.25 JIO1.34
  BOTTOM w0.381: LA8.1 304.25,28.34 CA95.1 305.86,28.34 v2(305.93,28.28) 306.21,28.28 306.96,29.02 308.04,29.02
HP_OUTL: length 8.6
  TOP w0.381: RA11.2 v2(296.63,26.82)
  BOTTOM w0.381: LA9.2 v1(300.19,29.49) 298.77,29.49 296.63,27.34 v2(296.63,26.82)
HP_OUTR: length 7.5
  TOP w0.381: RA9.2 v2(297.39,26.82)
  BOTTOM w0.381: v2(297.39,26.82) v1(298.8,28.23) 299.34,28.77 302.72,28.77 LA8.2
HPOUT_L: length 1.5
  TOP w0.203: UA1.27 296.42,24.9 296.63,25.11
  TOP w0.381: RA11.1 296.63,25.11
HPOUT_R: length 1.6
  TOP w0.203: 297.22,25.1 296.82,24.7 UA1.26
  TOP w0.381: RA9.1 297.39,25.27 297.22,25.1
HRESET_987: length 136.6
  TOP w0.127: v2(52.16,47.5) 51.9,47.75 51.61,47.83 49.72,47.83 RU64.1 ; v2(126.13,10.2) 123.91,12.42 117.52,12.42 116.22,13.72 116.22,17.75 117.3,18.83 117.3,21.03 118.18,21.9 v1(118.18,24) v2(118.18,26.73) ; v2(143.44,9.83) 144.04,9.23 UK1.18
  IN1 w0.127: v2(52.16,47.5) 53.52,46.14 53.52,43.71 54.59,42.64 56.01,42.64 57.79,44.42 65.24,44.42 67.86,41.8 67.86,31.3 70.51,28.65 85.31,28.65 87.14,26.82 89.75,26.82 91.08,25.48 94.47,25.48 96.26,27.28 98.16,27.28 101.19,24.25 112.69,24.25 114.91,26.47 117.92,26.47 v2(118.18,26.73)
  IN2 w0.127: v2(143.44,9.83) 142.35,10.92 135.26,10.92 135.09,11.09 132.59,11.09 131.87,11.81 127.23,11.81 126.13,10.7 v2(126.13,10.2)
HRESET_987_R: length 2.9
  TOP w0.127: RU63.1 48.62,48.66 RU64.2 48.62,48.26 49.14,47.73 UU4.44
I2C_0_SCL: length 19.6
  TOP w0.127: v2(209.76,7.57) 209.76,7.03 209.35,6.63 RH230.1 208.87,6.74 209.36,7.23 209.36,8.17 QC10.1
  BOTTOM w0.089: 207.66,13.31 207.38,13.59 207.38,13.59 205.97,15 205.97,15.31 204.41,16.88 204.03,16.88 203.75,17.15 203.75,18.03 203.95,18.23 203.95,18.66 204.07,18.78 204.07,19.71 UH1.BC22
  BOTTOM w0.127: 207.66,13.31 207.8,13.17 v1(207.8,13.09) 207.8,12.48 210.72,9.55 210.72,8.53 v2(209.76,7.57)
I2C_0_SDA: length 12.1
  TOP w0.127: v2(206.84,9.78) RH231.1 206.94,9.17 207.55,9.77 QC10.4
  BOTTOM w0.089: 206.84,13.54 v1(205.98,14.39) 205.72,14.65 205.72,15.31 204.6,16.44 204.2,16.44 203.54,17.1 203.54,18.26 UH1.BF23
  BOTTOM w0.127: v2(206.84,9.78) 206.84,13.54
I2C_1_SCL: length 13.6
  TOP w0.127: v2(212.45,10.13) 212.83,9.75 RH228.1
  BOTTOM w0.089: 205.58,16.61 205.28,16.61 204.78,17.12 204.78,17.59 204.63,17.74 204.63,18.45 204.4,18.68 UH1.BE21
  BOTTOM w0.127: 205.58,16.61 v1(206.37,15.82) 208.7,13.49 208.7,12.8 210.93,10.56 212.02,10.56 v2(212.45,10.13)
I2C_1_SDA: length 12.6
  TOP w0.127: RH229.1 212.07,9.85 v2(211.79,10.13)
  BOTTOM w0.089: UH1.BF21 204.42,18.23 204.42,17.68 204.6,17.5 204.6,16.98 v1(207.27,14.31) 208.02,13.55
  BOTTOM w0.127: 208.02,13.55 208.24,13.34 208.24,12.65 210.75,10.13 v2(211.79,10.13)
I2C_INT#: length 8.8
  TOP w0.127: v2(91.21,12.22) 91.56,11.86 v3(92.43,11.86) 93.66,11.86 DT1.2 93.79,12.89 91.84,12.89 R5236.2 R5808.2
  BOTTOM w0.127: JTP1.2 91.2,12.22 v2(91.21,12.22)
ILIM_1PH: length 5.9
  TOP w0.127: v2(173.21,127.33) v1(174.08,127.33)
  TOP w0.203: PRZ20.2 PCZ9.2 172.23,128.23 173.13,127.33 v2(173.21,127.33)
  BOTTOM w0.203: v2(173.21,127.33) 173.13,127.33 172.65,127.81 172.36,127.81 171.74,128.43 PUZ1.49
ILIM_2PH: length 2.1
  BOTTOM w0.203: PRZ44.1 167.77,134.03 v1(167.77,133.6) 167.77,133.59 167.83,133.53 PUZ1.32
ILIM_4PH: length 4.6
  BOTTOM w0.203: PUZ1.7 v1(168.23,125.19) 168.23,125.14 168.46,124.91 168.46,124.73 168.73,124.46 169.01,124.46 170.34,123.14 PRZ43.2
ILIM_SEL: length 3.1
  BOTTOM w0.127: v1(18.04,76.15) 18.04,76.3 18.28,76.54 RS17.1 18.57,77.17 19.03,77.62 US2.4
ILMT_1.35VSDGPUP: length 3.4
  BOTTOM w0.254: PUW1.2 240.95,56.04 240.65,56.35 v2(239.83,56.35) 239.73,56.35 238.96,57.12 PRW4.2
ILMT_1V05: length 5.5
  BOTTOM w0.254: PR1004.2 PR1002.1 240.08,23.05 240.08,24.19 239.74,24.53 v2(239.07,24.53) 238.4,24.53 237.82,25.11 PU1001.13
ILMT_VCCIOP: length 2.9
  BOTTOM w0.254: PUH1.13 182.52,102.96 182.25,102.69 v2(182.25,102.56) 181.64,101.95 PRH10.1 PRH9.2
IMON_1PH: length 4.3
  TOP w0.127: v1(171.99,131.82) 171.86,131.7 PRZ13.2
  TOP w0.203: v2(172.49,129.28) 172.47,129.3 172.47,129.4 PCZ6.2 PRZ13.2
  BOTTOM w0.203: PUZ1.46 172.05,129.63 172.4,129.28 v2(172.49,129.28)
IN_2.5V:
  vias: v1(106.25,19.21)
INT_MIC: length 5.2
  BOTTOM w0.254: v2(306.72,31.27) 307.04,31.58 308.08,31.58 308.25,31.75 JIO1.29
  BOTTOM w0.381: LA10.1 304.37,30.38 CA97.1 305.31,30.38 306.2,31.27 v2(306.72,31.27)
INT_MIC_R: length 12.6
  TOP w0.203: 295.06,25.61 295.06,25.14 294.82,24.9 UA1.31
  TOP w0.381: 295.06,25.61 295.06,25.83 295.5,26.26 RA4.2 v2(295.86,26.82)
  BOTTOM w0.381: v2(295.86,26.82) 295.86,27.48 298.63,30.24 v1(302.07,30.24) 302.88,30.24 LA10.2
INVPWR_B+: length 1.8
  TOP w0.254: v2(85.81,31.77) 85.4,31.77 85.06,32.12 PCP8.1 PRP4.1
  vias: v2(87.46,30.63) v2(87.46,30) v3(86.29,33.73)
