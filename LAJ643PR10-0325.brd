# Allegro board LAJ643PR10-0325.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
TPM_PP: length 2.5
  TOP w0.135: RTT35.2 RTT12.1 119.05,15.66 UT1.7
TPM_SERIRQ: length 2.3
  TOP w0.127: UT1.18 126.46,15.66 v1(126.98,15.15) 126.99,15.14 R5202.2
TSENSE_2PH: length 2.9
  BOTTOM w0.203: PUZ1.25 164.57,131.63 163.96,132.23 PCZ32.1 PRZ75.1
TSENSE_4PH: length 4.2
  BOTTOM w0.127: v1(164.74,125.36) 164.27,125.83 PRZ74.1
  BOTTOM w0.203: PUZ1.14 164.97,127.23 164.17,126.42 164.17,126.21 PRZ74.1 163.05,125.83 PCZ30.1
U2D_DN1: length 6
  TOP w0.127: LS9.4 20.46,85.61 20.56,85.52 v4(20.56,84.88) 20.56,84.5 20.18,84.11 19.91,84.11 v2(19.75,83.95)
  BOTTOM w0.127: v2(19.75,83.95) 19.75,84.13 19.62,84.26 19.47,84.26 19.28,84.08 19.28,83.1 19.48,82.9 19.48,82.9 19.61,82.77 19.61,82.53 19.72,82.42 19.96,82.42 20.03,82.36 US2.11
U2D_DP1: length 6
  TOP w0.127: LS9.1 19.96,85.59 20.04,85.51 20.2,85.51 20.3,85.41 20.3,84.6 20.07,84.37 19.82,84.37 19.69,84.5 19.69,84.6 v2(19.75,84.66)
  BOTTOM w0.127: US2.10 19.53,82.25 19.36,82.43 19.36,82.66 19.03,82.99 19.03,84.19 19.36,84.52 19.61,84.52 v2(19.75,84.66)
UART_2_CCTS_DRTS: length 4.9
  TOP w0.127: RH81.1 204.17,19.54 203.85,19.86 v1(203.85,20.03) 203.85,20.28 203.89,20.32 203.89,20.75 204.03,20.89 204.03,21.03 204.82,21.82 v2(205.22,21.82)
  BOTTOM w0.127: v2(205.22,21.82) 205,21.82 204.51,22.3 UH1.AV21
UART_2_CRTS_DCTS: length 4.3
  TOP w0.127: RH79.1 204.93,19.1 204.17,19.87 204.17,20.16 204.12,20.21 204.12,20.66 204.26,20.8 204.26,20.88 204.6,21.22 v2(205.28,21.22)
  BOTTOM w0.127: v2(205.28,21.22) 204.81,21.68 UH1.AW21
UART_2_CRXD_DTXD: length 143.4
  TOP w0.127: v2(277.75,16.45) 277.51,16.22 277.51,6.56 v1(277.52,6.56) 277.52,6.1 276.77,5.35 v2(276.77,5.35) ; v2(213.14,10.13) 213.59,9.68 RH76.1
  TOP w0.135: v2(311.19,17.83) 310.98,18.04 RWL32.1
  IN3 w0.127: v2(276.77,5.35) 276.77,5.35 277.2,5.78 281.56,5.78 282.7,4.63 303.68,4.63 311.96,12.91 311.96,17.53 311.66,17.83 v2(311.19,17.83) ; v2(221.3,9.28) 221.72,9.28 222.04,9.6 222.04,10.3 224.57,12.84 225.32,12.84 226.79,14.31 231.38,14.31 231.79,14.72 234.24,14.72 235.05,15.53 236.92,15.53 238.1,16.71 257.78,16.71 258.13,16.35 263.71,16.35 264.53,17.18 270.67,17.18 272.83,19.34 275.45,19.34 277.11,17.67 277.11,17.09 v2(277.75,16.45)
  BOTTOM w0.102: 204.89,18.14 204.89,18.57 204.64,18.83 204.64,19.36 UH1.BD20
  BOTTOM w0.127: v2(221.3,9.28) 220.44,10.14 219.01,10.14 218.3,9.43 213.84,9.43 v2(213.14,10.13) 212.09,11.17 210.94,11.17 209.13,12.98 209.13,13.55 205.65,17.03 205.65,17.38 204.89,18.14
UART_2_CTXD_DRXD: length 126
  TOP w0.127: RH78.1 214.36,9.85 214.06,10.15 v2(213.78,10.15) ; RWL33.1 311.21,15.54 v1(311.21,14.54) 311.21,14.25 310.63,13.68 307.81,13.68 305.37,16.12 v2(305.37,16.3)
  IN3 w0.127: v2(305.37,16.3) 304.48,15.4 303.9,15.4 302.06,13.56 292.35,13.56 290.72,11.93 285.98,11.93 281.65,16.26 278.53,16.26 277.38,17.41 277.38,17.82 275.6,19.6 272.7,19.6 270.54,17.44 264.42,17.44 263.6,16.62 258.25,16.62 257.89,16.98 237.99,16.98 236.81,15.8 234.94,15.8 234.81,15.67 226.57,15.67 224.41,13.52 224.41,13.06 221.62,10.27 v2(221.62,9.77)
  BOTTOM w0.102: 205.55,18.44 205.55,18.58 205.36,18.77 205.08,18.77 UH1.BE20
  BOTTOM w0.127: 205.87,17.18 205.87,17.47 205.55,17.8 205.55,18.44 ; v2(221.62,9.77) 220.99,10.4 218.91,10.4 218.19,9.69 214.24,9.69 v2(213.78,10.15) 212.42,11.5
  BOTTOM w0.135: 205.87,17.18 209.4,13.66 209.4,13.09 210.98,11.5 212.42,11.5
UG_DDR: length 5.8
  TOP w0.127: PQM1.1 94.37,33.19 v1(94.59,33.42)
  IN1 w0.508: v2(93.58,32.48) 93.58,31.39 92.97,30.78 92.05,30.78 91.25,29.98 v2(91.25,29.36)
UG_GT: length 7
  TOP w0.254: PUG1.8 116.95,93.9 116.79,93.75 v2(116.67,93.75)
  IN3 w0.508: v2(113.87,90.11) 115.11,90.11 116.67,91.67 v2(116.67,93.75)
  BOTTOM w0.508: v2(113.87,90.11) PQG1.1
UG_PH1: length 2.5
  IN3 w0.508: v2(151.27,133.25) 151.15,133.25 v2(150,132.1)
  BOTTOM w0.508: v2(150,132.1) 150.2,131.91 PQZ1.1
UG_PH2: length 2.5
  IN3 w0.508: v2(142.38,132.1) 143.53,133.25 v2(143.65,133.25)
  BOTTOM w0.508: v2(142.38,132.1) 142.58,131.91 PQZ2.1
UG_PH3: length 2.6
  IN3 w0.508: v2(136.03,133.25) 135.84,133.25 v2(134.73,132.13)
  BOTTOM w0.508: v2(134.73,132.13) 134.96,131.91 PQZ3.1
UG_PH4: length 2.5
  IN3 w0.508: v2(128.67,133.25) 128.54,133.25 v2(127.4,132.1)
  BOTTOM w0.508: v2(127.4,132.1) 127.59,131.91 PQZ4.1
UG_VCCSA: length 2
  TOP w0.127: PRA2.2 159.59,131.99 v1(159.4,132.18)
  TOP w0.508: v2(159.06,130.45) 159.09,130.45 159.59,130.96 PRA2.2
UG_VCCSA_R: length 8.5
  TOP w0.508: v2(158.58,128.67) 159.59,129.69 PRA2.1
  IN3 w0.508: v2(158.58,128.67) 158.58,127.9 158.07,127.39 158.07,125.06 v2(156.73,123.72)
  BOTTOM w0.127: v2(158.58,128.67) 158.7,128.67 v1(159.06,129.03)
  BOTTOM w0.508: PQA1.1 v2(156.73,123.72)
USB2_RCOMP: length 3.9
  TOP w0.127: v1(214.48,35.96) 214.48,37.25 213.86,37.87 RH8.1
  TOP w0.508: RH8.1 212.96,37.87 v2(212.78,38.05)
  BOTTOM w0.254: UH1.F4 v2(212.78,38.05)
USB3_DPE_MRX_C_DTX_N1: length 22.1
  TOP w0.127: CT320.1 26.09,52.54 25.59,52.54 RT1112.1 25.3,52.52 23.61,52.52 v2(23.43,52.33)
  BOTTOM w0.127: JUSBC1.B10 5.72,54.37 10.29,54.37 11.12,53.55 12.54,53.55 13.36,52.72 13.62,52.72 13.71,52.63 DU2.4 DU2.7 15.6,52.63 15.7,52.72 22.28,52.72 22.5,52.51 23.25,52.51 v2(23.43,52.33)
USB3_DPE_MRX_C_DTX_N2: length 22.5
  TOP w0.127: CT322.1 26.89,48.56 26.66,48.56 RT1114.1 26.3,48.56 24.09,48.56 21.28,51.37 v4(20.44,51.37) 19.93,51.37 19.52,50.96 16.59,50.96 15.98,51.57 15.65,51.57 15.56,51.66 DU1.7 DU1.4 13.68,51.66 13.59,51.57 13.27,51.57 12.88,51.18 12.88,50.61 12.57,50.31 9.39,50.31 9.13,50.57 7.9,50.57 7.78,50.69 JUSBC1.A10
USB3_DPE_MRX_C_DTX_P1: length 22.1
  TOP w0.127: CT319.1 26.13,52.86 25.55,52.86 RT1111.1 25.3,52.83 23.64,52.83 v2(23.43,53.04)
  BOTTOM w0.127: v2(23.43,53.04) 23.21,52.83 22.62,52.83 22.41,53.04 15.65,53.04 15.55,53.13 DU2.6 DU2.5 13.74,53.13 13.64,53.04 13.5,53.04 12.67,53.87 11.25,53.87 10.42,54.69 5.74,54.69 JUSBC1.B11
USB3_DPE_MRX_C_DTX_P2: length 22.4
  TOP w0.127: CT321.1 26.92,48.25 26.62,48.25 RT1113.1 26.34,48.25 23.95,48.25 21.15,51.05 20.06,51.05 19.65,50.65 v4(17.09,50.65) 16.46,50.65 15.85,51.25 15.68,51.25 15.59,51.16 DU1.6 DU1.5 13.67,51.16 13.58,51.25 13.4,51.25 13.2,51.05 13.2,50.48 12.71,49.99 9.26,49.99 9,50.25 7.89,50.25 7.83,50.19 JUSBC1.A11
USB3_DPE_MRX_DTX_N1: length 2.8
  TOP w0.127: UT11.31 28.85,52.38 28.81,52.42 28.36,52.42 28.24,52.54 v4(27.88,52.54) 27.03,52.54 CT320.2
USB3_DPE_MRX_DTX_N2: length 2.2
  TOP w0.127: CT322.2 27.79,48.6 28.04,48.6 28.58,49.14 29,49.14 29.04,49.18 UT11.39
USB3_DPE_MRX_DTX_P1: length 2.8
  TOP w0.127: UT11.30 28.85,52.78 28.81,52.74 28.5,52.74 28.37,52.86 26.99,52.86 CT319.2
USB3_DPE_MRX_DTX_P2: length 2.2
  TOP w0.127: CT321.2 27.83,48.28 28.17,48.28 28.71,48.82 28.97,48.82 29.01,48.78 UT11.40
USB3_DPE_MTX_C_DRX_N1: length 21.2
  TOP w0.127: JUSBC1.A3 7.74,54.19 7.82,54.26 8.21,54.26 8.38,54.43 v4(9.5,54.43) 11.59,54.43 13.29,52.73 13.59,52.73 13.66,52.66 DU1.2 DU1.9 15.57,52.66 15.66,52.75 21.82,52.75 23.8,50.77 25.52,50.77 26.07,51.32 26.56,51.32 CT280.1
USB3_DPE_MTX_C_DRX_N2: length 23.3
  TOP w0.127: CT282.1 26.56,50.38 26.14,50.38 25.99,50.23 23.6,50.23 21.61,52.22 19.4,52.22 19.12,51.94 17.75,51.94 v2(17.56,52.14)
  BOTTOM w0.127: JUSBC1.B3 5.74,50.49 12.1,50.49 13.13,51.53 13.54,51.53 13.65,51.63 DU2.2 DU2.9 15.53,51.63 15.62,51.54 16.07,51.54 16.47,51.94 17.36,51.94 v2(17.56,52.14)
USB3_DPE_MTX_C_DRX_P1: length 21.2
  TOP w0.127: JUSBC1.A2 7.75,54.69 7.85,54.58 8.08,54.58 8.25,54.75 v4(11.1,54.75) 11.72,54.75 13.43,53.05 13.59,53.05 13.71,53.16 DU1.1 DU1.10 15.61,53.16 15.7,53.07 21.95,53.07 23.93,51.09 25.39,51.09 25.94,51.64 26.59,51.64 CT279.1
USB3_DPE_MTX_C_DRX_P2: length 23.2
  TOP w0.127: v2(17.56,51.43) 17.75,51.62 19.25,51.62 19.53,51.9 21.48,51.9 23.47,49.91 26.12,49.91 26.27,50.06 26.59,50.06 CT281.1
  BOTTOM w0.127: JUSBC1.B2 5.73,50.18 12.23,50.18 13.26,51.21 13.54,51.21 13.62,51.13 DU2.1 DU2.10 15.63,51.13 15.72,51.22 16.2,51.22 16.6,51.62 17.36,51.62 v2(17.56,51.43)
USB3_DPE_MTX_DRX_N1: length 2.3
  TOP w0.127: CT280.2 27.49,51.32 27.77,51.32 27.87,51.22 v4(28.28,51.22) 28.81,51.22 28.85,51.18 UT11.34
USB3_DPE_MTX_DRX_N2: length 2.3
  TOP w0.127: UT11.36 28.92,50.38 28.84,50.3 28.23,50.3 28.12,50.4 27.47,50.4 CT282.2
USB3_DPE_MTX_DRX_P1: length 2.3
  TOP w0.127: CT279.2 27.46,51.64 27.9,51.64 28,51.54 28.81,51.54 28.85,51.58 UT11.33
USB3_DPE_MTX_DRX_P2: length 2.3
  TOP w0.127: CT281.2 27.48,50.09 27.99,50.09 28.1,49.98 UT11.37
USB3_PRX_C_MTX_N4: length 2.3
  TOP w0.127: UT11.4 31.35,47.35 31.43,47.28 31.43,45.83 CT286.1
USB3_PRX_C_MTX_P4: length 2.3
  TOP w0.127: UT11.5 31.75,47.35 31.68,47.28 v4(31.68,46.66) 31.68,45.95 CT285.1
USB3_PRX_DTX_N1: length 313.9
  IN3 w0.127: v2(209.36,41.48) 208.81,41.48 208.68,41.61 208.68,41.78 208.81,41.9 210.13,41.9 210.3,41.73 212.98,41.73 213.13,41.88 218.37,41.88 222.47,37.79 222.47,32.5 220.29,30.32 220.29,15.9 219.96,15.57 219.96,14.57 219.53,14.15 218.35,14.15 215.06,10.86 214.75,10.86 214.28,10.39 214.28,9.81 213.93,9.46 210.66,9.46 208.39,7.19 205.39,7.19 205.25,7.33 199.37,7.33 199.05,7 189.8,7 188.71,8.1 177.69,8.1 176.18,9.61 169.87,9.61 167.79,11.69 156.33,11.69 153.77,9.14 153.77,8.42 152.6,7.25 135.87,7.25 134.9,6.27 130.81,6.27 129.47,7.62 123.19,7.62 122.7,7.13 93.14,7.13 90.39,9.87 88.64,9.87 87.29,11.22 85.31,11.22 84.72,11.82 83.61,11.82 80.2,15.23 74.03,15.23 72.84,16.42 66.8,16.42 63.16,20.06 63.16,20.27 61.83,21.6 61.83,24.98 60.47,26.34 57.75,26.34 54.53,29.56 54.53,30.77 54.69,30.94 54.69,35.25 53.46,36.48 53.46,37.75 53.17,38.04 53.17,39.43 51.26,41.33 51.26,43.92 49.72,45.46 47.45,45.46 46.2,46.71 44.88,46.71 43.15,48.44 43.15,49.95 42.32,51.02 39.79,52.7 38.36,53.77 36.52,55.2 32.06,55.2 30.05,57.21 29.28,57.21 28.59,57.9 28.59,63.58 27.49,64.68 24.29,64.68 24.01,64.96 24.01,65.41 21.66,67.76 21.22,67.76 20.54,68.43 20.54,69.31 21.2,69.96 21.2,73.34 20.4,74.13 20.4,79.15 21.22,79.96 21.22,87.48 21.42,87.68 21.57,87.68 21.74,87.51 v2(21.74,87.36)
  BOTTOM w0.089: UH1.D11 209.51,39.04 209.51,39.06 209.51,39.43 209.34,39.6 209.34,40.79 208.97,41.16 208.97,41.59 209.06,41.68 209.19,41.68 209.36,41.5 v2(209.36,41.48)
  BOTTOM w0.127: RS34.1 20.44,88.08 20.86,88.08 21.33,87.61 21.49,87.61 v2(21.74,87.36)
USB3_PRX_DTX_N2: length 108.6
  IN1 w0.135: v2(307.23,39.65) 306.94,39.94 306.94,40.11 306.61,40.43 288.41,40.43 287.67,39.7 277.29,39.7 276.26,38.66 272.18,38.66 271.55,39.29 262.62,39.29 261.87,38.55 260.58,38.55 259.83,39.29 257.59,39.29 257.36,39.52 255.35,39.52 254.58,40.28 254.14,40.28 253.41,41.01 252.83,41.01 252.43,41.41 248.42,41.41 248.29,41.55 244.69,41.55 244.13,40.99 243.16,40.99 242.02,39.84 239.21,39.84 238.88,40.17 236.32,40.17 236.15,40.34 234.8,40.34 234.32,39.86 232.59,39.86 231.69,38.97 221.39,38.97 218.54,41.81 213.84,41.81 213.75,41.9 211.47,41.9 211.28,42.08 211.28,42.29 211.41,42.42 v2(211.47,42.42)
  BOTTOM w0.089: UH1.B9 210.28,39.65 210.35,39.59 210.45,39.59 210.5,39.64 210.5,39.95 210.39,40.05 210.39,40.12 210.56,40.29 210.56,40.54 210.78,40.76 210.78,41.38 211.23,41.83 211.23,42.18 v2(211.47,42.42)
  BOTTOM w0.127: v2(307.23,39.65) 307,39.65 306.87,39.51 306.87,39.27 307.04,39.09 307.32,39.09 307.73,39.51 308.19,39.51 308.44,39.75 JIO1.13
USB3_PRX_DTX_N3: length 116.3
  IN1 w0.135: v2(307.61,36.89) 307.46,36.74 307.27,36.74 307.12,36.9 307.12,37.36 307.55,37.8 308.25,37.8 308.76,38.3 308.76,40.47 307.93,41.3 293.53,41.3 292.95,41.87 288.42,41.87 287.19,40.64 274.54,40.64 273.91,40.01 262.32,40.01 261.57,39.27 260.88,39.27 260.13,40.01 257.89,40.01 257.24,40.66 255.22,40.66 254.88,41 254.43,41 253.3,42.13 248.72,42.13 247.95,42.9 245.03,42.9 243.91,41.79 242.25,41.79 241.66,41.2 239.6,41.2 239.42,41.01 236.64,41.01 236.46,41.2 234.4,41.2 233.78,40.58 232.28,40.58 231.38,39.69 221.84,39.69 218.71,42.81 215.91,42.81 215.62,42.53 214.51,42.53 213.92,43.11 212.44,43.11 212.03,43.52 211.83,43.52 211.62,43.73 210.71,43.73 210,43.02 210,42.93 v2(209.77,42.7)
  BOTTOM w0.089: v2(209.77,42.7) 210.11,42.36 210.11,41.7 210.06,41.65 209.9,41.65 209.81,41.56 209.81,41.46 209.9,41.37 210.05,41.37 210.11,41.31 210.11,40.88 209.99,40.75 209.99,40.53 209.67,40.21 209.67,39.75 UH1.B10
  BOTTOM w0.127: JIO1.19 308.27,36.75 308.1,36.58 307.92,36.58 v2(307.61,36.89)
USB3_PRX_DTX_P1: length 313.9
  IN3 w0.127: v2(209.32,42.32) 209.48,42.16 210.24,42.16 210.41,41.99 212.88,41.99 213.02,42.14 218.48,42.14 222.72,37.89 222.72,32.39 220.54,30.21 220.54,15.79 220.21,15.46 220.21,14.47 219.64,13.89 218.45,13.89 215.16,10.6 214.86,10.6 214.54,10.28 214.54,9.71 214.04,9.2 210.77,9.2 208.49,6.93 205.28,6.93 205.14,7.07 199.48,7.07 199.15,6.75 189.69,6.75 188.6,7.84 177.59,7.84 176.07,9.36 169.77,9.36 167.69,11.44 156.43,11.44 154.03,9.03 154.03,8.32 152.71,6.99 135.98,6.99 135,6.02 130.71,6.02 129.36,7.36 123.3,7.36 122.81,6.87 93.03,6.87 90.29,9.62 88.53,9.62 87.19,10.96 85.21,10.96 84.61,11.56 83.5,11.56 80.09,14.97 73.92,14.97 72.73,16.16 66.69,16.16 62.9,19.95 62.9,20.16 61.57,21.49 61.57,24.87 60.36,26.08 57.65,26.08 54.27,29.46 54.27,30.88 54.44,31.05 54.44,35.14 53.21,36.37 53.21,37.64 52.91,37.94 52.91,39.32 51.01,41.23 51.01,43.81 49.61,45.21 47.35,45.21 46.1,46.46 44.77,46.46 42.89,48.34 42.89,49.87 42.14,50.83 39.65,52.49 38.2,53.56 36.43,54.95 31.95,54.95 29.94,56.95 29.17,56.95 28.33,57.8 28.33,63.47 27.38,64.43 24.18,64.43 23.76,64.85 23.76,65.3 21.56,67.5 21.11,67.5 20.28,68.33 20.28,69.41 20.94,70.07 20.94,73.23 20.14,74.03 20.14,79.25 20.96,80.07 20.96,87.59 21.31,87.94 21.6,87.94 v2(21.74,88.07)
  BOTTOM w0.089: v2(209.32,42.32) 209.42,42.22 209.42,42.04 209.25,41.87 208.98,41.87 208.78,41.67 208.78,41.08 209.15,40.71 209.15,39.52 209.26,39.41 UH1.C11
  BOTTOM w0.127: v2(21.74,88.07) 21.53,87.87 21.44,87.87 20.97,88.34 20.47,88.34 RS32.1
USB3_PRX_DTX_P2: length 108.6
  IN1 w0.135: v2(306.47,39.65) 306.66,39.84 306.66,40 306.5,40.16 288.52,40.16 287.79,39.42 277.41,39.42 276.37,38.38 272.07,38.38 271.44,39.01 262.73,39.01 261.99,38.27 260.46,38.27 259.71,39.01 257.47,39.01 257.25,39.24 255.23,39.24 254.47,40 254.02,40 253.29,40.73 252.72,40.73 252.31,41.14 248.31,41.14 248.17,41.27 244.81,41.27 244.24,40.71 243.28,40.71 242.13,39.56 239.09,39.56 238.76,39.89 236.21,39.89 236.04,40.06 234.91,40.06 234.43,39.58 232.7,39.58 231.81,38.69 221.27,38.69 218.43,41.53 213.72,41.53 213.63,41.62 211.35,41.62 211.01,41.96 211.01,42.29 v2(210.88,42.42)
  BOTTOM w0.089: UH1.C9 210.06,39.64 210.06,40.06 210.37,40.37 210.37,40.62 210.59,40.84 210.59,41.46 211.04,41.91 211.04,42.26 v2(210.88,42.42)
  BOTTOM w0.127: JIO1.14 307.84,39.25 307.42,38.84 306.93,38.84 306.61,39.16 306.61,39.51 v2(306.47,39.65)
USB3_PRX_DTX_P3: length 116.3
  IN1 w0.135: v2(210.36,42.7) 210.28,42.78 210.28,42.9 210.82,43.45 211.51,43.45 211.71,43.24 211.92,43.24 212.32,42.83 213.8,42.83 214.39,42.25 215.74,42.25 216.02,42.53 218.59,42.53 221.72,39.41 231.5,39.41 232.39,40.3 233.9,40.3 234.51,40.92 236.35,40.92 236.53,40.73 239.53,40.73 239.72,40.92 241.78,40.92 242.37,41.51 244.03,41.51 245.14,42.62 247.84,42.62 248.6,41.85 253.18,41.85 254.32,40.72 254.76,40.72 255.11,40.38 257.12,40.38 257.77,39.73 260.01,39.73 260.76,38.99 261.69,38.99 262.44,39.73 274.03,39.73 274.66,40.36 287.31,40.36 288.54,41.59 292.84,41.59 293.41,41.02 307.82,41.02 308.48,40.35 308.48,38.42 308.14,38.08 307.44,38.08 306.84,37.48 306.84,36.78 307.15,36.46 307.68,36.46 307.8,36.35 307.8,36.24 v2(307.62,36.05)
  BOTTOM w0.089: UH1.C10 209.86,39.24 209.86,40.13 210.18,40.45 210.18,40.68 210.3,40.8 210.3,42.65 v2(210.36,42.7)
  BOTTOM w0.127: v2(307.62,36.05) 307.89,36.32 308.21,36.32 308.28,36.25 JIO1.20
USB3_PRX_MTX_N4: length 288.8
  TOP w0.127: v2(36.43,46.82) 36.12,46.82 35.87,46.58 35.87,44.67 35.15,43.95 32.09,43.95 v4(31.74,44.3) 31.43,44.61 31.43,45.04 CT286.2
  IN3 w0.127: v2(36.43,46.82) 36.43,46.99 36.55,47.11 36.7,47.11 37.09,46.72 37.09,45.96 39.32,43.72 39.32,40.21 40.9,38.63 42.17,38.63 42.96,37.84 49.86,37.84 50.55,37.14 50.55,36.09 50.89,35.75 50.89,35.53 52.21,34.22 52.21,31.97 51.92,31.69 51.92,28.35 55.53,24.74 55.53,22.88 56.15,22.27 57.66,22.27 58.12,21.8 58.12,20.88 65.46,13.54 72.14,13.54 73.35,12.33 76.92,12.33 78.58,10.67 80.99,10.67 84.69,6.97 88.23,6.97 90.56,4.64 138.87,4.64 139.84,5.61 153.48,5.61 155.56,7.7 155.56,8.61 156.99,10.04 166.89,10.04 168.35,8.58 168.35,7.67 169.67,6.35 169.67,5.92 170.45,5.14 214.34,5.14 215.72,6.52 215.72,8.26 216.12,8.66 217.33,8.66 218.81,10.13 219.14,10.13 221.06,12.04 221.74,12.04 222.79,13.1 222.79,16.32 221.92,17.19 221.92,29.64 224.51,32.23 224.51,35.22 224.1,35.63 224.1,39.71 218.56,45.25 209.24,45.25 206.17,42.17 206.17,41.65 205.69,41.18 205.69,39.96 206.4,39.25 206.4,36.82 206.12,36.54 206.12,35.98 206.25,35.86 v2(206.25,35.63)
  BOTTOM w0.089: v2(206.25,35.63) 206.25,35.63 206.97,35.63 UH1.K16
USB3_PRX_MTX_P4: length 288.8
  TOP w0.127: v2(35.87,47.63) 35.9,47.67 36.08,47.67 36.24,47.5 36.24,47.32 35.61,46.69 35.61,44.77 35.04,44.2 v4(33.18,44.2) 32.2,44.2 32.02,44.39 31.93,44.48 31.69,44.72 31.69,44.93 CT285.2
  IN3 w0.127: v2(35.87,47.63) 35.67,47.44 35.67,47.18 35.84,47.01 36.02,47.01 36.38,47.37 36.8,47.37 37.34,46.83 37.34,46.07 39.58,43.83 39.58,40.31 41.01,38.89 42.27,38.89 43.07,38.1 49.96,38.1 50.81,37.25 50.81,36.2 51.15,35.86 51.15,35.64 52.46,34.32 52.46,31.87 52.18,31.58 52.18,28.46 55.79,24.85 55.79,22.99 56.25,22.53 57.76,22.53 58.38,21.91 58.38,20.98 65.56,13.8 72.24,13.8 73.46,12.58 77.02,12.58 78.68,10.92 81.1,10.92 84.79,7.23 88.34,7.23 90.67,4.9 138.76,4.9 139.74,5.87 153.37,5.87 155.3,7.8 155.3,8.72 156.88,10.3 166.99,10.3 168.61,8.68 168.61,7.77 169.92,6.46 169.92,6.03 170.56,5.4 214.24,5.4 215.47,6.63 215.47,8.36 216.02,8.91 217.23,8.91 218.7,10.39 219.04,10.39 220.95,12.3 221.63,12.3 222.53,13.2 222.53,16.21 221.66,17.08 221.66,29.75 224.25,32.33 224.25,35.11 223.84,35.52 223.84,39.6 218.45,44.99 209.35,44.99 206.42,42.07 206.42,41.54 205.95,41.07 205.95,40.06 206.66,39.35 206.66,36.71 206.38,36.43 206.38,36.09 206.49,35.98 206.67,35.98 v2(206.73,36.03)
  BOTTOM w0.089: v2(206.73,36.03) 206.87,36.03 UH1.J15
USB3_PRX_R_DTX_N1: length 9.9
  BOTTOM w0.127: JUSB3.5 13.2,85.56 13.33,85.69 13.77,85.69 14.29,86.21 16.23,86.21 16.53,86.51 v4(16.53,86.85) 16.53,87.3 16.13,87.69 16.13,88.05 16.24,88.16 17.27,88.16 17.39,88.03 DS6.1 DS6.9 18.94,88.03 19.06,88.15 19.44,88.15 RS34.2
USB3_PRX_R_DTX_P1: length 9.9
  BOTTOM w0.127: RS32.2 19.55,88.41 19,88.41 18.87,88.53 DS6.8 DS6.2 17.39,88.53 17.27,88.41 v4(16.57,88.41) 16.13,88.41 15.88,88.16 15.88,87.59 16.27,87.19 16.27,86.67 16.07,86.47 14.19,86.47 13.67,85.95 13.34,85.95 13.2,86.09 JUSB3.6
USB3_PTX_C_DRX_N1: length 1
  BOTTOM w0.127: RS27.1 20.46,89.75 20.71,89.75 CS34.1
USB3_PTX_C_DRX_P1: length 1
  BOTTOM w0.127: RS28.1 20.46,90 20.71,90 CS29.1
USB3_PTX_C_MRX_N4: length 2.5
  TOP w0.127: UT11.7 32.55,47.46 32.63,47.38 32.63,47.15 v4(33.02,46.77) 33.48,46.3 33.48,46.07 CT288.1
USB3_PTX_C_MRX_P4: length 2.5
  TOP w0.127: CT287.1 33.74,46.03 33.74,46.41 33.2,46.95 32.89,47.26 32.89,47.38 32.95,47.45 UT11.8
USB3_PTX_DRX_N1: length 307.6
  IN3 w0.127: v2(210.37,37.38) 210.32,37.33 210.32,36.98 210.44,36.86 211.09,36.86 211.44,37.21 211.44,37.68 211.19,37.93 211.19,38.26 211.03,38.43 211.03,39.68 211.71,40.36 216.86,40.36 219.74,37.49 221.37,37.49 221.78,37.07 221.78,32.78 218.15,29.15 218.15,21.45 218.39,21.2 218.39,17.99 218.79,17.59 219.29,17.59 219.6,17.28 219.6,16.41 214.85,11.66 211.13,11.66 208.07,8.59 205.32,8.59 205.12,8.78 203.16,8.78 202.39,8.02 198.34,8.02 198.01,7.69 190.09,7.69 188.99,8.79 178.26,8.79 176.7,10.35 170.27,10.35 168.23,12.38 156.04,12.38 151.6,7.94 134.5,7.94 133.63,7.06 131.09,7.06 129.85,8.31 122.88,8.31 122.39,7.82 94.13,7.82 91.72,10.22 91.72,10.22 91.33,10.61 89.04,10.61 87.47,12.18 87.47,12.55 85.57,14.45 82.26,14.45 79.59,17.13 67.11,17.13 64.41,19.83 64.41,20.13 62.92,21.62 62.92,24.86 60.71,27.06 60.04,27.06 59.02,28.09 57.01,28.09 55.77,29.33 55.77,30.9 55.38,31.29 55.38,35.53 54.17,36.75 54.17,38.02 53.86,38.33 53.86,39.72 53.43,40.14 53.43,42.72 49.49,46.66 47.23,46.66 46.45,47.44 45.17,47.44 43.9,48.7 43.9,50.11 42.8,51.53 40.19,53.27 38.78,54.32 36.75,55.89 32.34,55.89 29.28,58.95 29.28,63.87 26.76,66.39 24.02,66.39 22.73,67.68 22.73,75.67 21.72,76.68 21.72,79.23 21.96,79.47 21.96,84.3 22.43,84.77 22.43,88.92 22.01,89.34 22.01,89.64 22.14,89.77 22.45,89.77 v2(22.7,89.52)
  BOTTOM w0.089: UH1.F9 210.59,37.75 210.49,37.45 v2(210.37,37.38)
  BOTTOM w0.127: CS34.2 22.25,89.74 22.48,89.74 v2(22.7,89.52)
USB3_PTX_DRX_N2: length 106.5
  IN1 w0.135: v2(213.06,38.61) 212.93,38.8 212.95,38.88 212.98,39.05 213.21,39.28 213.99,39.28 214.38,38.89 215.91,38.89 216.2,39.18 218.06,39.18 220.13,37.1 229.16,37.1 229.3,37.25 233.09,37.25 233.94,38.1 237.42,38.1 237.77,38.45 238.12,38.45 238.45,38.12 243.79,38.12 244.93,39.26 248.16,39.26 248.6,39.7 250.95,39.7 251.85,38.8 253,38.8 253.72,38.09 254.33,38.09 254.62,37.8 255.21,37.8 256.12,36.89 258.47,36.89 258.48,36.9 258.83,36.9 258.83,36.89 258.98,36.89 259.26,36.61 267.64,36.61 267.98,36.95 273.72,36.95 274.13,36.53 278.9,36.53 279.71,37.34 288.45,37.34 288.88,37.77 292.72,37.77 293.25,38.3 302.51,38.3 302.9,37.91 303.43,37.91 303.61,37.73 303.61,37.4 v2(303.53,37.33)
  BOTTOM w0.089: v2(213.06,38.61) 213.25,38.94 213.28,39.09 UH1.C3
  BOTTOM w0.127: v2(303.53,37.33) 303.37,37.49 303.24,37.49 302.85,37.88 302.85,39.18 304.2,40.54 307.56,40.54 308.27,41.25 JIO1.10
USB3_PTX_DRX_N3: length 111.8
  IN1 w0.135: v2(304.85,38.37) 304.53,38.05 304.53,37.86 304.71,37.67 304.9,37.67 305.54,38.31 305.54,38.62 304.9,39.26 292.94,39.26 292.23,38.55 288.65,38.55 288.16,38.06 279.41,38.06 278.6,37.25 274.55,37.25 274.13,37.66 267.68,37.66 267.35,37.33 259.76,37.33 258.8,38.3 257.17,38.3 256.95,38.52 254.92,38.52 254.63,38.81 254.01,38.81 252.84,39.99 252.36,39.99 251.93,40.42 248.2,40.42 247.77,39.99 243.8,39.99 243.46,39.64 243.46,39.29 243,38.84 238.75,38.84 238.41,39.17 237.16,39.17 236.81,38.82 233.64,38.82 232.79,37.97 220.95,37.97 218.6,40.31 212.71,40.31 212.52,40.5 210.98,40.5 209.07,38.59 209.07,37.71 209.32,37.47 209.58,37.47 209.82,37.71 v2(209.89,37.71)
  BOTTOM w0.127: v2(209.89,37.71) 209.72,37.54 209.47,37.54 209.37,37.65 UH1.F11 ; JIO1.16 308.25,38.25 308.12,38.12 306.45,38.12 305.94,38.63 305.47,38.63 305.21,38.37 v2(304.85,38.37)
USB3_PTX_DRX_P1: length 307.6
  IN3 w0.127: v2(22.7,90.23) 22.5,90.03 22.03,90.03 21.75,89.75 21.75,89.23 22.17,88.81 22.17,84.88 21.7,84.41 21.7,79.57 21.46,79.34 21.46,76.58 22.47,75.57 22.47,67.57 23.92,66.13 26.65,66.13 29.02,63.76 29.02,58.85 32.24,55.63 36.66,55.63 38.62,54.11 40.04,53.06 42.62,51.34 43.64,50.02 43.64,48.6 45.06,47.18 46.35,47.18 47.12,46.4 49.39,46.4 53.18,42.61 53.18,40.03 53.6,39.61 53.6,38.22 53.91,37.91 53.91,36.64 55.13,35.43 55.13,31.18 55.51,30.8 55.51,29.22 56.9,27.83 58.91,27.83 59.94,26.81 60.61,26.81 62.67,24.75 62.67,21.51 64.15,20.02 64.15,19.72 67,16.87 79.48,16.87 82.16,14.2 85.46,14.2 87.22,12.44 87.22,12.08 88.94,10.36 91.22,10.36 91.61,9.97 94.02,7.56 122.5,7.56 122.99,8.05 129.74,8.05 130.99,6.8 133.73,6.8 134.61,7.68 151.7,7.68 156.15,12.13 168.13,12.13 170.16,10.1 176.59,10.1 178.16,8.53 188.88,8.53 189.98,7.43 198.11,7.43 198.44,7.76 202.5,7.76 203.26,8.53 205.02,8.53 205.21,8.34 208.18,8.34 211.24,11.4 214.96,11.4 219.86,16.3 219.86,17.39 219.39,17.85 218.9,17.85 218.65,18.1 218.65,21.31 218.41,21.55 218.41,29.05 222.04,32.68 222.04,37.18 221.47,37.74 219.84,37.74 216.97,40.62 211.61,40.62 210.77,39.79 210.77,38.32 210.94,38.16 210.94,37.82 211,37.76 211,37.54 v2(210.98,37.52)
  BOTTOM w0.089: v2(210.98,37.52) UH1.F7
  BOTTOM w0.127: v2(22.7,90.23) 22.47,90 22.27,90 CS29.2
USB3_PTX_DRX_P2: length 106.5
  IN1 w0.135: v2(212.48,38.73) 212.65,38.84 212.72,39.19 213.09,39.56 214.1,39.56 214.5,39.16 215.8,39.16 216.09,39.45 218.17,39.45 220.25,37.38 229.04,37.38 229.19,37.53 232.97,37.53 233.82,38.38 237.3,38.38 237.65,38.73 238.23,38.73 238.57,38.4 243.68,38.4 244.82,39.54 248.05,39.54 248.49,39.98 251.06,39.98 251.96,39.08 253.12,39.08 253.83,38.37 254.45,38.37 254.74,38.08 255.33,38.08 256.24,37.17 258.36,37.17 258.36,37.17 258.94,37.17 258.95,37.17 259.1,37.17 259.38,36.89 267.53,36.89 267.86,37.22 273.83,37.22 274.25,36.81 278.79,36.81 279.6,37.62 288.34,37.62 288.77,38.05 292.6,38.05 293.13,38.58 302.62,38.58 303.02,38.19 303.74,38.19 v2(303.77,38.22)
  BOTTOM w0.089: UH1.D4 212.92,39.14 212.71,39.14 212.65,39.09 212.58,39.02 212.52,39.02 212.44,38.94 212.44,38.77 v2(212.48,38.73)
  BOTTOM w0.127: JIO1.11 308.14,40.75 307.67,40.28 304.31,40.28 303.1,39.08 303.1,37.99 303.34,37.74 303.87,37.74 303.99,37.87 303.99,38.01 v2(303.77,38.22)
USB3_PTX_DRX_P3: length 111.8
  IN1 w0.135: v2(305.52,37.68) 305.52,37.9 305.82,38.2 305.82,38.74 305.02,39.54 292.82,39.54 292.12,38.83 288.54,38.83 288.04,38.34 279.3,38.34 278.49,37.52 274.67,37.52 274.25,37.94 267.56,37.94 267.23,37.61 259.88,37.61 258.91,38.58 257.29,38.58 257.06,38.8 255.04,38.8 254.75,39.09 254.13,39.09 252.95,40.27 252.47,40.27 252.04,40.7 248.09,40.7 247.66,40.27 243.69,40.27 243.18,39.76 243.18,39.41 242.88,39.11 238.86,39.11 238.53,39.45 237.04,39.45 236.69,39.1 233.53,39.1 232.67,38.25 221.06,38.25 218.72,40.59 212.82,40.59 212.64,40.78 210.87,40.78 208.8,38.71 208.8,37.59 209.2,37.19 209.79,37.19 v2(209.85,37.13)
  BOTTOM w0.127: v2(209.85,37.13) 209.09,37.13 UH1.G12 ; v2(305.52,37.68) 305.39,37.81 305.39,38.19 305.58,38.38 305.83,38.38 306.34,37.87 v4(307.31,37.87) 308.13,37.87 308.25,37.75 JIO1.17
USB3_PTX_MRX_N4: length 275.9
  TOP w0.127: v2(34.63,47.52) 34.39,47.28 34.39,47.1 35.08,46.41 35.08,45.19 v4(34.82,44.92) 34.54,44.64 33.66,44.64 33.44,44.86 33.44,45.15 CT288.2
  IN3 w0.127: v2(207.02,41.07) 207.46,41.07 207.57,41.18 207.57,42.27 209.51,44.21 217.9,44.21 223.41,38.7 223.41,35.34 223.82,34.94 223.82,32.51 221.23,29.93 221.23,16.9 222.1,16.03 222.1,13.38 221.45,12.73 219.99,12.73 218.39,11.14 218.39,10.73 217.11,9.45 215.94,9.45 214.92,8.42 214.92,7.03 213.82,5.93 178.41,5.93 176.48,7.86 170.11,7.86 167.22,10.75 156.72,10.75 154.83,8.86 154.83,8.08 153.06,6.3 136.51,6.3 135.53,5.33 90.96,5.33 88.44,7.85 88.01,7.85 86.59,9.27 83.61,9.27 81.33,11.55 79.66,11.55 78.15,13.06 73.65,13.06 72.47,14.24 65.74,14.24 61.36,18.62 61.36,19.52 60.02,20.87 60.02,22.11 59.31,22.81 58.73,22.81 52.61,28.93 52.61,31.4 52.9,31.69 52.9,34.5 51.67,35.73 51.67,37 49.64,39.03 44.48,39.03 42.64,40.87 42.64,41.69 40.48,43.84 40.48,44.63 40.17,44.94 39.84,44.94 36.44,48.35 35.45,48.35 v2(34.63,47.52)
  BOTTOM w0.102: v2(207.02,41.07) 207.02,41 207.18,40.83 207.5,40.83 207.75,40.58 207.75,40.09 207.87,39.97 207.87,39.79 207.94,39.72 208.02,39.72 UH1.B14
USB3_PTX_MRX_P4: length 275.9
  TOP w0.127: CT287.2 33.69,45.1 33.69,44.97 33.77,44.89 34.43,44.89 34.83,45.29 34.83,46.3 v4(34.56,46.57) 34.12,47.01 34.12,47.61 34.43,47.92 v2(34.43,48.35)
  IN3 w0.127: v2(34.43,48.35) 34.26,48.19 34.26,48.01 34.33,47.94 34.68,47.94 35.34,48.6 36.54,48.6 39.95,45.2 40.27,45.2 40.74,44.73 40.74,43.95 42.89,41.79 42.89,40.98 44.59,39.28 49.75,39.28 51.92,37.11 51.92,35.84 53.15,34.61 53.15,31.58 52.87,31.3 52.87,29.04 58.84,23.07 59.42,23.07 60.27,22.21 60.27,20.97 61.62,19.63 61.62,18.73 65.84,14.5 72.57,14.5 73.75,13.32 78.25,13.32 79.76,11.81 81.44,11.81 83.71,9.53 86.69,9.53 88.12,8.11 88.54,8.11 91.06,5.59 135.43,5.59 136.4,6.56 152.95,6.56 154.58,8.18 154.58,8.97 156.61,11.01 167.32,11.01 170.21,8.12 176.58,8.12 178.51,6.19 213.71,6.19 214.66,7.14 214.66,8.53 215.83,9.7 217,9.7 218.14,10.84 218.14,11.24 219.88,12.99 221.34,12.99 221.84,13.49 221.84,15.93 220.98,16.8 220.98,30.03 223.56,32.62 223.56,34.83 223.16,35.24 223.16,38.59 217.8,43.95 209.62,43.95 207.83,42.17 207.83,41.07 207.57,40.81 207.35,40.81 207.03,40.48 v2(207.02,40.48)
  BOTTOM w0.102: v2(207.02,40.48) 207.16,40.63 207.41,40.63 207.55,40.5 207.55,40.01 207.67,39.89 207.67,39.7 UH1.C14
USB3_PTX_R_DRX_N1: length 9
  BOTTOM w0.127: JUSB3.8 13.2,91.41 13.49,91.7 13.82,91.7 14.24,91.27 15.17,91.27 15.33,91.42 16.09,91.42 16.46,91.05 16.46,90.82 16.3,90.66 16.3,90.19 v4(16.56,89.93) 16.84,89.66 17.36,89.66 17.48,89.53 DS6.4 DS6.7 18.9,89.53 19.05,89.69 19.55,89.69 RS27.2
USB3_PTX_R_DRX_P1: length 9.1
  BOTTOM w0.127: RS28.2 19.44,89.95 19.03,89.95 18.94,90.03 DS6.6 DS6.5 17.46,90.03 17.34,89.91 16.94,89.91 16.55,90.3 16.55,90.55 16.72,90.71 16.72,91.16 v4(16.46,91.41) 16.2,91.68 15.22,91.68 15.07,91.53 14.35,91.53 13.92,91.95 13.55,91.95 13.2,92.31 JUSB3.9
USB20_N1: length 269.1
  IN3 w0.127: v2(24.52,74.32) 24.81,74.32 24.91,74.22 24.91,73.87 25.38,73.41 25.38,70.87 28.24,68.01 28.24,65.99 30.55,63.68 30.55,61.07 32.9,58.72 32.9,57.57 33.82,56.65 36.28,56.65 37.01,56.65 39.24,54.93 40.63,53.89 42.46,52.68 44.43,51.42 45.02,51.09 47.19,50.09 49.04,48.24 49.97,48.24 53.23,44.98 54.43,44.98 55.9,43.51 55.9,41.59 56.18,41.31 56.18,36.87 57.37,35.67 57.37,31.17 58.56,29.98 61.2,29.98 63.65,27.53 64.31,27.53 66.95,24.89 66.95,23.24 67.74,22.45 70.08,22.45 73.19,19.34 80.47,19.34 83.16,16.64 88.88,16.64 94.7,10.82 99.09,10.82 99.96,9.96 108.3,9.96 109.05,10.71 114.61,10.71 114.67,10.65 117.43,10.65 117.66,10.88 134.98,10.88 135.33,10.53 150.14,10.53 152.4,12.79 153.42,12.79 155.2,14.57 172.04,14.57 174.02,12.6 177.48,12.6 179.15,10.93 191.14,10.93 191.46,10.6 201.94,10.6 202.95,11.61 203.58,11.61 205.28,13.31 208.79,13.31 210.73,15.25 210.73,16.1 212.14,17.51 212.44,17.51 214.04,19.11 214.04,20.24 213.55,20.73 213.55,22.91 213.8,23.16 213.8,26.72 214.57,27.48 215.63,27.48 216,27.86 216,31.52 215.37,32.16 215.37,34.2 214.99,34.58 214.99,37.47 v2(214.78,37.67)
  BOTTOM w0.089: v2(214.78,37.67) 214.86,37.59 214.86,37.22 214.27,36.63 213.57,36.63 213.31,36.38 UH1.J3
  BOTTOM w0.127: v2(24.52,74.32) 24.37,74.32 24.25,74.19 24.25,73.95 24.16,73.86 23.85,73.86 23.46,73.48 20.89,73.48 20.33,74.04 20.31,74.06 19.78,74.58 19.78,77.92 20.03,78.16 US2.2
USB20_N1_C: length 11.8
  TOP w0.127: JUSB3.2 14.7,89.15 14.92,88.93 15.18,88.93 15.65,88.47 16.28,88.47 16.38,88.57 16.38,88.84 16.13,89.09 16.13,89.44 v4(16.44,89.75) 16.7,90.01 17.07,90.01 17.36,89.72 17.36,89.01 17.43,88.93 17.61,88.93 DS5.2 18.44,89.27 18.61,89.1 18.92,89.1 20.02,88 20.02,87.68 20.39,87.31 20.39,86.5 LS9.3
USB20_N2: length 113
  IN1 w0.076: v2(207.83,35.09) 207.6,35.09 207.47,34.96 207.47,34.75 207.58,34.64 210.23,34.64 210.33,34.54 210.57,34.54 210.63,34.59 210.65,34.59
  IN1 w0.135: v2(302.1,33.66) 302.25,33.81 302.54,33.81 302.69,33.66 302.69,33.41 302.48,33.2 294.67,33.2 291.28,29.81 267.02,29.81 265.09,31.74 258.49,31.74 254.92,35.31 254.17,35.31 253.77,35.72 251.64,35.72 251.21,36.15 234.75,36.15 233.9,35.3 230.11,35.3 229.48,34.66 222.94,34.66 221.8,33.52 221.8,32.51 220.38,31.09 217.32,31.09 215.7,32.71 214.27,32.71 213.05,33.93 212.69,33.93 212.03,34.59 210.65,34.59
  BOTTOM w0.089: UH1.N13 v2(207.83,35.09)
  BOTTOM w0.127: v2(302.1,33.66) 302.25,33.81 304.88,33.81 305.96,34.89 308.14,34.89 308.28,34.75 JIO1.23
USB20_N3: length 105.4
  IN1 w0.135: v2(306.49,33.21) 306.65,33.36 307.03,33.36 307.33,33.65 307.33,34.49 305.66,36.15 302.95,36.15 301.9,37.21 289.14,37.21 288.76,36.82 279.93,36.82 279.12,36.01 273.81,36.01 273.39,36.43 268.19,36.43 267.79,36.03 256.26,36.03 255.13,37.16 252.24,37.16 251.71,37.69 246.14,37.69 245.66,38.17 244.64,38.17 244.06,37.59 234.15,37.59 233.3,36.73 229.52,36.73 229.23,36.44 219.82,36.44 217.61,38.66 216.42,38.66 215.98,38.22 v2(215.73,38.22)
  BOTTOM w0.089: v2(215.73,38.22) 215.92,38.03 215.92,37.87 215.79,37.74 215.79,37.5 215.09,36.8 215,36.8 214.18,35.98 213.41,35.98 213.3,36.09 212.9,36.09 212.6,35.8 UH1.K4
  BOTTOM w0.127: JIO1.26 307.43,33.25 307.19,33.49 306.78,33.49 v2(306.49,33.21)
USB20_N4: length 280
  TOP w0.127: v2(44.93,48.55) 44.75,48.55 44.66,48.46 44.66,48.24 44.81,48.09 45.1,48.09 45.54,47.64 UU4.53 ; v2(20.98,50) 20.66,49.68 20.31,49.68 19.97,49.34 17.97,49.34 ML11.4
  IN1 w0.135: v2(20.98,50) 20.98,49.71 21.08,49.62 21.28,49.62 21.51,49.85 21.51,52.34 23.36,54.19 24.07,54.19 25.02,55.14 34.37,55.14 36.46,53.05 38.35,53.05 39.09,52.5 40.45,51.54 41.03,51.18 42.78,49.43 43.39,49.43 44.85,47.97 45.04,47.97 45.11,48.03 45.11,48.37 v2(44.93,48.55)
  IN3 w0.127: v2(209.68,35.42) 209.81,35.55 210.36,35.55 210.38,35.57 211.23,35.57 211.43,35.77 212.84,35.77 214.03,36.96 214.03,37.75 214.92,38.64 217.42,38.64 218.1,37.96 218.1,32.26 217.38,31.54 217.38,23.15 216.23,22 216.23,20.81 217.43,19.61 217.43,17.87 218.05,17.25 218.05,15.94 215.38,13.27 211.66,13.27 207.75,9.36 205.91,9.36 205.64,9.62 202.91,9.62 202.07,8.79 198.02,8.79 197.69,8.46 193.06,8.46 192.33,9.18 190.93,9.18 190.56,9.55 178.58,9.55 177.01,11.12 171.63,11.12 169.55,13.2 155.77,13.2 151.28,8.7 133.84,8.7 133.47,9.07 124.97,9.07 124.62,9.42 122.84,9.42 122,8.58 94.99,8.58 92.86,10.71 92.79,10.79 92.71,10.86 92.71,10.86 91.84,11.74 89.27,11.74 88.83,12.18 88.83,12.97 86.59,15.22 82.59,15.22 79.88,17.93 67.4,17.93 65.67,19.66 65.67,19.95 63.96,21.66 63.96,22.59 64.22,22.85 64.22,25.86 61.19,28.89 57.68,28.89 56.67,29.9 56.67,31.11 56.27,31.52 56.27,34.44 56.17,34.54 56.17,35.91 54.94,37.13 54.94,38.37 54.76,38.55 54.76,42.47 49.81,47.42 47.83,47.42 45.91,49.34 45.42,49.34 45.09,49.01 45.09,48.71 v2(44.93,48.55)
  BOTTOM w0.089: UH1.M10 v2(209.68,35.42)
USB20_N4_L: length 20.6
  TOP w0.127: JUSBC1.A7 7.8,52.19 7.94,52.33 9.96,52.33 10.16,52.13 10.16,51.91 10.04,51.78 9.93,51.78 v2(9.84,51.87) ; v2(13.36,49.54) 13.6,49.3 14.22,49.3 14.36,49.44 DU3.6 DU3.5 16.17,49.44 16.28,49.33 17.12,49.33 ML11.3
  IN1 w0.135: v2(13.36,49.54) 13.22,49.4 12.81,49.4 12.02,50.19 12.02,51.86 11.23,52.65 10.32,52.65 9.98,52.3 9.98,52.01 v2(9.84,51.87) 10.27,51.44 10.27,51.16 9.65,50.54 8.5,50.54 7.96,51.09 7.96,51.87 7.4,52.43 6.97,52.43 6.87,52.52 6.87,52.77 6.8,52.84 JUSBC1.B7
USB20_N5: length 191.1
  IN3 w0.127: v2(70.16,21.26) 70.05,21.26 69.8,21 69.8,19.86 71.02,18.64 80.17,18.64 82.91,15.91 88.64,15.91 94.47,10.08 98.67,10.08 99.48,9.27 108.58,9.27 109.34,10.02 111.48,10.02 112.23,9.27 114.17,9.27 114.86,9.96 118.09,9.96 118.31,10.19 125.38,10.19 125.8,9.76 133.8,9.76 134.17,9.39 150.09,9.39 152.79,12.09 153.69,12.09 155.49,13.89 171.6,13.89 173.63,11.85 177.25,11.85 178.87,10.24 190.85,10.24 191.21,9.88 202.19,9.88 203.2,10.88 206.35,10.88 208.09,12.62 209.07,12.62 210.82,14.36 214.86,14.36 216.74,16.25 216.74,16.73 215.5,17.98 215.5,24.53 216.69,25.73 216.69,31.84 217.1,32.25 217.1,35.24 216.97,35.37 216.97,37.22 216.85,37.34 216.75,37.34 v2(216.54,37.13)
  BOTTOM w0.089: UH1.M1 214.21,35.2 214.12,35.11 214.12,35.03 214.24,34.91 214.46,34.91 214.71,35.16 214.71,35.65 215.37,36.31 216.12,36.31 216.5,36.69 216.92,36.69 216.99,36.76 216.99,37.28 216.9,37.37 216.76,37.37 216.54,37.14 v2(216.54,37.13)
  BOTTOM w0.127: L1.1 68.59,22.65 68.59,22.55 68.81,22.33 69.22,22.33 69.85,21.7 69.85,21.47 70.07,21.26 v2(70.16,21.26)
USB20_N5_R: length 12.2
  BOTTOM w0.127: L1.2 68.57,23.51 68.57,25.77 69.39,26.59 69.39,26.89 69.52,27.02 70.1,27.02 D507.3 69.4,27.99 69.4,28.29 68.88,28.82 v4(68.39,28.82) 67.8,28.82 67.56,29.06 66.32,29.06 65.93,29.45 65.13,29.45 64.95,29.63 64.95,29.77 65.05,29.88 JEDP1.9
USB20_N6: length 3
  TOP w0.127: v2(211.3,36.47) 211.3,36.95 211.45,37.09 211.45,37.82 211,38.26 TH146.1
  BOTTOM w0.089: UH1.K7 v2(211.3,36.47)
USB20_N9: length 1.3
  TOP w0.127: v2(211.64,35.21) 212.15,35.72 TH148.1
  BOTTOM w0.089: v2(211.64,35.21) 211.8,35.06 UH1.M6
USB20_N14: length 122.2
  IN1 w0.076: 213.23,37.61 213.21,37.61 213.17,37.56 212.55,37.56 212.4,37.41 211.76,37.41 211.64,37.53 211.64,37.73 211.82,37.91 212.03,37.91 v2(212.13,37.81)
  IN1 w0.135: 213.23,37.61 213.68,37.61 215.28,36.01 219.18,36.01 219.68,35.52 229.32,35.52 229.82,36.01 233.6,36.01 234.45,36.87 251.51,36.87 251.94,36.44 254.81,36.44 258.79,32.46 266.14,32.46 267.96,30.64 274.7,30.64 279.07,35.01 303.27,35.01 305.54,32.74 309.52,32.74 310.01,32.25 310.01,28.42 310.65,27.78 310.65,27.1 310.36,26.81 309.96,26.81 v2(309.81,26.67)
  BOTTOM w0.102: UH1.E5 v2(212.13,37.81)
  BOTTOM w0.127: v2(309.81,26.67) 309.54,26.94 309.04,26.94 308.89,27.09 307.25,27.09 305.42,25.25 305.42,24.59 304.54,23.71 303.72,23.71 303.62,23.6 JWLAN1.5
USB20_P1: length 269.1
  IN3 w0.127: v2(215.37,37.67) 215.24,37.55 215.24,34.69 215.63,34.3 215.63,32.26 216.26,31.63 216.26,27.75 215.73,27.23 214.67,27.23 214.06,26.61 214.06,23.06 213.81,22.8 213.81,20.84 214.3,20.35 214.3,19.01 212.54,17.25 212.24,17.25 210.99,15.99 210.99,15.14 208.89,13.05 205.38,13.05 203.69,11.36 203.06,11.36 202.05,10.34 191.35,10.34 191.03,10.67 179.05,10.67 177.37,12.34 173.91,12.34 171.94,14.32 155.31,14.32 153.52,12.53 152.51,12.53 150.25,10.27 135.22,10.27 134.87,10.62 117.76,10.62 117.54,10.4 114.56,10.4 114.51,10.45 109.16,10.45 108.4,9.7 99.85,9.7 98.99,10.57 94.59,10.57 88.78,16.38 83.06,16.38 80.36,19.08 73.09,19.08 69.97,22.2 67.63,22.2 66.69,23.13 66.69,24.78 64.2,27.27 63.54,27.27 61.09,29.73 58.45,29.73 57.12,31.06 57.12,35.57 55.93,36.76 55.93,41.2 55.65,41.48 55.65,43.4 54.32,44.72 53.12,44.72 49.86,47.99 48.93,47.99 47.04,49.87 44.9,50.86 44.89,50.86 44.89,50.86 44.3,51.2 42.32,52.46 40.48,53.68 39.08,54.72 36.93,56.4 36.82,56.4 36.82,56.4 36.39,56.4 33.71,56.4 32.64,57.47 32.64,58.61 30.29,60.96 30.29,63.57 27.98,65.88 27.98,67.9 25.12,70.76 25.12,73.3 24.8,73.62 24.54,73.62 v2(24.52,73.61)
  BOTTOM w0.089: v2(215.37,37.67) 215.29,37.67 215.05,37.43 215.05,37.15 214.35,36.44 213.65,36.44 213.6,36.4 UH1.J2
  BOTTOM w0.127: v2(24.52,73.61) 23.95,73.61 23.57,73.22 20.78,73.22 v4(20.13,73.88) 19.53,74.48 US2.3
USB20_P1_C: length 11.7
  TOP w0.127: LS9.2 19.96,86.49 20.13,86.66 20.13,87.21 19.76,87.58 19.76,87.89 18.81,88.84 18.56,88.84 18.44,88.72 DS5.3 17.59,88.68 17.32,88.68 17.1,88.9 17.1,89.61 16.96,89.75 16.81,89.75 16.39,89.33 16.39,89.2 16.64,88.95 16.64,88.46 16.39,88.21 v4(15.97,88.21) 15.54,88.21 15.08,88.68 14.92,88.68 14.7,88.45 JUSB3.3
USB20_P2: length 113
  IN1 w0.076: v2(207.84,34.21) 207.89,34.26 208.08,34.45 208.1,34.47 210.16,34.47 210.27,34.37 210.57,34.37 210.63,34.31 210.65,34.31
  IN1 w0.135: 210.65,34.31 211.92,34.31 212.58,33.65 212.93,33.65 214.16,32.43 215.58,32.43 217.2,30.81 220.49,30.81 222.07,32.39 222.07,33.41 223.05,34.38 229.6,34.38 230.23,35.02 234.01,35.02 234.86,35.87 251.1,35.87 251.53,35.44 253.65,35.44 254.06,35.03 254.81,35.03 258.37,31.47 264.97,31.47 266.9,29.53 291.4,29.53 294.78,32.92 302.59,32.92 302.97,33.3 302.97,33.77 302.66,34.09 302.25,34.09 v2(302.1,34.24)
  BOTTOM w0.089: v2(207.84,34.21) 207.82,34.4 207.61,34.56 UH1.N15
  BOTTOM w0.127: JIO1.22 308.27,35.25 308.17,35.15 305.85,35.15 304.77,34.07 302.28,34.07 v2(302.1,34.24)
USB20_P3: length 105.5
  IN1 w0.135: v2(306.49,34.05) 306.33,33.88 306.33,33.74 306.43,33.64 306.92,33.64 307.05,33.77 307.05,34.38 305.55,35.88 302.83,35.88 301.78,36.93 289.26,36.93 288.87,36.54 280.04,36.54 279.23,35.73 273.69,35.73 273.27,36.15 268.31,36.15 267.91,35.75 256.14,35.75 255.01,36.88 252.12,36.88 251.59,37.41 246.02,37.41 245.54,37.89 244.76,37.89 244.18,37.31 234.27,37.31 233.42,36.45 229.63,36.45 229.34,36.16 219.71,36.16 217.49,38.38 216.53,38.38 216.09,37.94 216.09,37.75 216.23,37.62 216.46,37.62 v2(216.56,37.72)
  BOTTOM w0.089: UH1.K3 213.12,35.66 213.16,35.61 213.31,35.61 213.49,35.79 214.25,35.79 215.08,36.61 215.17,36.61 215.98,37.42 215.98,37.66 216.19,37.87 216.4,37.87 v2(216.56,37.72)
  BOTTOM w0.127: JIO1.25 308.28,33.75 308.04,33.51 307.54,33.51 307.29,33.75 306.63,33.75 306.49,33.88 v2(306.49,34.05)
USB20_P4: length 280.2
  TOP w0.127: UU4.50 46.74,47.45 46.44,47.75 46.44,48.11 46,48.55 45.53,48.55 v2(45.51,48.53) ; v2(21.1,49.19) 20.87,49.43 20.42,49.43 20.08,49.08 17.97,49.08 ML11.1
  IN1 w0.135: v2(45.51,48.53) 45.39,48.4 45.39,47.92 45.15,47.69 44.74,47.69 43.28,49.15 42.66,49.15 40.85,50.95 40.29,51.3 38.92,52.27 38.26,52.77 36.35,52.77 34.26,54.86 25.13,54.86 24.19,53.91 23.47,53.91 21.78,52.23 21.78,49.73 21.39,49.34 21.24,49.34 v2(21.1,49.19)
  IN3 w0.127: v2(210.14,35.98) 210.29,35.83 211.13,35.83 211.32,36.03 212.73,36.03 213.77,37.07 213.77,37.86 214.81,38.9 217.52,38.9 218.35,38.07 218.35,32.15 217.64,31.44 217.64,23.05 216.49,21.9 216.49,20.92 217.69,19.72 217.69,17.98 218.31,17.36 218.31,15.84 215.48,13.01 211.77,13.01 207.86,9.1 205.8,9.1 205.54,9.37 203.02,9.37 202.18,8.53 198.13,8.53 197.8,8.2 192.95,8.2 192.23,8.92 190.83,8.92 190.46,9.29 178.47,9.29 176.91,10.86 171.53,10.86 169.44,12.94 155.88,12.94 151.38,8.44 133.74,8.44 133.37,8.82 124.86,8.82 124.51,9.17 122.95,9.17 122.11,8.32 94.89,8.32 92.68,10.53 92.61,10.6 91.73,11.48 89.17,11.48 88.58,12.07 88.58,12.87 86.48,14.96 82.49,14.96 79.78,17.67 67.3,17.67 65.42,19.55 65.42,19.84 63.7,21.56 63.7,22.69 63.96,22.96 63.96,25.75 61.08,28.63 57.58,28.63 56.42,29.79 56.42,31 56.01,31.41 56.01,34.33 55.91,34.43 55.91,35.8 54.69,37.02 54.69,38.26 54.51,38.45 54.51,42.37 49.7,47.17 47.72,47.17 45.81,49.08 45.53,49.08 45.34,48.9 45.34,48.71 45.51,48.54 v2(45.51,48.53)
  BOTTOM w0.089: UH1.L9 v2(210.14,35.98)
USB20_P4_L: length 20.6
  TOP w0.127: ML11.2 17.14,49.07 16.28,49.07 16.15,48.94 DU3.4 DU3.7 14.33,48.94 14.22,49.05 13.58,49.05 v2(13.36,48.83) ; JUSBC1.A6 7.8,52.69 7.91,52.58 10.07,52.58 10.42,52.23 10.42,52.01 v2(10.55,51.87)
  IN1 w0.135: v2(13.36,48.83) 13.43,48.9 13.43,48.99 13.3,49.12 12.69,49.12 11.74,50.07 11.74,51.75 11.12,52.37 10.44,52.37 10.26,52.19 10.26,51.97 10.35,51.87 v2(10.55,51.87) 10.55,51.05 9.77,50.26 8.39,50.26 7.68,50.97 7.68,51.75 7.28,52.15 6.5,52.15 JUSBC1.B6
USB20_P5: length 191.1
  IN3 w0.127: v2(69.45,21.26) 69.54,21.17 69.54,20.82 69.54,19.76 70.91,18.39 80.07,18.39 82.8,15.65 88.54,15.65 94.36,9.82 98.57,9.82 99.37,9.01 108.69,9.01 109.44,9.76 111.37,9.76 112.12,9.01 114.27,9.01 114.97,9.71 118.2,9.71 118.42,9.93 125.27,9.93 125.7,9.5 133.69,9.5 134.07,9.13 150.2,9.13 152.9,11.83 153.8,11.83 155.6,13.63 171.49,13.63 173.53,11.6 177.15,11.6 178.76,9.98 190.74,9.98 191.1,9.63 202.3,9.63 203.3,10.63 206.46,10.63 208.19,12.36 209.18,12.36 210.92,14.11 214.97,14.11 217,16.14 217,16.84 215.76,18.08 215.76,24.43 216.95,25.62 216.95,31.73 217.36,32.14 217.36,35.34 217.23,35.48 217.23,36.96 v2(217.4,37.13)
  BOTTOM w0.089: UH1.L2 213.93,35.25 213.93,35.25 213.93,34.95 214.16,34.72 214.54,34.72 214.9,35.08 214.9,35.57 215.45,36.12 216.2,36.12 216.58,36.5 217,36.5 217.18,36.68 217.18,36.92 v2(217.4,37.13)
  BOTTOM w0.127: L1.4 68.34,22.65 68.34,22.44 68.71,22.07 69.11,22.07 69.6,21.59 69.6,21.4 v2(69.45,21.26)
USB20_P5_R: length 12.2
  BOTTOM w0.127: JEDP1.8 64.55,29.86 64.69,29.73 64.69,29.52 65.02,29.19 65.82,29.19 66.22,28.8 v4(67.05,28.8) 67.46,28.8 67.7,28.56 68.77,28.56 69.15,28.19 69.15,27.99 D507.2 68.45,27.02 69.01,27.02 69.13,26.89 69.13,26.69 68.32,25.88 68.32,23.47 L1.3
USB20_P6: length 1.2
  TOP w0.127: TH145.1 211.93,37.04 v2(211.93,36.64)
  BOTTOM w0.089: UH1.K6 v2(211.93,36.64)
USB20_P9: length 1.3
  TOP w0.127: TH147.1 210.74,35.42 v2(211.01,35.15)
  BOTTOM w0.089: v2(211.01,35.15) UH1.N8
USB20_P14: length 122.2
  IN1 w0.076: 213.23,37.35 213.21,37.35 213.17,37.4 212.62,37.4 212.47,37.25 211.7,37.25 211.48,37.46 211.48,37.8 211.78,38.1 211.78,38.2 v2(211.63,38.35)
  IN1 w0.135: 213.23,37.35 213.54,37.35 215.16,35.74 219.07,35.74 219.56,35.24 229.44,35.24 229.93,35.74 233.71,35.74 234.57,36.59 251.4,36.59 251.83,36.16 254.7,36.16 258.67,32.18 266.03,32.18 267.85,30.36 274.82,30.36 279.19,34.73 303.15,34.73 305.43,32.46 309.4,32.46 309.73,32.13 309.73,28.3 310.37,27.66 310.37,27.21 310.24,27.09 309.84,27.09 309.68,27.25 309.68,27.35 v2(309.81,27.49)
  BOTTOM w0.102: UH1.F6 v2(211.63,38.35)
  BOTTOM w0.127: v2(309.81,27.49) 309.53,27.2 309.14,27.2 309,27.34 307.15,27.34 305.16,25.36 305.16,24.7 304.43,23.96 303.75,23.96 303.61,24.1 JWLAN1.3
USB_CHARGE_EN: length 190
  TOP w0.127: v2(149.77,11.86) 149.77,11.59 150.35,11.02 UK1.36
  IN2 w0.127: v2(14.89,77.62) 14.89,75.61 15.59,74.91 15.59,69.25 15.79,69.06 15.79,66.92 15.59,66.72 15.59,64.01 12.48,60.9 12.48,57.11 16.42,53.16 19.32,53.16 24.03,48.46 29.91,48.46 31.58,46.79 33.12,46.79 34.33,45.58 35.46,45.58 38.08,42.96 38.08,40.44 39.75,38.78 41.52,38.78 41.74,38.78 42.49,38.03 46.37,38.03 46.47,37.92 46.84,37.55 51.45,37.55 52.01,37 52.01,35.98 53.2,34.79 53.2,28.51 58.3,23.42 58.3,23.31 58.74,22.87 59.76,22.87 65.36,17.27 74.02,17.27 76.48,14.82 90.45,14.82 90.8,15.16 98.31,15.16 101.41,12.06 109.1,12.06 109.38,11.78 116.7,11.78 117.26,11.23 125.28,11.23 126.67,12.61 131.83,12.61 132.24,12.2 135.1,12.2 135.61,11.69 145.64,11.69 146.36,12.41 149.12,12.41 149.24,12.28 149.36,12.28 v2(149.77,11.86)
  BOTTOM w0.127: RS16.1 15.96,78.34 15.23,77.62 v2(14.89,77.62)
USB_CHARGE_EN_R: length 4.1
  BOTTOM w0.127: v3(16.27,76.64) 16.87,77.24 RS16.2 17.42,79.44 US2.5
USB_CTL1: length 186
  TOP w0.127: v2(59.57,25.09) v3(59.57,24.52) ; UK1.84 142.04,22.91 142.3,22.65 142.3,21.69 v2(141.71,21.11)
  IN1 w0.127: v2(59.57,25.09) 59.59,25.06 59.59,24.79 59.33,24.53 56.37,24.53 51.4,29.5 51.4,30.59 49.69,32.3 49.69,34 49.28,34.4 49.28,35.32 48.95,35.66 48.18,35.66 47.67,35.15 42.97,35.15 42.38,35.74 39.38,35.74 37.65,37.47 37.65,43.01 34.51,46.15 31.71,46.15 31.56,46 28.39,46 27.92,46.46 27.53,46.46 26.79,47.21 21.22,47.21 19.69,48.74 19.69,61.93 17.02,64.6 17.02,74.1 16.1,75.01 16.1,78.3 v2(15.27,79.14)
  IN2 w0.127: v2(59.57,25.09) 60.41,25.09 60.63,25.3 62.07,25.3 64.03,27.26 81.57,27.26 81.97,26.85 81.97,25.88 83.72,24.13 87.6,24.13 90.78,20.94 94.7,20.94 95.01,21.26 95.58,21.26 95.9,20.94 97.58,20.94 99.88,23.24 109.17,23.24 112.24,20.17 117.05,20.17 117.32,19.9 119.25,19.9 119.91,20.56 123.54,20.56 123.82,20.84 129.97,20.84 130.21,21.08 132.02,21.08 132.99,20.11 135.75,20.11 136.56,20.91 138.34,20.91 138.96,21.53 141.28,21.53 v2(141.71,21.11)
  BOTTOM w0.127: US2.6 17.38,79.94 17.22,79.78 RS41.2 16.44,79.35 16.33,79.35 16.31,79.33 15.5,79.33 15.31,79.14 v2(15.27,79.14)
USB_CTL2: length 212.5
  TOP w0.127: v2(146.84,22.45) UK1.72 ; v2(115.52,11.07) 115.52,11.52 v3(114.79,12.25) 113.87,13.17 113.87,14.2 115.1,15.43 115.1,15.87 114.28,16.68 114.28,19.1 115.66,20.48 115.66,23.53 v2(115.18,24.01)
  IN2 w0.127: v2(13.9,75.74) 13.9,75.24 15.03,74.11 15.03,64.21 11.94,61.12 11.94,56.89 16.2,52.62 18.13,52.62 18.48,52.27 18.48,51.16 22.4,47.24 27.25,47.24 28.02,46.48 30.87,46.48 31.14,46.21 32.9,46.21 34.03,45.08 35.19,45.08 37.54,42.73 37.54,40.22 39.53,38.24 41.52,38.24 42.27,37.49 46.14,37.49 46.62,37.02 48.02,37.02 48.85,36.19 49.51,36.19 49.83,36.51 50.85,36.51 51.41,35.95 51.41,35.74 52.66,34.49 52.66,31.85 52.46,31.64 52.46,28.46 55.33,25.58 55.33,22.83 56.04,22.12 57.04,22.12 57.89,21.27 57.89,20.85 58.47,20.27 61.22,20.27 64.76,16.73 73.71,16.73 76.22,14.22 81.61,14.22 81.81,14.03 92.22,14.03 92.7,13.55 94.57,13.55 95.59,14.56 98.06,14.56 101.4,11.22 105.02,11.22 106.1,10.14 108.19,10.14 109,10.95 115.4,10.95 v2(115.52,11.07)
  BOTTOM w0.127: v2(146.84,22.45) 146.34,22.45 146.25,22.53 142.23,22.53 141.8,22.1 138.81,22.1 138.43,21.72 135.8,21.72 135.8,21.72 135.58,21.72 134.87,22.44 133.38,22.44 133.19,22.63 128.2,22.63 127.46,21.89 125.47,21.89 124.59,22.77 122.68,22.77 121.31,22.77 121.31,22.77 119.93,22.77 118.65,22.77 118.32,22.77 117.19,22.77 117.19,22.77 116.47,22.77 115.23,24.01 v2(115.18,24.01) ; v2(13.9,75.74) 14.47,76.31 14.47,78.84 14.86,79.23 14.86,80.71 15.45,81.3 16.11,81.3 RS42.2 17.31,80.54 17.42,80.44 US2.7
USB_CTL3: length 200.6
  TOP w0.127: v2(13.97,79.13) v3(13.55,79.56) ; v2(148.45,11.86) 148.45,12.02 148.81,12.38 149.87,12.38 150.44,11.82 UK1.38 152.92,11.82 RK28.2
  IN2 w0.127: v2(13.97,79.13) 13.97,76.47 14.47,75.98 14.47,75.64 15.29,74.82 15.29,64.1 12.21,61.01 12.21,57 16.31,52.89 19.19,52.89 23.89,48.19 26.69,48.19 28.13,46.75 30.98,46.75 31.21,46.53 33,46.53 34.22,45.31 35.35,45.31 37.81,42.85 37.81,40.33 39.64,38.51 41.63,38.51 42.38,37.76 46.26,37.76 46.36,37.65 46.73,37.29 51.34,37.29 51.74,36.88 51.74,35.84 52.93,34.65 52.93,28.38 55.94,25.37 55.94,22.67 56.22,22.39 57.15,22.39 58.25,21.29 58.25,20.96 58.61,20.6 61.65,20.6 65.25,17 73.91,17 76.37,14.55 90.56,14.55 90.91,14.89 98.2,14.89 101.35,11.74 109.04,11.74 109.42,11.36 114.59,11.36 114.75,11.51 116.59,11.51 117.36,10.75 125.18,10.75 126.64,12.2 131.86,12.2 132.2,11.86 135.06,11.86 135.5,11.42 145.75,11.42 146.29,11.96 148.35,11.96 v2(148.45,11.86)
  BOTTOM w0.127: v2(13.97,79.13) 14.17,79.13 14.6,79.56 14.6,80.82 15.34,81.56 16.65,81.56 17.28,80.94 US2.8
USB_IN_STATUS#: length 181.9
  TOP w0.127: v2(137.37,18.11) 137.08,17.82 UK1.108
  IN2 w0.127: v2(23.21,86.61) 23.39,86.43 23.39,85.37 22.84,84.83 22.84,81.28 23.47,80.65 23.47,77.75 24.65,76.56 24.95,75.62 24.95,74.48 25.39,74.04 25.39,71.19 27.04,69.53 27.04,66.57 31.57,62.04 31.57,60.63 32.64,59.57 32.88,59.57 34.19,58.25 34.19,57.52 36.16,55.55 36.4,55.31 36.97,55.31 40.97,52.56 45.97,49.64 46.37,49.23 46.63,48.85 47.12,48.36 47.94,48.25 48.86,47.94 49.31,47.77 49.31,47.77 50.08,47.49 50.63,47.29 50.8,47.12 52.65,45.27 56.21,45.27 56.47,45.53 59.02,45.53 59.26,45.77 67.63,45.77 68.35,46.49 79.17,46.49 v2(79.26,46.39)
  IN3 w0.127: v2(108.37,22.76) 107.98,22.36 100.72,22.36 99.04,24.03 99.04,25.55 97.78,26.81 v2(97.52,26.81)
  BOTTOM w0.127: v2(137.37,18.11) 137.27,18.21 137.27,18.51 136.85,18.93 132.72,18.93 131.84,19.81 124.61,19.81 123.72,20.69 120.04,20.69 119.54,20.19 117.38,20.19 116.88,20.69 114.3,20.69 113.12,21.87 110.5,21.87 109.61,22.76 v2(108.37,22.76) ; v2(23.21,86.61) 22.27,86.61 22.01,86.34 19.72,86.34 v1(18.25,84.87) 18.24,84.86 18.24,83.55 RS43.2 18.52,82.68 19.03,82.17 US2.9 ; v2(79.26,46.39) 79.32,46.34 82.8,46.34 83.23,46.77 83.44,46.98 97.75,46.98 99.58,45.15 99.58,40.71 98.99,40.12 98.23,40.12 97.62,39.51 97.62,30.53 98.49,29.66 98.49,27.78 v2(97.52,26.81)
USB_OC0#: length 238.5
  TOP w0.127: v2(186.34,27.94) 187.07,27.94 v1(188.51,26.49) 189.05,25.95 190.86,25.95 191.39,25.42 195.69,25.42 196.2,25.93 196.42,25.93 196.84,26.35 v2(196.99,26.35)
  TOP w0.135: RH217.1 185.67,28.6 v2(186.34,27.94)
  IN2 w0.127: v2(80.08,46.79) 80.03,46.84 79.06,46.84 78.98,46.76 68.24,46.76 67.51,46.04 59.15,46.04 58.91,45.8 56.36,45.8 56.1,45.54 52.76,45.54 50.91,47.39 50.78,47.53 49.95,47.83 49.68,47.92 48.94,48.19 47.93,48.53 47.72,48.85 47.72,49.07 47.36,49.44 47.16,49.57 47.03,49.62 46.51,49.87 46.51,49.88 45.39,50.42 45.39,50.42 44.34,50.92 42.74,51.86 42.71,51.87 42.62,51.93 42.62,51.93 42.35,52.1 41.17,52.86 38.81,54.47 38.81,54.47 37.2,55.58 36.51,55.58 35.6,56.48 34.46,57.63 34.46,58.36 32.99,59.83 32.76,59.83 31.84,60.75 31.84,62.2 27.35,66.69 27.35,69.61 25.66,71.3 25.66,74.16 25.22,74.59 25.22,75.73 24.92,76.67 23.74,77.86 23.74,79.85 v2(24.05,80.16) ; v2(186.34,27.94) 185.16,29.12 182.66,29.12 180.11,26.56 179.57,26.56 175.37,22.36 161.27,22.36 160.66,22.98 152.54,22.98 151,21.44 146.49,21.44 145.81,22.12 142.6,22.12 142.28,21.8 138.85,21.8 138.23,21.18 136.44,21.18 135.64,20.38 133.1,20.38 132.13,21.35 130.1,21.35 129.86,21.11 123.71,21.11 123.43,20.83 119.79,20.83 119.14,20.17 117.43,20.17 117.16,20.44 112.35,20.44 109.28,23.51 99.77,23.51 97.62,21.36 v2(96.21,21.36)
  BOTTOM w0.127: v2(96.21,21.36) 96.21,23.14 96.45,23.39 97.15,23.39 97.66,23.9 97.66,25.22 98.75,26.31 98.75,29.77 97.88,30.64 97.88,39.4 98.34,39.85 99.1,39.85 99.84,40.6 99.84,45.26 97.86,47.24 83.34,47.24 82.69,46.6 80.27,46.6 v2(80.08,46.79) ; v2(196.99,26.35) 196.94,26.4 UH1.AH36 ; RS10.1 23.7,80.51 v2(24.05,80.16)
