# Allegro board LAJ643PR10-0325.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GNDA: length 28
  TOP w0.127: v3(300.02,30.79) v2(299.17,30.79) ; v2(302.47,28.09) v3(302.47,28.71) ; v2(307.54,29.75) v3(307.54,29.02)
  TOP w0.203: v2(299.24,23.42) 299.24,23.32 298.55,22.63 UA1.22 ; v2(291.18,24.18) 291.33,24.18 291.62,23.89 291.62,23.49 291.68,23.43 UA1.37 ; UA1.30 295.22,24.83 v2(295.52,25.13)
  TOP w0.305: CA23.1 v2(298.28,26.83)
  TOP w0.356: v2(307.54,29.75) 307.54,29.97 RA24.2 ; CA12.1 v2(289.51,24.42) ; CA11.2 v2(289.26,23.01)
  TOP w0.381: CA13.2 299.95,22.45 300.39,22.88 CA14.1 301.09,22.88 v2(301.24,23.03) ; v2(300.98,24.54) 301,24.56 CA38.2 ; CA36.2 v2(302.47,28.09) ; CA5.1 294.24,26.69 v2(293.8,26.25) ; CA37.2 298.69,30.31 v2(299.17,30.79) ; CA17.1 300.82,23.9 300.44,24.28 v2(300.44,24.41) ; CA32.2 v2(295.07,27.1)
  BOTTOM w0.254: v2(307.54,29.75) JIO1.33 ; v2(307.52,31.09) 308.13,31.09 308.3,31.25 JIO1.30 ; JIO1.36 v2(307.56,28.25)
  BOTTOM w0.356: CA31.2 295.61,25.04 v2(295.52,25.13) ; CA12.1 v2(289.51,24.42) ; v2(292.44,25.28) CA19.2 CA20.2 v2(291.8,25.3) ; v2(290.19,22.42) 290.29,22.32 CA30.2 ; CA11.2 v2(289.26,23.01)
  BOTTOM w0.381: RA22.2 302.4,31.51 v2(302.04,31.51) ; v2(299.27,22.29) 298.92,21.94 RA23.2 ; CA95.2 v2(305.66,27.76) ; CA97.2 v2(305.01,31.51) ; CA96.2 304.62,29.03 v2(304.49,28.89)
VBAT: length 2.5
  TOP w0.203: PRB06.1 240.23,13.59 v1(239.72,13.59) 239.59,13.59 239.29,13.29 PUB01.26
VCC_5V:
  vias: v2(78.33,9.42)
VCCGT_SENSE: length 52.3
  IN3 w0.203: v2(146.92,110.54) 146.92,110.94 147.83,111.86 163.85,111.86 172.75,120.76 172.75,121.46 175.37,124.08 176.38,124.08 177.78,125.48 177.78,130.58 175.34,133.02 175.34,135.02 v2(174.83,135.53)
  BOTTOM w0.203: v2(174.83,135.53) 174.38,135.53 PRZ31.2
  BOTTOM w0.254: RC12.1 147.02,110.92 146.92,110.82 v2(146.92,110.54) 146.92,110.46 147.99,109.39 UC1.AH38
VCCIO_SENSE: length 1.2
  TOP w0.127: v2(162.97,91.16) 163.12,91.32 TC92.1
  BOTTOM w0.254: UC1.H14 v2(162.97,91.16)
VCCMPHY_SENSE: length 3.5
  BOTTOM w0.127: TH139.1 189.95,35.62 191.65,35.62 UH1.K47
VCCSA_SENSE: length 27.4
  IN1 w0.203: v2(177.02,126.01) 177.39,125.64 177.39,124.62 176.39,123.61 174.42,123.61 161.43,110.62 v2(160.8,110.62)
  BOTTOM w0.203: RC15.1 160.48,111.14 160.8,110.82 v2(160.8,110.62) 160.8,110.03 160.54,109.77 160.54,109.19 UC1.M38 ; PRZ11.1 176.41,126.46 176.87,126.01 v2(177.02,126.01)
VCCSENSE: length 38.9
  TOP w0.203: v2(174.58,121.82) 174.36,121.82 170.77,118.22 170.77,115.85 170.35,115.43 v2(170.12,115.43)
  IN3 w0.203: v2(170.12,115.43) 169.9,115.43 164.42,109.95 161.6,109.95 161.05,109.4 159.26,109.4 158.6,110.05 149.84,110.05 149.71,109.92 v2(149.29,109.92)
  BOTTOM w0.203: v2(174.58,121.82) 174.76,121.64 175.29,121.64 176.13,122.48 176.13,123.11 PRZ25.1
  BOTTOM w0.254: UC1.AG37 149.16,108.87 149.16,109.78 v2(149.29,109.92) 149.94,110.57 RC10.1
VCCSENSE_VGA: length 36.7
  TOP w0.127: v1(231.77,58.49) 231.77,58.7 v2(231.16,59.3)
  IN3 w0.152: v2(231.16,59.3) 230.57,59.9 222.71,59.9 221.79,60.82 221.79,61.48 220.27,62.99 220.27,63.73 219.92,64.09 219.92,67.49 219.92,67.94 214.57,73.29 213.3,73.29 210.42,76.16 210.42,77.87 v2(211.09,78.54)
  BOTTOM w0.254: v2(231.16,59.3) 231.09,59.38 231.09,60.09 231.25,60.25 PRV38.1
  BOTTOM w0.381: UG1.L4 211.48,78.17 211.13,78.51 211.12,78.51 v2(211.09,78.54)
VCCSENSE_VGA_S: length 9.1
  BOTTOM w0.127: TG12.1 212.11,70.51 212.35,70.75 212.35,71.29 210.54,73.09 210.54,73.26 210.02,73.78 209.85,73.78 209.5,74.14 207.94,74.14 206.48,75.6 UG1.U1
VDD_DDR: length 4.7
  TOP w0.127: v1(88.52,26.05) 88.69,25.88 v2(89.21,25.88)
  TOP w0.508: v2(89.21,25.88) 89.54,26.2 PRM2.1
  BOTTOM w0.203: PUM1.11 89.64,26.15 89.36,25.88 v2(89.21,25.88)
  BOTTOM w0.508: v2(89.21,25.88) 88.58,25.88 PCM16.1 87.79,25.97 PRM4.2
VDDP_DDR: length 7
  BOTTOM w0.127: v1(87.16,29.09) PDM3.1
  BOTTOM w0.203: 89.1,26.55 PUM1.12
  BOTTOM w0.381: 89.1,26.55 88.83,26.81 PCM7.2
  BOTTOM w0.508: PCM7.2 88.25,26.81 87.33,27.72 PDM3.1 85.83,26.4 PRM5.2
VIN_3V_LCDVDD: length 1.4
  TOP w0.127: LV2.2 v1(75.16,34.41)
VSSGT_SENSE: length 53.2
  IN3 w0.203: v2(148.16,110.61) 148.16,110.82 148.62,111.28 164.09,111.28 173.33,120.52 173.33,121.22 175.61,123.49 176.62,123.49 178.36,125.24 178.36,130.82 175.93,133.26 175.93,135.43 175.19,136.17 v2(174.83,136.17)
  BOTTOM w0.203: v2(148.16,110.61) 148.29,110.74 RC13.1 ; PRZ33.2 v2(174.83,136.17)
  BOTTOM w0.254: v2(148.16,110.61) 148.16,109.98 148.37,109.78 148.37,108.76 148.1,108.49 UC1.AH37
VSSIO_SENSE: length 1.3
  TOP w0.127: v2(162.16,91.56) 162.16,91.74 TC93.1
  BOTTOM w0.254: v2(162.16,91.56) UC1.J14
VSSMPHY_SENSE: length 4.2
  BOTTOM w0.127: UH1.K46 192.06,36.11 191.69,36.11 191.57,35.99 189.01,35.99 188.8,35.79 TH138.1
VSSSA_SENSE: length 32.2
  IN1 w0.203: v2(177.14,126.62) 177.42,126.62 177.75,126.29 177.75,124.47 176.55,123.26 174.55,123.26 161.26,109.97 160.41,109.97 160.15,110.23 v2(160.15,110.61)
  BOTTOM w0.203: PRZ9.1 176.05,127.15 176.61,127.15 v2(177.14,126.62) ; UC1.M37 160.19,108.89 160.19,110.52 160.15,110.55 v2(160.15,110.61)
  BOTTOM w0.254: RC16.1 159.59,111.26 160.15,110.69 v2(160.15,110.61)
VSSSENSE: length 36.2
  TOP w0.203: v2(170.18,116.1) 170.18,118.46 v1(171.14,119.42) 174.22,122.5 174.91,122.5 v2(175.09,122.32)
  IN3 w0.203: v2(170.18,116.1) 169.75,116.1 164.18,110.54 161.36,110.54 160.8,109.98 159.5,109.98 158.84,110.63 148.99,110.63 v2(148.87,110.51)
  BOTTOM w0.203: v2(148.87,110.51) 149.05,110.69 RC11.1 ; v2(175.09,122.32) 175.42,122.65 PRZ27.1
  BOTTOM w0.254: UC1.AG38 148.77,110.41 v2(148.87,110.51)
VSSSENSE_VGA: length 36.7
  IN3 w0.152: v2(211.06,79.38) 210.13,78.45 210.13,76.04 213.13,73.04 214.4,73.04 219.62,67.82 219.62,63.97 219.98,63.61 219.98,62.87 221.49,61.35 221.49,60.69 222.58,59.6 230.06,59.6 v2(230.58,59.08)
  BOTTOM w0.254: PRV19.1 230.24,60.51 230.63,60.13 230.63,59.13 v2(230.58,59.08)
  BOTTOM w0.381: v2(211.06,79.38) 211.48,78.95 UG1.L5
VSSSENSE_VGA_S: length 9.8
  BOTTOM w0.102: 207.01,75.39 206.82,75.58 206.82,75.88 206.48,76.23 UG1.U2
  BOTTOM w0.127: TG13.1 212.87,70.73 212.87,71.09 210.77,73.19 210.77,73.36 210.12,74.01 209.95,74.01 209.6,74.36 208.04,74.36 207.01,75.39
7237_FB: length 4.8
  TOP w0.127: v1(83.16,32.38) 83.82,33.03 PRP4.2
  TOP w0.254: PUP1.4 84.2,34.81 84.72,34.29 PRP5.1 84.72,33.65 85.03,33.34 PCP8.2 PRP4.2
81215_ALERT: length 1.8
  BOTTOM w0.203: PRZ19.1 172.48,131.79 172.32,131.63 PUZ1.41
81215_SCLK: length 1.9
  BOTTOM w0.203: PUZ1.42 172.78,131.23 PRZ17.1
81215_SDIO: length 2
  BOTTOM w0.203: PUZ1.40 171.96,132.03 172.48,132.55 PRZ21.1
81215_VR_HOT: length 3
  BOTTOM w0.203: PUZ1.39 170.63,132.83 170.84,133.04 171.38,133.04 v1(171.91,133.56) 172.72,133.56 PRZ14.1
+2546PWR:
  vias: v1(20.73,77.3) v2(22.31,77.61) v2(22.31,77.05) v2(23.07,77.62) v2(23.07,77.05)
+CR_VDD_3V3: length 18.8
  TOP w0.127: v2(37.01,22.67) v3(36.56,23.12) ; v3(38.38,22.83) CR1.1
  TOP w0.508: v2(37.01,22.67) 37.01,21.77 CR1.1 CR4.1 37.17,19.75 39.03,17.88 v3(39.03,17.85) 39.03,17.18 38.64,16.79 v2(38.64,16.73)
  IN2 w0.508: JCR2.6 35.34,28.71 35.34,24.34 v2(37.01,22.67)
  BOTTOM w0.203: v2(38.64,16.73) 38.71,16.66 UR1.12
+EC_VCCA: length 4.3
  TOP w0.254: LK1.2 151.68,25.66 CK3.1 150.83,25.54 150.51,25.22 149.22,25.22 148.84,24.84 UK1.67
+FB_PLLAVDD: length 2.9
  TOP w0.305: CG9.1 207.36,97.84 v2(206.88,97.84)
  BOTTOM w0.356: UG1.K27 v2(211.59,96.73)
  BOTTOM w0.381: v2(214.55,88.6) 214.11,89.04 UG1.H17
  BOTTOM w0.406: v2(206.88,97.84) UG1.U27
  vias: v1(187.6,93.34) v2(190.79,92.71) v2(191.39,92.72)
+GPU_PLLVDD: length 28.7
  IN2 w0.508: v2(200.29,81.97) 200.27,81.99 200.27,95.86 200.78,96.37 205.86,96.37 206.31,96.83 207.9,96.83 208.33,96.4 211.07,96.4 211.5,95.97 213.51,95.97 v2(213.6,96.06)
  BOTTOM w0.356: UG1.H26 v2(213.6,96.06)
  vias: v1(192.09,77.63) v2(192.78,79.43) v2(193.58,79.44) v2(193.55,78.64) v2(194.37,79.43) v2(198.56,81.09) v2(200.27,81.06)
+LAN_REGOUT:
  vias: v1(52.27,17.65)
+LAN_VDD_1V0: length 18.4
  TOP w0.508: v2(54.54,23.65) 55.83,22.36 56.39,22.36 58.29,20.46 59.12,20.46 60.13,21.46 60.13,22.16 58.98,23.31 v2(58.98,23.6)
  BOTTOM w0.203: CL26.1 55.11,23.31 UL1.3 ; CL11.1 52.15,20.9 52.35,20.7 52.72,20.7 52.87,20.54 UL1.30 ; UL1.8 57.11,22.33 57.2,22.42 58.23,22.42 58.83,23.01 CL12.1
  BOTTOM w0.356: CL27.1 51.59,21.49 v2(51.63,21.45) CL11.1 ; CL26.1 54.83,23.35 v2(54.54,23.65) ; v2(58.98,23.6) 59.01,23.57 CL12.1
  vias: v1(54.02,13.18) v2(51.44,15.24) v2(52.13,15.19) v2(52.74,15.21)
+LAN_VDD_3V3: length 102.8
  TOP w0.254: LED5.2 3.84,61.15 v2(3.84,61.01)
  TOP w0.508: v2(49.14,33.16) 49.14,26.95 v2(49.13,26.94)
  IN1 w0.508: v2(51.29,23.84) 50.94,23.84 49.13,25.65 v2(49.13,26.94)
  IN2 w0.254: v2(49.14,33.16) 48.95,33.16 47.16,34.95 41.64,34.95 41.08,35.52 37.66,35.52 35.02,38.16 35.02,41.97 34.74,42.25 34.74,43.06 34.13,43.67 28.45,43.67 27.74,44.37 27.42,44.37 26.11,45.68 16.84,45.68 15.1,47.42 15.1,51.54 5.62,61.01 v2(3.84,61.01)
  IN2 w0.508: v2(60.87,19.41) 60.56,19.1 57.99,19.1 56.87,17.98 56.08,17.98 54.32,16.21 ; 54.31,15.56 54.31,13.35 54.81,12.85 v2(58.54,12.85)
  BOTTOM w0.203: 59.52,20.56 59.45,20.62 58.48,20.62 58.4,20.54 UL1.11 ; CL5.1 53.17,22.97 53.66,22.48 UL1.32
  BOTTOM w0.254: v2(3.84,61.01) 3.23,60.4 LED4.2
  BOTTOM w0.356: CL9.1 59.52,20.56
  BOTTOM w0.381: CL5.1 51.62,22.97 CL19.1 51.37,23.76 v2(51.29,23.84)
  BOTTOM w0.508: UL2.1 v2(58.54,12.85) ; DM12.5 49.26,26.81 v2(49.13,26.94) ; CL9.1 60.09,20.56 CL20.1 60.43,20.77 60.87,20.34 v2(60.87,19.41) ; DM13.5 v2(49.14,33.16)
  vias: v2(53.68,15.87) v2(53.68,15.31) v3(51.45,20.19)
+LCDVDD: length 14.7
  TOP w0.254: CV4.1 69.93,32.74 70.84,33.65 v3(72.79,33.65) 76.46,33.65 76.8,33.99 76.8,36.84 v3(76.49,37.15) 76.49,37.88 76.79,38.18 77.8,38.18 78.01,38.39 CV2.1 RV49.1
  vias: v2(68.92,33.04) v2(68.92,32.41) v2(68.92,31.77) v2(69.19,33.62) v3(69.69,34.16)
+MIC2_VREFO: length 1.5
  TOP w0.203: 296.02,24.92 UA1.28
  TOP w0.305: 296.02,24.92 296.02,25.53 RA4.1
+PD_CC1: length 61.5
  TOP w0.203: CU67.1 48.62,37.69 48.21,38.1 48.21,39.01 47.94,39.28 UU4.24 ; v2(8.72,53.01) 8.69,52.98 7.98,52.98 7.77,53.19 JUSBC1.A5
  TOP w0.254: 16.77,47.22 16.55,47.44 DU3.1 DU3.10 14.27,47.44 v2(13.95,47.12)
  TOP w0.305: v2(18.69,48.4) v3(17.51,47.22) 16.77,47.22 ; v2(47.32,36.33) 47.52,36.33 48.03,36.83 48.03,37.01 48.35,37.33 48.45,37.33 CU67.1
  IN1 w0.305: v2(13.95,47.12) 14.43,47.6 14.43,49.15 13.95,49.62 13.95,50.64 13.61,50.98 13.61,53.05 12.08,54.58 8.76,54.58 8.26,54.08 8.26,53.46 v2(8.72,53.01)
  IN2 w0.305: v2(18.69,48.4) 18.94,48.66 20.32,48.66 22.21,46.77 27.06,46.77 27.82,46.01 30.65,46.01 32.21,44.45 34.94,44.45 37.07,42.32 37.07,38.8 39.12,36.75 43.92,36.75 44.63,36.05 47.04,36.05 v2(47.32,36.33)
+PD_CC2: length 67.1
  TOP w0.203: UU4.26 48.74,39.53 49.34,38.94 50.14,38.94 50.36,38.72
  TOP w0.254: 16.74,47.94 DU3.2 DU3.9 13.72,47.94 v2(13.4,47.62)
  TOP w0.305: 50.36,38.72 50.62,38.46 CU66.1 50.64,38.15 51.74,37.05 51.74,36.25 v3(51.2,35.7) v2(50.33,35.7) ; v2(17.59,48.23) 17.3,47.94 16.74,47.94
  IN1 w0.114: JUSBC1.B5 5.82,51.14 5.89,51.03 5.99,50.85 6.26,50.44 6.34,50.44
  IN1 w0.305: v2(13.4,47.62) 13.34,47.62 11.32,49.64 v2(8.87,49.64) 8.04,49.64 7.24,50.44 6.34,50.44
  IN2 w0.305: v2(50.33,35.7) 50.33,35.58 49.32,34.57 48.5,34.57 47.59,35.49 44.3,35.49 43.59,36.19 38.87,36.19 36.78,38.28 36.17,38.28 35.74,38.71 35.74,42 35.27,42.47 35.27,43.28 34.5,44.05 31.82,44.05 30.42,45.45 27.59,45.45 26.83,46.22 21.84,46.22 20,48.05 19.19,48.05 18.99,47.84 17.89,47.84 17.59,48.14 v2(17.59,48.23)
  IN3 w0.114: JUSBC1.B5 5.82,51.14 5.89,51.03 5.99,50.85 6.26,50.44 6.34,50.44
  IN3 w0.305: 6.34,50.44 8.07,50.44 v2(8.87,49.64)
+RTCBATT_R: length 3.9
  TOP w0.127: DH1.2 176.77,13.49 176.28,13.98 v1(175.66,13.98)
  TOP w0.508: RH92.1 DH1.2
+USB_VCC2:
  vias: v2(20.12,91.84) v2(20.13,91.28) v2(20.61,92.15) v2(20.62,91.6) v2(21.69,85.88) v2(21.69,85.24) v2(22.94,86.08) v2(22.94,85.52) v3(20.57,92.94)
+V_DAC: length 16.8
  TOP w0.508: CL1.2 48.42,32.54 v2(48.45,32.5) ; CL1.2 v1(47.66,30.91) 47.66,30.3 v2(48.45,29.5) 47.66,28.7 CL4.1 48.39,26.44 v2(48.45,26.5) ; CL1.2 47.66,33.23 48.65,34.23 v2(48.65,35.2)
  BOTTOM w0.508: TSL1.1 48.35,35.5 v2(48.65,35.2) ; TSL1.4 v2(48.45,32.5) ; TSL1.10 v2(48.45,26.5) ; TSL1.7 v2(48.45,29.5)
+VGA_CORE: length 45.2
  TOP w0.508: v2(209.91,86.44) 210.37,86.9 PCV43.1
  IN1 w0.254: v2(232.83,58.87) 231.81,59.89 226.91,59.89 225.15,61.64 224.79,61.64 224.68,61.53 223.91,61.53 223.03,62.41 219.23,62.41 218.92,62.1 217.99,62.1 217.16,62.93 217.16,67.15 216.79,67.51 v2(215.32,67.51)
  IN3 w0.254: v2(232.96,41.83) 233.35,42.22 233.35,47.54 232.98,47.91 232.98,48.47 v2(233.25,48.74)
  BOTTOM w0.254: v2(232.96,41.83) 233.54,41.83 RG40.1 ; v2(232.83,58.87) 232.44,58.87 PRV22.1 232.49,58.25 232.86,58.25 233.38,57.73 233.38,55.35 232.97,54.93 232.97,52.29 232.96,52.28 232.96,51.09 233.64,50.41 233.64,49.13 v2(233.25,48.74)
  vias: v2(194.14,66.83) v2(194.14,66.19) v2(194.37,68.17) v2(194.37,67.59) v2(194.81,66.66) v2(194.81,66.08) v2(194.81,65.5) v2(195.02,69.08) v2(195.02,68.49) v2(195.02,67.91) v2(195.02,67.33) v2(195.4,66.66) v2(195.4,66.08) v2(195.4,65.5) v2(195.63,71.11) v2(195.61,70.48) v2(195.61,69.82) v2(196.2,69.82) v2(196.45,71.84) v2(196.78,69.82) v2(196.98,72.21) v2(196.98,71.62) v2(196.98,71.04) v2(196.98,70.46) v2(197.37,69.82) v2(197.55,70.76) v2(197.95,69.82) v2(198.38,72.68) v2(198.38,72.05) v2(198.38,71.41) v2(198.54,69.82) v2(199.12,69.82) v2(199.28,69.23) v2(199.28,68.65) v2(199.28,68.06) v2(199.28,67.48) v2(199.7,69.82) v2(199.87,69.23) v2(199.87,68.65) v2(199.87,68.06) v2(199.87,67.48) v2(200.29,69.82) v2(200.45,69.23) v2(200.45,68.65) v2(200.45,68.06) v2(200.45,67.48) v2(201.07,92.46) v2(201.05,86.41) v2(201.08,84.44) v2(201.16,94.44) v2(201.25,90.45) v2(201.25,82.64) v2(201.35,72.75) v2(201.46,69.82) v2(201.57,69.23) v2(201.57,68.65) v2(201.57,68.06) v2(201.57,67.48) v2(201.62,66.89) v2(201.66,83.1) v2(201.93,90.38) v2(202.04,69.82) v2(202.08,87.37) v2(202.19,88.42) v2(202.19,71.92) v2(202.17,71.35) v2(202.17,70.76) v2(202.15,69.23) v2(202.15,68.65) v2(202.15,68.06) v2(202.15,67.48) v2(202.2,66.89) v2(202.27,93.45) v2(202.27,92.47) v2(202.33,91.45) v2(202.63,69.82) v2(202.73,75.36) v2(202.71,74.78) v2(202.69,74.09) v2(202.75,73.31) v2(202.75,72.73) v2(202.74,69.23) v2(202.74,68.65) v2(202.74,68.06) v2(202.74,67.48) v2(202.82,77.76) v2(202.79,76.92) v2(202.78,71.92) v2(202.76,71.35) v2(202.76,70.76) v2(202.79,66.89) v2(202.93,88.35) v2(203.06,94.54) v2(203.09,84.49) v2(203.21,69.82) v2(203.34,71.35) v2(203.34,70.76) v2(203.41,74.61) v2(203.42,73.97) v2(203.36,71.92) v2(203.46,75.24) v2(203.57,78.56) v2(203.63,77.76) v2(203.63,76.94) v2(203.6,76.18) v2(203.79,69.82) v2(203.93,85.41) v2(204.01,87.31) v2(204.08,93.44) v2(204.06,91.63) v2(204.15,83.54) v2(204.09,75.18) v2(204.12,74.56) v2(204.12,73.99) v2(204.09,73.34) v2(204.1,72.74) v2(204.36,82.45) v2(204.36,81.84) v2(204.38,81.01) v2(204.43,80.15) v2(204.42,79.38) v2(204.39,78.52) v2(204.44,77.76) v2(204.39,76.94) v2(204.42,76.21) v2(204.38,69.82) v2(204.57,83.02) v2(204.74,73.98) v2(204.78,75.21) v2(204.76,74.56) v2(204.97,82.58) v2(204.95,81.98) v2(204.96,69.82) v2(205.07,93.61) v2(205.08,92.22) v2(205.13,91.58) v2(205.1,87.56) v2(205.07,86.28) v2(205.08,84.44) v2(205.08,83.44) v2(205.24,80.25) v2(205.21,79.41) v2(205.23,77.78) v2(205.26,81.11) v2(205.25,78.54) v2(205.25,76.97) v2(205.25,76.18) v2(205.39,75.21) v2(205.38,74.56) v2(205.35,73.98) v2(205.55,69.82) v2(206.04,91.52) v2(206.04,77.73) v2(206.04,76.94) v2(206.04,76.16) v2(206.03,75.22) v2(206.02,74.57) v2(205.99,73.95) v2(206.08,93.44) v2(206.09,87.56) v2(206.09,78.53) v2(206.13,69.82) v2(206.25,89.47) v2(206.68,83.03) v2(206.71,69.82) v2(206.8,91.45) v2(206.93,78.54) v2(207.04,92.27) v2(207.03,89.44) v2(207.02,69.11) v2(207.02,68.53) v2(207.02,67.94) v2(207.12,90.4) v2(207.08,88.7) v2(207.08,88.15) v2(207.15,86.25) v2(207.09,73.95) v2(207.09,73.3) v2(207.1,72.73) v2(207.22,85.49) v2(207.24,83.46) v2(207.27,84.45) v2(207.3,69.82) v2(207.5,82.93) v2(207.6,69.11) v2(207.6,68.53) v2(207.6,67.94) v2(207.89,72.28) v2(207.89,71.71) v2(207.9,71.13) v2(207.9,70.55) v2(207.88,69.82) v2(208.11,93.47) v2(208.08,90.44) v2(208.08,87.44) v2(208.08,85.44) v2(208.18,91.35) v2(208.18,69.11) v2(208.18,68.53) v2(208.18,67.94) v2(208.44,73.33) v2(208.45,72.74) v2(208.45,72.16) v2(208.46,71.59) v2(208.46,71) v2(208.87,83.37) v2(208.87,82.78) v2(209.01,90.38) v2(209.03,84.55) v2(209.08,94.69) v2(209.06,88.61) v2(209.3,69.11) v2(209.3,68.53) v2(209.3,67.94) v2(209.64,69.82) v2(209.82,71.51) v2(209.81,70.94) v2(209.94,93.48) v2(209.91,92.43) v2(209.89,69.11) v2(209.89,68.53) v2(209.89,67.94) v2(210.03,87.49) v2(210.08,91.55) v2(210.08,85.44) v2(210.23,83.28) v2(210.22,69.82) v2(210.47,69.11) v2(210.47,68.53) v2(210.47,67.94) v2(210.8,69.82) v2(211.18,94.34) v2(211.21,92.41) v2(211.31,86.44) v2(211.39,69.82) v2(212,93.35) v2(211.97,69.82) v2(212.18,88.34) v2(212.35,91.42) v2(212.42,90.73) v2(212.56,69.82) v2(213.14,69.82) v2(214.74,68.68) v2(214.74,68.1) v2(214.74,67.51) v2(215.32,68.1) v3(193.07,65.86)
+VIO: length 1.9
  BOTTOM w0.127: CR17.1 40.21,20.03 40.61,19.63 UR1.18
AC_LED#: length 154.6
  TOP w0.127: UK1.34 152.16,10.22 152.6,10.66 v2(152.6,10.73) ; v1(280.56,25.56) 281.15,26.16 v2(281.15,26.41)
  IN2 w0.127: v2(281.15,26.41) 280.58,26.98 279.4,26.98 278.43,26.01 276.2,26.01 275.68,25.48 275.46,25.48 274.87,24.89 274.87,24.27 274.72,24.12 274.72,20.25 276.26,18.71 276.26,17.46 275.3,16.5 263.62,16.5 263.33,16.2 258.02,16.2 257.73,16.49 237.69,16.49 236.87,15.66 235.6,15.66 235.17,16.09 227.18,16.09 224.54,13.46 224.54,13.02 221.72,10.19 221.4,10.19 220.88,9.67 220.88,7.96 220.3,7.38 216.11,7.38 215.07,8.42 211.33,8.42 211,8.09 205.68,8.09 205.15,8.62 202.3,8.62 201.93,8.25 199.25,8.25 198.5,7.5 181.78,7.5 179.66,9.62 178.34,9.62 177.25,10.72 174.21,10.72 171.59,13.34 154.62,13.34 152.61,11.33 152.61,10.73 v2(152.6,10.73)
  BOTTOM w0.127: v2(281.15,26.41) 281.44,26.69 PR2.1 281.44,27.8 PR1.1
AC_PRESENT: length 81.5
  TOP w0.127: v2(172.04,11.6) 172.39,11.95 172.97,11.95 173.12,11.8 173.12,11.69 173.18,11.63 v1(173.18,11.63) 173.3,11.5 175.02,11.5 177.54,8.99 184.25,8.99 186.28,6.96 191.89,6.96 192.56,7.63 192.56,8.46 191.84,9.18 191.47,9.18 191.44,9.21 191.37,9.21 191.06,9.51 RH46.2 ; v2(141.81,19.83) 141.5,20.14 138.8,20.14 138.28,20.66 138.28,21.44 138.61,21.77 138.61,22.88 138.44,23.05 UK1.93
  IN2 w0.127: v2(172.04,11.6) 169.82,11.6 168.36,13.07 155.82,13.07 152.74,9.98 v2(152.74,8.06)
  BOTTOM w0.127: v2(152.74,8.06) 151.65,8.06 150.35,6.76 143.58,6.76 140.15,10.19 140.15,16.8 142.12,18.77 142.12,19.52 v2(141.81,19.83)
AC_PRESENT_R: length 10.5
  TOP w0.127: v2(192.64,15.42) 192.79,15.57 193.34,15.57 193.62,15.29 193.62,14.84 v1(193.48,14.7) 192.93,14.16 192.93,13.68 192.49,13.23 192.49,11.16 191.98,10.65 RH45.1 RH46.1
  BOTTOM w0.127: v2(192.64,15.42) 192.64,15.74 193.38,16.47 193.38,16.86 194.21,17.7 UH1.BG42
ACCEL_INT#: length 52
  TOP w0.127: v2(177.2,50.68) 176.71,50.68 176.03,49.99 v1(176.03,49.6) D516.2
  TOP w0.135: RH181.1 198.07,18.12 v2(197.81,17.86)
  IN3 w0.127: v2(197.81,17.86) 197.81,19.37 198.12,19.68 198.12,20.98 197.79,21.31 197.79,24.13 197.38,24.54 195.96,24.54 195.01,25.49 194.23,25.49 194.06,25.32 191.79,25.32 190.21,26.9 190.21,30.5 191.79,32.09 191.79,33.67 186.87,38.59 186.87,40.6 184.89,42.58 184.89,45.4 180.39,49.89 177.98,49.89 v2(177.2,50.68)
  BOTTOM w0.127: v2(197.81,17.86) 197.81,18.26 UH1.BF35
ACCEL_INT#_R: length 3
  TOP w0.127: v1(176.24,44.93) 176.03,45.15 D516.1
  TOP w0.254: D516.1 176.53,46.47 U9.12
ACDRV: length 40.1
  TOP w0.203: PUB01.30 237.69,13.06 236.72,14.03
  TOP w0.381: v2(252.16,21.61) 251.45,21.61 v1(251.02,21.18) 250.86,21.02 250.86,18.72 248.3,16.17 241.76,16.17 241.59,16.33 237.47,16.33 236.72,15.58 236.72,14.03 ; PRB07.2 264.4,29.93 263.49,29.93 262.73,29.17 262.27,29.17 261.83,29.61 v2(261.83,29.71)
  IN3 w0.381: v2(252.16,21.61) 252.18,21.59 254.59,21.59 261.91,28.91 261.91,29.63 v2(261.83,29.71)
ACDRV_R: length 24.1
  TOP w0.508: PQB01.4 267.28,31.04 267.04,30.79 PCB01.2 266.72,29.45 266.54,29.63 PRB07.1 266.1,28.93 265.35,28.18 v1(264.91,28.18) 264.19,28.18 263.73,28.64 v2(263.73,29.13) ; PQB03.4 265.52,34.81 265.38,34.95 PCB02.2 263.94,36.29 263.47,36.76 263.47,37.31 263.07,37.71 PQB02.1 262.43,38.28 262.59,38.44 v2(262.78,38.44)
  IN3 w0.508: v2(262.78,38.44) 262.53,38.44 262.44,38.35 262.44,38.06 262.21,37.83 262.21,31.57 263.73,30.05 v2(263.73,29.13)
ACIN_BUF: length 20.6
  TOP w0.102: 212.53,73.63 209.73,76.44 209.73,77.11 209.41,77.42 v2(209.41,77.73)
  TOP w0.127: RG393.2 219.48,65.53 DG2.2 221.16,67.21 RG399.2 220.33,68.28 v1(217.1,68.28) 212.53,72.85 212.53,73.63
  BOTTOM w0.102: v2(209.41,77.73) 209.44,77.73 UG1.N3
ACIN_LED: length 13.7
  BOTTOM w0.127: PR1.2 282.25,26.91 283.3,25.85 285.28,25.85 PD2.3 287.27,27.84 v2(287.27,28.88) 287.27,29.11 285.97,30.4 285.97,32.37 PJP1.5
ACLIM: length 4.8
  TOP w0.203: PRB27.1 PRB29.1 242.6,7.22 241.96,7.22 241.74,7.43 240.11,7.43 239.69,7.85 PUB01.16
ACPVEE: length 3.2
  TOP w0.127: CA23.2 298.33,25.73 299.12,26.51 v1(299.12,26.67)
  TOP w0.203: CA23.2 298.28,25.6 297.22,24.54 UA1.25
ADP_I: length 27.1
  TOP w0.127: v2(133.72,21.95) 133.67,22.01 133.67,23.07 v1(133.39,23.34) ; UK1.65 149.64,23.06 149.18,22.61 v2(149.18,22.4) 149.84,22.4 150.52,23.09 151.38,23.09 153.36,25.07 154.04,25.07 PCB32.1 155.41,25.6 PRB40.1
  BOTTOM w0.127: v2(133.72,21.95) 134.99,21.95 135.48,21.46 135.91,21.46 135.91,21.46 138.54,21.46 138.91,21.84 142.28,21.84 142.45,22.01 145.81,22.01 146.25,21.58 148.36,21.58 v2(149.18,22.4)
ADP_I_R: length 98.5
  TOP w0.127: v2(177.31,6.36) 177.31,6.71 176.86,7.16 176.78,7.16 174.26,9.67 171.53,9.67 162.71,18.49 162.71,20.4 158.87,24.24 158.87,25.18 156.83,27.22 155.55,28.5 154.81,28.5 154.58,28.27 v1(154.58,27.72) 155.41,26.88 PRB40.2 ; PUB01.6 235.54,9.83 235.36,9.65 233.17,9.65 231.4,11.41 v2(231.4,11.81)
  IN3 w0.127: v2(222.4,6.61) 222.81,7.02 224.33,7.02 228.24,10.93 230.52,10.93 v2(231.4,11.81)
  BOTTOM w0.127: v2(177.31,6.36) 177.47,6.2 220.99,6.2 221.4,6.61 v2(222.4,6.61)
ADP_ID: length 214.6
  TOP w0.127: v2(279.21,11.88) 279.21,12.55 278.5,13.26 278.5,15.14 280.41,17.04 v1(280.41,18.98) 280.41,21.18 278.46,23.12 278.46,23.91 278.6,24.04 278.6,26.36 280.14,27.9 281.46,27.9 283.47,29.91 292.06,29.91 292.74,30.59 292.74,35.04 291.89,35.88 290.3,35.88 290.19,35.77 287.19,35.77 285.73,37.23 PD3.1 285.73,39.35 286.21,39.83 PR5.1 PC5.1 PC6.1 PR3.2 ; UK1.75 145.64,21.35 v2(145.39,21.11)
  IN3 w0.127: v2(225.09,8.71) 225.61,8.71 228.1,11.2 230.19,11.2 231.31,12.31 234.05,12.31 234.81,13.07 238.16,13.07 239.36,14.27 240.88,14.27 240.94,14.22 245.16,14.22 246.09,15.14 257.04,15.14 257.88,14.3 263.87,14.3 265.09,15.51 274.53,15.51 275.26,14.79 275.26,13.98 277.73,11.5 278.83,11.5 v2(279.21,11.88)
  BOTTOM w0.127: v2(225.09,8.71) 225.11,8.69 225.11,7.35 223.13,5.38 170.24,5.38 169.5,6.11 169.5,9.41 167.17,11.74 164.7,11.74 163.1,13.34 151.98,13.34 150.06,11.43 144.91,11.43 143.22,13.12 143.22,15.38 145.49,17.65 146.43,17.65 146.69,17.91 146.69,19.8 v2(145.39,21.11)
ADP_SIGNAL: length 11.9
  TOP w0.135: PJP1.6 285.96,32.34 285.96,36.5 v3(285.16,37.3) 283.33,37.3 282.86,37.77 PD1.3 284,38.73 PR3.1
ALL_GPWRGD: length 8.7
  BOTTOM w0.127: QG1.2 184.12,83.13 183.55,82.56 182.21,82.56 v1(182.2,82.55) 182,82.34 182,79.37 183.11,78.26 RG83.1 183.84,78.12 184.14,77.81 UG11.4
AMIC2_CAP: length 3.4
  TOP w0.127: v1(293.35,26.74) 293.35,26.1 293.67,25.78 CA5.2
  TOP w0.135: UA1.32 294.42,25.16 294.47,25.21 CA5.2
B/I#: length 169.3
  TOP w0.127: v2(175.59,6.49) 175.59,7 174.61,7.99 173.96,7.99 173.06,8.89 171.2,8.89 161.92,18.17 161.92,19.86 158.57,23.21 154.59,23.21 v1(154.44,23.37) 153.86,23.37 152.32,21.82 UK1.63 ; v2(238.38,7.16) 238.49,7.28 PUB01.13 ; PR16.2 283.27,15.43 PR17.2 283.35,14.63 283.84,14.15 284.81,14.15 285.06,13.89 286.58,13.89 287.15,13.32 287.15,12.62 284.74,10.21 283.49,10.21 282.9,10.8 v2(282.9,11.22)
  IN3 w0.127: v2(221.84,6.19) 222.12,5.92 223.99,5.92 228.46,10.39 231.35,10.39 234.58,7.16 v2(238.38,7.16) 238.38,8.12 237.97,8.52 236.87,8.52 236.39,9 236.39,11.88 236.7,12.19 238.42,12.19 239.7,13.47 240.55,13.47 240.6,13.41 245.5,13.41 246.42,14.33 256.71,14.33 257.55,13.49 264.21,13.49 265.42,14.7 273.39,14.7 277.4,10.7 282.39,10.7 v2(282.9,11.22)
  BOTTOM w0.127: v2(175.59,6.49) 176.14,5.94 221.6,5.94 v2(221.84,6.19)
BAT_CHG_LED: length 194
  TOP w0.127: v2(143.03,19.85) 142.28,20.6 138.99,20.6 138.74,20.85 138.74,21.25 139.78,22.3 139.78,22.88 139.64,23.03 UK1.90
  IN2 w0.127: v2(281.02,24.9) 279,22.88 279,18.61 279.72,17.89 279.72,15.01 279.28,14.56 275.45,14.56 274.9,15.11 265.64,15.11 264.66,14.14 257.35,14.14 256.46,15.03 248.04,15.03 247.59,14.57 240.62,14.57 240.39,14.8 237.91,14.8 236.79,13.68 231.88,13.68 230.84,14.72 228.69,14.72 226.25,12.28 226.25,11.41 225.78,10.95 225.78,8.79 222.76,5.77 190.33,5.77 190.33,5.77 172.76,5.77 167.64,10.88 156.7,10.88 154.97,9.15 154.97,6.29 154.75,6.07 154.75,5.68 v2(155.07,5.36)
  BOTTOM w0.127: v2(281.02,24.9) 281.02,24.91 280.43,25.5 v1(280.43,25.62) 279.89,26.16 279.89,28.46 280.22,28.79 PR6.1 280.56,28.8 PR4.1 ; v2(143.03,19.85) 143.03,18.95 140.67,16.59 140.67,10.41 143.8,7.29 150.14,7.29 151.83,8.98 153.85,8.98 154.77,8.06 154.77,5.83 155.07,5.52 v2(155.07,5.36)
BAT_GATE: length 32
  TOP w0.203: PUB01.25 239.69,12.88
  TOP w0.254: 239.69,12.88 239.86,13.05
  TOP w0.381: 239.86,13.05 v2(240.39,13.05)
  BOTTOM w0.381: PQB04.4 265.2,11.2 265.07,11.33 PCB12.1 265.07,13.09 264.51,13.64 259.57,13.64 259.14,13.22 255.88,13.22 255.01,12.34 255.01,10.83 254.61,10.44 253.08,10.44 252.35,11.16 242.36,11.16 242.14,11.38 242.12,11.38 241.94,11.57 241.94,11.59 241.76,11.77 241.75,11.77 241.74,11.78 241.74,12.49 v1(241.18,13.05) v2(240.39,13.05)
BOARD_ID: length 8.4
  TOP w0.127: 153.68,25.64 RK4.2 ; 153.68,25.64 153.68,25.73 153.19,26.22 153.19,26.95 v1(152.52,27.62) ; 153.68,25.64 RK2.1 152.71,25.24 152.4,24.93 149.46,24.93 149.24,24.71 UK1.66
BST_1.35VSDGPUP: length 3.1
  BOTTOM w0.127: PRW2.1 238.63,50.46 238.17,50 238.17,48.69 238.64,48.22 v1(238.64,47.98)
BST_1V05: length 4
  BOTTOM w0.127: PR1009.1 236.47,30.2 235.49,31.19 v1(234.59,31.19)
  BOTTOM w0.254: PR1009.1 236.47,29.64 236.92,29.2 PU1001.1
BST_1V05_R: length 1.8
  BOTTOM w0.127: PC1002.1 v1(233.73,30.15)
  BOTTOM w0.254: PC1002.1 235.14,30.15 235.18,30.12 PR1009.2
BST_3V_R: length 3.5
  BOTTOM w0.127: PC302.1 244.91,28.31 244.56,28.66 243.54,28.66 243.16,28.28 v1(243.16,27.14)
BST_5V: length 2.8
  TOP w0.127: v2(78.29,7.08) 78.62,6.76 v1(78.62,6.28)
  TOP w0.508: PR305.1 77.88,6.67 v2(78.29,7.08)
  BOTTOM w0.254: v2(78.29,7.08) 78.05,6.83 PU302.13
BST_5V_R: length 2
  TOP w0.127: v1(77.04,7.66) 76.55,7.17 PR305.2
  TOP w0.508: PR305.2 75.76,6.67 PC313.1
BST_CHG_R: length 6.5
  TOP w0.508: PRB13.2 244.03,13.18 v1(244.56,13.18) 244.73,13.35 245.5,13.35 245.95,12.89 245.95,12.35 PDB03.1 245.14,11.53 PCB17.1
BST_DDR: length 2.6
  BOTTOM w0.203: PUM1.18 91.65,29.11 91.8,29.26 v1(91.8,29.72) 91.8,30.25
  BOTTOM w0.508: 91.8,30.25 91.8,30.81 PRM1.2
BST_DDR_R: length 1.2
  BOTTOM w0.127: v1(89.12,31.87) 89.12,31.69 PCM4.1
BST_GT: length 3.3
  TOP w0.127: PRG1.1 v1(119.81,92.68)
  TOP w0.254: PRG1.1 119.54,93.9 PUG1.1
BST_GT_R: length 2.5
  TOP w0.127: v1(114.71,93.29) PCG5.1
  TOP w0.508: PRG1.2 116.34,92.68 PCG5.1
BST_PH1: length 1.4
  BOTTOM w0.127: v1(149.31,136.43) 149.64,136.1 PRZ79.1
BST_PH1_R: length 2.3
  BOTTOM w0.127: v1(148.48,135.24) 149.62,135.24 150.16,134.71 PRZ79.2
BST_PH2: length 1.4
  BOTTOM w0.127: PRZ82.1 142.13,136.1 v1(141.74,136.5)
BST_PH2_R: length 2.1
  BOTTOM w0.127: PRZ82.2 142.27,134.71 141.64,135.34 v1(141.15,135.34)
BST_PH3: length 1.3
  BOTTOM w0.127: PRZ85.1 134.5,136.1 v1(134.14,136.46)
BST_PH3_R: length 1.9
  BOTTOM w0.127: PRZ85.2 135.01,134.71 134.43,135.28 v1(133.63,135.28)
BST_PH4: length 1.3
  BOTTOM w0.127: PRZ88.1 126.95,136.1 v1(126.76,136.29)
BST_PH4_R: length 1.2
  BOTTOM w0.127: PRZ88.2 v1(126.73,134.71)
BST_VCCIOP:
  vias: v2(186.8,104.21)
BST_VCCIOP_R: length 1.8
  BOTTOM w0.127: PCH4.1 v1(188.36,105.94)
  BOTTOM w0.254: PCH4.1 188.36,104.56 188.34,104.54 PRH3.2
BST_VCCSA: length 1.5
  BOTTOM w0.127: v1(158.51,135.48) 158.07,135.04 PRA1.1
BST_VCCSA_R: length 4
  BOTTOM w0.127: v1(157.13,135.39) 157.13,133.78 158.07,132.84 PRA1.2
  BOTTOM w0.508: PRA1.2 PCA5.1
BT_ON: length 136.6
  TOP w0.127: RH179.2 206.16,18.23 206.16,19.26 RH272.2 205.48,19.73 204.68,20.53 v2(204.61,20.53) ; v2(286.19,5.57) v1(285.64,5.57)
  IN1 w0.127: v2(286.19,5.57) 283.49,5.57 275.36,13.7 275.36,14.29 274.58,15.07 267.83,15.07 267.44,14.67 264.87,14.67 264.15,13.95 257.5,13.95 256.91,14.54 248.08,14.54 247.41,13.86 234.46,13.86 234.13,13.53 226.23,13.53 225.94,13.82 224.91,13.82 223.64,12.55 221.96,12.55 221.55,12.13 215.78,12.13 215.16,12.76 213.47,12.76 213.09,12.38 211.91,12.38 210.92,13.37 209.19,13.37 205.95,16.61 205.95,19.51 205.57,19.9 205.42,19.9 205.17,20.14 205.17,20.29 204.93,20.53 v2(204.61,20.53)
  IN3 w0.127: v2(286.19,5.57) 286.74,6.12 288.05,6.12 288.98,5.19 300.15,5.19 300.99,6.04 304.28,6.04 306.74,8.5 306.74,9 v2(309.08,11.35) ; v2(198.84,13.61) 199.6,14.37 200.46,14.37 200.74,14.66 200.74,16.6 201,16.85 201.38,16.85 201.5,16.72 202.71,16.72 204.17,18.18 204.17,20.09 v2(204.61,20.53)
  BOTTOM w0.127: v2(309.08,11.35) JWLAN1.46 ; RH271.1 199.34,14.12 v2(198.84,13.61)
BT_ON_R: length 3.5
  BOTTOM w0.127: RH271.2 199.34,17.17 199.15,17.36 199.15,18.06 199.11,18.1 UH1.BF32
CAP_LOCK#: length 85.1
  TOP w0.127: UK1.91 139.24,23.05 139.53,22.76 139.53,22.37 138.51,21.35 138.51,20.76 138.9,20.37 141.92,20.37 v2(142.45,19.84) ; v2(172.68,11.54) 172.97,11.24 174.91,11.24 177.43,8.72 181.36,8.72 181.44,8.64 v1(182.99,8.64) 184.23,8.64 186.17,6.7 197.39,6.7 C390.1 R5237.1
  IN2 w0.127: v2(172.68,11.54) 172.29,11.15 169.75,11.15 168.11,12.79 155.94,12.79 153.18,10.03 v2(153.18,8.44)
  BOTTOM w0.127: v2(142.45,19.84) 142.45,18.73 140.41,16.7 140.41,10.3 143.69,7.02 150.25,7.02 151.75,8.53 153.09,8.53 v2(153.18,8.44)
CATERR#: length 1.2
  TOP w0.127: TC96.1 129.68,103.59 v2(130.32,103.59)
  BOTTOM w0.135: UC1.BM30 v2(130.32,103.59)
CBN: length 5
  TOP w0.127: CA98.1 300.06,26.26 v1(300.55,26.76)
  TOP w0.203: UA1.24 298.27,23.43 298.33,23.49 298.33,23.92 298.79,24.38 298.79,25.42 299.17,25.8 CA26.1 CA98.1
CBP: length 4.6
  TOP w0.127: v1(300.89,25.47) 300.64,25.22 CA98.2
  TOP w0.203: UA1.23 298.48,23.03 298.74,23.3 298.74,23.8 299.42,24.48 CA26.2 CA98.2
CFG0: length 5.7
  BOTTOM w0.102: RC31.1 v2(124.99,98.78) 125.38,98.78 126.37,99.77 126.65,99.77 127.16,100.28 128.94,100.28 UC1.BN25
CFG2: length 5.5
  BOTTOM w0.102: RC32.1 124.39,99.5 v1(125.29,99.5) 125.61,99.5 126.27,100.16 126.72,100.16 127.05,100.49 128.94,100.49 UC1.BN26
CFG4: length 4.1
  BOTTOM w0.102: 125.99,96.16 126.11,96.04 126.73,96.04 127.05,96.36 127.63,96.36 UC1.BR20
  BOTTOM w0.127: 125.99,96.16 125.71,96.45 v1(125.24,96.45) RC33.1
CFG5: length 7.1
  BOTTOM w0.127: RC36.1 v1(125.24,94.82) 129.88,94.82 130.19,95.13 130.19,95.75 UC1.BM20
CFG6: length 3.2
  BOTTOM w0.127: RC34.1 v2(124.97,95.58) 126.81,95.58 UC1.BT20
CFG7: length 4.9
  BOTTOM w0.102: UC1.BP20 128.09,96.55 126.97,96.55 126.8,96.38 126.43,96.38 126.12,96.7
  BOTTOM w0.127: 126.12,96.7 125.75,97.06 v2(125.02,97.06) 124.45,97.06 RC35.1
CFG_RCOMP: length 3.8
  BOTTOM w0.102: RC19.1 v1(125.21,98) 125.29,98 UC1.BT25
CHARGE_LED: length 7.5
  BOTTOM w0.127: PJP1.8 284.95,29.94 286.01,28.88 PD2.2 285.08,28.51 v2(284.71,28.88) 284.26,28.42 282.63,28.42 PR4.2
CHG_ACIN: length 4.1
  TOP w0.203: PUB01.1 235.77,11.83 v2(235.54,12.07)
  BOTTOM w0.127: v2(235.54,12.07) v1(235.54,12.78)
  BOTTOM w0.254: v2(235.54,12.07) 235.67,11.93 PRB12.1 235.67,11.35 236.24,10.78 PCB16.1 236.22,10.53 PRB10.2
CHG_CCLIM: length 2.9
  TOP w0.203: PRB30.1 236.89,6.93 237.69,7.73 PUB01.11
  TOP w0.254: PRB28.2 PRB30.1
CHG_COMP: length 4.7
  TOP w0.203: PUB01.10 237.29,7.8 237.09,7.6 235.43,7.6 PCB26.1 235.22,6.73 PRB31.1
CHG_COMP_R: length 3.5
  TOP w0.127: v1(232.52,5.37) 232.87,5.01 233.84,5.01 234.55,5.72 PCB27.1
  TOP w0.254: PCB27.1 234.96,5.84 235.14,5.66 PRB31.2
CHG_DCIN: length 5.7
  BOTTOM w0.127: v1(240.74,6.76) PRB11.1
  BOTTOM w0.508: v2(241.67,8.83) 241.67,9.49 241.35,9.81 PCB14.1 ; PRB11.1 240.74,9.29 240.86,9.4 PCB14.1 ; PCB14.1 240.86,9.82 PCB36.1
CHG_DCIN_R: length 4.1
  BOTTOM w0.127: PRB11.2 237.96,8.24 237.96,6.62 v1(237.98,6.6)
  BOTTOM w0.508: PRB11.2 237.75,8.67 236.82,8.67 PDB01.1
CHG_FSET: length 2
  TOP w0.203: PRB34.1 237.66,7.21 238.09,7.65 PUB01.12
CHG_NTC: length 2.4
  TOP w0.203: PUB01.17 240.65,9.03 241.32,8.36 v1(241.36,8.36) 241.91,8.36 242.19,8.65 PRB18.1
CHG_NTC_R: length 0.8
  TOP w0.203: PRB18.2 PRB19.1
CHG_PHASE: length 19.4
  TOP w0.508: v2(258.59,6.89) PRB21.1
  IN3 w0.635: v2(241.5,11.19) 241.69,11.38 243.13,11.38 243.78,10.73 250.83,10.73 253.65,7.91 256.81,7.91
  BOTTOM w0.127: v1(240.24,11.88) 240.81,11.88 v2(241.5,11.19)
  vias: v2(253.92,9.8) v2(253.92,9.21) v2(253.92,8.63) v2(254.51,9.8) v2(254.51,9.21) v2(254.51,8.63) v2(258.55,8.31) v2(258.55,7.7)
CHG_PROCHOT: length 10
  TOP w0.127: v2(233.34,10.07) 233.5,9.91 235.19,9.91 235.51,10.23 PUB01.5
  BOTTOM w0.127: v2(233.34,10.07) 232.75,10.07 231.96,10.86 231.96,12.22 v1(231.83,12.35) 231.63,12.56 PDB02.1 228.92,12.56 228.86,12.62 PRB44.2
CHG_PROG: length 3.4
  TOP w0.127: v1(234.91,8.93) PRB35.1
  TOP w0.203: PRB35.1 236.82,7.95 236.89,8.02 PUB01.9
CHG_SRN: length 4.5
  TOP w0.203: PRB22.1 239.41,5.62 PCB22.2 239.33,6.55 PCB23.1 238.99,7.02 v2(238.99,7.16) 238.99,7.45 238.89,7.55 PUB01.14
  BOTTOM w0.127: v2(238.99,7.16) 238.99,6.91 v1(239.29,6.61)
CHG_SRP: length 5.6
  TOP w0.203: PUB01.15 239.29,7.7 239.91,7.08 241.57,7.08 PCB24.1 241.64,6.64 241.51,6.5 PRB20.1 240.35,6.5 PCB22.1
CHG_VDD: length 30.8
  TOP w0.203: PRB37.1 243.87,9.24 242.18,9.24 241.99,9.43 241.28,9.43 240.88,9.83 PUB01.19
  TOP w0.254: v2(235.01,4.81) 235.96,4.81 236.13,4.98 PRB28.1 ; v2(232.46,11.1) 232.22,11.1 231.99,11.32 231.99,11.91 233.07,12.99 PRB23.1 ; v2(243.23,5.59) 243.73,6.09 PRB27.2 244.43,6.24 244.95,6.77 v1(244.95,6.88) 244.95,7.09 244.03,8.01 PCB30.1 244.03,9.07 PRB37.1
  IN2 w0.254: v2(235.01,4.81) 234.38,5.43 234.38,6.79 232.46,8.72 v2(232.46,11.1)
  IN3 w0.254: v2(235.01,4.81) 235.76,5.56 240.41,5.56 241.13,4.84 242.88,4.84 243.23,5.19 v2(243.23,5.59)
CHG_VDDP: length 5
  TOP w0.381: PDB03.2 245.41,9.61 245.43,9.58 245.49,9.58 245.53,9.54 245.53,7.47 245.8,7.2 247.92,7.2 PCB35.1
  vias: v1(241.98,10.16)
CL_CLK: length 2.7
  BOTTOM w0.127: UH1.AR2 216.05,23.51 TH55.1
CL_DATA: length 5.4
  BOTTOM w0.127: TH56.1 217,23.24 216.81,23.42 216.27,23.42 216.1,23.26 213.93,23.26 213.86,23.19 212.44,23.19 UH1.AT5
CL_RST#: length 2
  TOP w0.127: TH57.1 211.93,23.14 v2(211.65,22.86)
  BOTTOM w0.122: v2(211.65,22.86) 211.7,22.81 212.73,22.81 UH1.AU4
CLK_CNV_PRX_DTX_N: length 124.1
  IN1 w0.135: v2(301.34,17.39) 301.49,17.39 301.65,17.23 301.65,16.23 301.94,15.95 302.19,15.95 302.27,15.87 302.27,15.57 301.92,15.23 301.57,15.23 301.3,15.49 300.64,15.49 300.38,15.23 299.07,15.23 298.56,14.71 298.37,14.71 298.09,14.99 297.67,14.99 297.24,14.56 297.24,14.14 297.52,13.86 297.52,13.67 297.39,13.55 293.36,13.55 293.25,13.44 292.02,13.44 291.72,13.14 291.72,12.79 291.58,12.66 291.21,12.66 291.08,12.79 291.08,13.14 290.78,13.44 290.34,13.44 290.05,13.16 289.5,13.16 289.36,13.29 289.36,14.06 289.07,14.36 288.46,14.36 288.16,14.05 288.16,12.73 288.07,12.64 287.61,12.64 287.48,12.78 287.48,14.29 287.12,14.64 286.22,14.64 286.02,14.85 286.02,14.98 286.43,15.39 286.43,15.84 285.98,16.29 285.59,16.29 284.77,15.47 284.53,15.47 284.24,15.76 284.24,16.05 284.68,16.48 284.68,17.24 284.28,17.64 283.91,17.64 283.58,17.31 283.15,17.31 282.96,17.5 282.96,18.01 283.41,18.46 283.41,19.05 280.67,21.79 279.28,21.79 277.75,23.32 274.08,23.32 272.06,25.35 264.99,25.35 264.1,26.23 256.47,26.23 251.94,30.77 248.48,30.77 246.98,32.27 236.34,32.27 235.51,31.44 231.71,31.44 231.07,30.8 226.52,30.8 222.1,26.38 222.1,21.95 220.25,20.1 216.93,20.1 216.7,20.33 216.01,20.33 215.84,20.16 213.43,20.16 213.19,19.79 v2(212.93,19.73)
  BOTTOM w0.102: UH1.BD4 212.97,19.69 v2(212.93,19.73)
  BOTTOM w0.127: v2(301.34,17.39) 301.5,17.55 301.5,17.65 301.27,17.88 301.27,19.22 301.65,19.6 JWLAN1.21
CLK_CNV_PRX_DTX_P: length 124.2
  IN1 w0.135: v2(302.11,17.39) 301.93,17.22 301.93,16.35 302.05,16.23 302.31,16.23 302.55,15.99 302.55,15.46 302.04,14.95 301.45,14.95 301.19,15.22 300.76,15.22 300.49,14.95 299.19,14.95 298.68,14.43 298.25,14.43 297.97,14.71 297.78,14.71 297.52,14.45 297.52,14.26 297.8,13.98 297.8,13.56 297.51,13.27 293.48,13.27 293.37,13.16 292.13,13.16 292,13.03 292,12.68 291.7,12.38 291.09,12.38 290.8,12.68 290.8,13.03 290.66,13.16 290.45,13.16 290.17,12.88 289.38,12.88 289.08,13.18 289.08,13.95 288.95,14.08 288.58,14.08 288.44,13.94 288.44,12.61 288.19,12.36 287.5,12.36 287.2,12.66 287.2,14.17 287.01,14.36 286.11,14.36 285.74,14.73 285.74,15.1 286.15,15.51 286.15,15.73 285.87,16.01 285.71,16.01 284.89,15.19 284.42,15.19 283.96,15.65 283.96,16.16 284.4,16.6 284.4,17.12 284.16,17.36 284.02,17.36 283.7,17.03 283.03,17.03 282.68,17.38 282.68,18.12 283.13,18.58 283.13,18.93 280.56,21.51 279.17,21.51 277.64,23.04 273.96,23.04 271.94,25.07 264.87,25.07 263.98,25.95 256.36,25.95 251.83,30.49 248.37,30.49 246.87,31.99 236.45,31.99 235.63,31.16 231.83,31.16 231.19,30.52 226.63,30.52 222.38,26.27 222.38,21.83 220.36,19.82 216.82,19.82 216.58,20.05 216.12,20.05 215.95,19.88 213.58,19.88 213.44,19.66 v2(213.51,19.37)
  BOTTOM w0.102: UH1.BE3 213.36,19.22 v2(213.51,19.37)
  BOTTOM w0.127: v2(302.11,17.39) 302.05,17.33 301.86,17.33 301.75,17.44 301.75,17.76 301.52,17.98 301.52,19.11 301.76,19.34 301.87,19.34 302.11,19.1 JWLAN1.23
CLK_CNV_PTX_DRX_N: length 133.7
  IN1 w0.135: v2(212.13,20.34) 212.28,20.2 212.38,20.2 213.06,20.88 215.45,20.88 215.64,21.07 216.98,21.07 217.23,20.81 219.95,20.81 221.38,22.25 221.38,26.68 226.22,31.52 230.77,31.52 231.41,32.16 235.21,32.16 236.04,32.99 247.28,32.99 248.78,31.49 252.26,31.49 256.79,26.95 264.4,26.95 265.28,26.06 272.35,26.06 274.38,24.04 278.07,24.04 279.6,22.51 281.01,22.51 288.44,15.07 289.52,15.07 290.39,14.21 291.38,14.21 291.72,14.55 296.15,14.55 297.78,16.18 298.79,16.18 301.73,19.12 302.78,19.12 303.65,19.99 306.38,19.99 306.94,19.42 306.94,17.94 307.37,17.51 307.37,13.04 308.18,12.23 308.18,8.35 305.78,5.95 305.78,5.73 v2(306,5.51)
  BOTTOM w0.102: v2(212.13,20.34) 212.09,20.3 212.09,19.89 UH1.BC5
  BOTTOM w0.127: v2(306,5.51) 305.91,5.6 305.91,6.37 305.34,6.93 303.81,6.93 303.65,7.1 JWLAN1.63
CLK_CNV_PTX_DRX_P: length 133.6
  IN1 w0.135: v2(211.59,19.87) 211.64,19.92 212.5,19.92 213.18,20.6 215.57,20.6 215.75,20.79 216.86,20.79 217.12,20.54 220.07,20.54 221.66,22.13 221.66,26.56 226.33,31.24 230.89,31.24 231.53,31.88 235.33,31.88 236.16,32.71 247.16,32.71 248.66,31.21 252.14,31.21 256.68,26.67 264.28,26.67 265.17,25.78 272.24,25.78 274.26,23.76 277.95,23.76 279.49,22.23 280.89,22.23 288.33,14.79 289.41,14.79 290.28,13.93 291.5,13.93 291.84,14.27 296.27,14.27 297.9,15.9 298.91,15.9 301.85,18.84 302.9,18.84 303.77,19.71 306.26,19.71 306.66,19.31 306.66,17.82 307.09,17.39 307.09,12.92 307.9,12.11 307.9,8.47 305.5,6.06 305.5,5.59 v2(305.41,5.51)
  BOTTOM w0.102: v2(211.59,19.87) 211.59,19.87 UH1.BB6
  BOTTOM w0.127: v2(305.41,5.51) 305.28,5.51 305.22,5.57 305.22,5.77 305.36,5.92 305.56,5.92 305.65,6.01 305.65,6.26 305.24,6.68 303.79,6.68 303.71,6.6 JWLAN1.65
CLK_PCI_LPC: length 74.1
  TOP w0.127: RH27.2 194.48,16.62 v2(194.37,16.74) v1(194.37,17.28) ; UK1.12 141.64,10.49 144.09,12.94 144.09,14.11 144.4,14.42 146.54,14.42 147.87,15.76 v2(147.87,16.63)
  IN3 w0.127: v2(194.37,16.74) 194.37,17.08 194.07,17.38 192.95,17.38 192.8,17.52 192.8,17.89 192.97,18.06 194.49,18.06 194.6,18.18 194.6,18.54 194.48,18.66 193.26,18.66 192.93,18.99 192.93,19.2 193.06,19.33 193.97,19.33 194.22,19.57 194.22,20.78 193.86,21.14 191.86,21.14 191.22,20.5 187.76,20.5 186.43,19.17 186.43,18.03 186.22,17.82 182.59,17.82 181.58,18.82 175.11,18.82 174.4,19.53 172.56,19.53 172.42,19.39 164.84,19.39 164.7,19.52 160.5,19.52 160.25,19.28 158.5,19.28 158.25,19.52 155.09,19.52 154.88,19.31 154.4,19.31 153.99,19.72 153,19.72 150.07,16.79 148.04,16.79 v2(147.87,16.63)
CLK_PCIE_N1: length 127.7
  IN1 w0.135: v2(307.12,23.18) 307.12,23.03 306.97,22.88 303.56,22.88 301.8,21.13 299.58,21.13 297.04,18.59 295.18,18.59 294.79,18.2 289.11,18.2 287.7,19.61 287.7,21.81 284.44,25.07 281.85,25.07 281.24,25.68 280.67,25.68 278.09,28.25 275.62,28.25 274.86,29.01 266.63,29.01 264.69,30.95 258.16,30.95 254.59,34.52 253.84,34.52 253.44,34.92 251.31,34.92 250.89,35.35 235.08,35.35 234.23,34.5 230.44,34.5 229.81,33.87 224.46,33.87 220.65,30.06 218.69,30.06 217.83,29.2 216.97,29.2 216.52,28.75 215.77,28.75 215.62,28.89 215.22,28.89 215.07,28.75 214.06,28.75 213.4,28.09 213.2,28.09 212.91,27.8 212.91,27.6 212.75,27.44 211.56,27.44 211.16,27.04 210.51,27.04 210.41,27.14 210.41,27.39 210.51,27.49 v2(210.6,27.49)
  BOTTOM w0.089: v2(210.6,27.49) 210.42,27.31 UH1.AH9
  BOTTOM w0.127: v2(307.12,23.18) 307.76,23.18 308.43,22.51 308.43,21.18 308.83,20.78 308.83,17.08 308.43,16.67 308.43,15.78 305.36,12.72 304.18,12.72 304.06,12.6 JWLAN1.41
CLK_PCIE_N2: length 230.7
  IN3 w0.127: v2(103.27,10.47) 103.27,10.47 103.74,10.47 103.9,10.63 103.9,11.81 104.28,12.19 109.76,12.19 110.17,12.6 119.24,12.6 119.51,12.33 135.58,12.33 135.82,12.09 145.38,12.09 145.83,12.54 150.09,12.54 151.81,14.25 152.66,14.25 154.52,16.11 176.41,16.11 178.18,14.35 178.75,14.35 180.17,12.93 187.34,12.93 187.73,12.53 196.01,12.53 196.11,12.43 201.05,12.43 201.69,13.07 202.31,13.07 202.67,13.43 202.67,13.82 203.14,14.29 204.21,14.29 205.92,16 207.56,16 208.36,16.8 208.36,20.12 207.83,20.65 207.83,21.34 209.27,22.78 209.27,23.26 210.06,24.05 210.29,24.05 211.23,24.99 211.23,26.2 212.87,27.84 212.87,28.26 212.63,28.5 211.19,28.5 210.08,29.61 208.65,29.61 208.07,29.03 208.07,28.27 208.23,28.1 208.34,28.1 v2(208.41,28.18)
  BOTTOM w0.089: UH1.AE14 v2(208.41,28.18)
  BOTTOM w0.127: JSSD1.53 22.85,8.42 22.61,8.17 22.61,7.59 25.42,4.77 33.25,4.77 33.81,5.33 37.42,5.33 40.3,8.21 41.14,8.21 43.09,10.17 43.09,10.64 43.5,11.06 58.17,11.06 58.38,11.27 60.62,11.27 61.8,12.46 62.78,12.46 63.63,13.31 63.63,14.73 66.39,17.49 80.01,17.49 82.02,15.49 94.89,15.49 95.1,15.27 97.34,15.27 99.47,13.14 99.47,10.03 100.38,9.13 102.65,9.13 103.71,10.19 103.71,10.69 103.62,10.78 103.4,10.78 103.27,10.65 v2(103.27,10.47)
CLK_PCIE_N3: length 198.7
  IN3 w0.127: v2(102.08,10.5) 101.85,10.73 101.85,11.44 103.04,12.62 109.58,12.62 110.01,13.05 119.5,13.05 119.79,12.76 135.76,12.76 135.88,12.64 143.95,12.64 144.28,12.97 149.91,12.97 151.63,14.68 152.31,14.68 154.17,16.54 176.62,16.54 178.19,14.97 178.79,14.97 180.35,13.4 187.47,13.4 187.91,12.96 196.19,12.96 196.29,12.86 200.87,12.86 202.84,14.83 204.13,14.83 206.14,16.83 206.14,19.8 206.38,20.04 206.38,21.89 206.77,22.28 207.5,22.28 208.61,23.39 208.61,24.3 211.3,26.99 v2(211.3,28.07)
  BOTTOM w0.089: UH1.AE6 211.76,28.52 v2(211.3,28.07)
  BOTTOM w0.127: v2(102.08,10.5) 101.85,10.27 101.85,9.88 101.6,9.63 100.62,9.63 100.08,10.16 100.08,13.79 97.96,15.92 82.21,15.92 80.2,17.92 66.13,17.92 63.07,14.86 63.07,13.45 62.54,12.92 61.57,12.92 60.4,11.74 58.21,11.74 58.01,11.54 42.3,11.54 41.01,12.83 UR1.6
CLK_PCIE_N5: length 184.4
  IN3 w0.127: v2(106.35,11.22) 106.51,11.06 106.51,10.89 106.91,10.49 108.11,10.49 108.85,11.23 114.65,11.23 114.95,11.53 118.34,11.53 118.49,11.38 135.19,11.38 135.53,11.04 149.94,11.04 152.2,13.31 153.18,13.31 155.01,15.13 172.26,15.13 174.25,13.15 178.6,13.15 179.76,11.98 186.93,11.98 187.36,11.55 195.67,11.55 195.74,11.48 201.48,11.48 202.12,12.12 203.37,12.12 206.31,15.06 207.95,15.06 209.4,16.5 209.4,19.71 210.55,20.85 210.55,21.23 211.36,22.05 211.8,22.05 213.27,23.52 213.27,26.9 213.82,27.45 213.82,28.89 215.17,30.24 215.17,30.57 215.31,30.72 215.31,30.82 v2(215.49,30.99)
  BOTTOM w0.089: UH1.AB2 213.75,30.35 214.94,30.35 215.14,30.55 215.14,30.93 215.2,30.99 v2(215.49,30.99)
  BOTTOM w0.127: v2(106.35,11.22) 106.72,11.22 106.85,11.35 106.85,11.53 106.69,11.69 105.43,11.69 104.84,12.28 103.69,12.28 102.55,13.41 102.55,14.56 99.67,17.45 82.87,17.45 80.61,19.7 73,19.7 72.76,19.47 65.47,19.47 63.35,17.35 60.03,17.35 58.7,18.69 58.3,18.69 58.15,18.54 UL1.16
CLK_PCIE_P1: length 127.7
  IN1 w0.135: v2(307.11,22.44) 306.94,22.6 303.67,22.6 301.92,20.85 299.69,20.85 297.16,18.31 295.3,18.31 294.91,17.92 289,17.92 287.42,19.5 287.42,21.69 284.33,24.79 281.73,24.79 281.12,25.4 280.55,25.4 277.97,27.97 275.51,27.97 274.75,28.74 266.51,28.74 264.58,30.67 258.05,30.67 254.48,34.24 253.73,34.24 253.32,34.65 251.2,34.65 250.77,35.07 235.19,35.07 234.34,34.22 230.56,34.22 229.93,33.59 224.58,33.59 220.77,29.78 218.81,29.78 217.94,28.92 217.08,28.92 216.64,28.47 214.18,28.47 212.87,27.16 211.68,27.16 211.28,26.76 210.39,26.76 210.13,27.02 210.13,27.38 v2(210,27.51)
  BOTTOM w0.089: v2(210,27.51) 209.79,27.51 209.68,27.4 UH1.AH10
  BOTTOM w0.127: JWLAN1.39 303.64,13.1 303.7,13.04 303.7,12.91 303.76,12.86 303.96,12.86 304.07,12.97 305.26,12.97 308.17,15.89 308.17,16.78 308.58,17.18 308.58,20.68 308.18,21.08 308.18,22.4 307.66,22.93 307.48,22.93 307.39,22.83 307.39,22.72 307.51,22.6 307.51,22.47 307.41,22.37 307.18,22.37 v2(307.11,22.44)
CLK_PCIE_P2: length 230.8
  IN3 w0.127: v2(104.29,10.47) 104.16,10.59 104.16,11.71 104.38,11.93 109.87,11.93 110.27,12.34 119.14,12.34 119.41,12.07 135.47,12.07 135.72,11.83 145.49,11.83 145.94,12.28 150.2,12.28 151.92,14 152.77,14 154.63,15.86 176.31,15.86 178.07,14.09 178.64,14.09 180.06,12.67 187.23,12.67 187.63,12.27 195.91,12.27 196.01,12.17 201.16,12.17 201.8,12.81 202.42,12.81 202.93,13.32 202.93,13.72 203.25,14.03 204.31,14.03 206.02,15.75 207.67,15.75 208.61,16.69 208.61,20.23 208.09,20.76 208.09,21.23 209.53,22.67 209.53,23.16 210.17,23.8 210.4,23.8 211.48,24.88 211.48,26.09 213.13,27.74 213.13,28.36 212.73,28.76 211.3,28.76 210.19,29.87 208.54,29.87 207.81,29.14 207.81,28.31 v2(207.66,28.16)
  BOTTOM w0.089: v2(207.66,28.16) UH1.AE15
  BOTTOM w0.127: v2(104.29,10.47) 103.97,10.15 103.97,10.08 102.76,8.87 100.27,8.87 99.21,9.92 99.21,13.03 97.23,15.02 94.99,15.02 94.78,15.23 81.91,15.23 79.91,17.24 66.5,17.24 63.89,14.63 63.89,13.2 62.89,12.2 61.91,12.2 60.73,11.01 58.49,11.01 58.27,10.8 43.61,10.8 43.35,10.54 43.35,10.06 41.25,7.96 40.41,7.96 37.53,5.08 33.92,5.08 33.36,4.52 25.32,4.52 22.35,7.48 JSSD1.55
CLK_PCIE_P3: length 198.7
  IN3 w0.127: v2(101.37,10.5) 101.6,10.73 101.6,11.55 102.93,12.88 109.48,12.88 109.9,13.31 119.6,13.31 119.89,13.02 135.87,13.02 135.99,12.89 143.84,12.89 144.17,13.22 149.81,13.22 151.52,14.94 152.2,14.94 154.06,16.8 176.72,16.8 178.3,15.23 178.89,15.23 180.46,13.66 187.58,13.66 188.02,13.22 196.3,13.22 196.4,13.12 200.77,13.12 202.73,15.09 204.03,15.09 205.88,16.94 205.88,19.91 206.12,20.15 206.12,22 206.66,22.54 207.39,22.54 208.35,23.5 208.35,24.41 211.04,27.1 211.04,27.7 210.67,28.07 v2(210.67,28.08)
  BOTTOM w0.089: v2(210.67,28.08) 210.75,28.16 210.75,28.77 210.84,28.86 211,28.86 211.11,28.74 UH1.AE7
  BOTTOM w0.127: UR1.5 41.41,14.35 41.26,14.21 41.26,12.94 42.4,11.8 57.91,11.8 58.11,12 60.29,12 61.46,13.17 62.43,13.17 62.82,13.56 62.82,14.97 66.03,18.18 80.31,18.18 82.32,16.17 98.06,16.17 100.34,13.9 100.34,10.27 100.73,9.88 101.49,9.88 101.6,9.99 101.6,10.27 v2(101.37,10.5)
CLK_PCIE_P5: length 184.3
  IN3 w0.127: v2(107.28,11.22) 107.08,11.43 106.9,11.43 106.77,11.3 106.77,11 107.02,10.75 108.01,10.75 108.75,11.49 114.54,11.49 114.84,11.79 118.45,11.79 118.6,11.64 135.3,11.64 135.63,11.3 149.83,11.3 152.1,13.56 153.07,13.56 154.9,15.39 172.37,15.39 174.36,13.4 178.71,13.4 179.87,12.24 187.04,12.24 187.47,11.81 195.77,11.81 195.84,11.74 201.38,11.74 202.01,12.38 203.27,12.38 206.2,15.31 207.85,15.31 209.14,16.61 209.14,19.81 210.29,20.96 210.29,21.34 211.26,22.31 211.69,22.31 213.01,23.63 213.01,27.01 213.56,27.56 213.56,29 214.91,30.35 214.91,30.68 215,30.77 215,30.93 214.94,30.99 v2(214.78,30.99)
  BOTTOM w0.089: v2(214.78,30.99) 214.95,30.83 214.95,30.63 214.86,30.54 213.58,30.54 213.33,30.29 UH1.AB3
  BOTTOM w0.127: UL1.15 58.8,18.94 60.14,17.61 63.24,17.61 65.37,19.73 72.66,19.73 72.89,19.96 80.72,19.96 82.98,17.7 99.78,17.7 102.81,14.67 102.81,13.52 103.8,12.54 104.94,12.54 105.54,11.94 106.8,11.94 107.13,11.61 107.13,11.37 v2(107.28,11.22)
CLK_PEG_N4: length 89.2
  IN3 w0.127: v2(208.19,46.81) 207.96,47.04 207.96,47.4 204.58,50.78 201.57,50.78 200.33,52.02 195.23,52.02 192.34,54.91 192.34,68.82 193.39,69.87 193.39,70.36 193.88,70.84 193.88,77.17 195.09,78.39 195.09,82.48 194.7,82.88 194.7,84.25 194.82,84.37 195.43,84.37 195.71,84.66 195.71,84.93 v2(195.98,85.2)
  BOTTOM w0.089: 215.73,29.68 215.7,29.68 215.67,29.72 214.85,29.72 214.82,29.75 214.19,29.75 214.14,29.7 213.67,29.7 UH1.AC2
  BOTTOM w0.102: v2(195.98,85.2) 195.98,85.29 UG1.AK13
  BOTTOM w0.127: 215.73,29.68 218.92,29.68 219.88,30.64 220.81,30.64 222.17,31.99 222.17,41.28 220.93,42.52 220.93,44.1 220.1,44.93 218.31,44.93 216.91,46.33 208.06,46.33 207.96,46.43 207.96,46.58 v2(208.19,46.81)
CLK_PEG_P4: length 89.3
  IN3 w0.127: v2(207.48,46.81) 207.7,47.04 207.7,47.3 204.48,50.52 201.47,50.52 200.23,51.76 195.12,51.76 192.08,54.8 192.08,68.92 193.13,69.97 193.13,70.46 193.62,70.95 193.62,77.28 194.83,78.49 194.83,82.38 194.44,82.77 194.44,84.35 194.72,84.63 195.32,84.63 195.46,84.76 195.46,84.92 v2(195.16,85.21)
  BOTTOM w0.089: UH1.AC3 213.16,29.89 214.06,29.89 214.11,29.94 214.9,29.94 214.93,29.91 215.67,29.91 215.7,29.94 215.73,29.94
  BOTTOM w0.102: v2(195.16,85.21) 194.78,85.59 UG1.AL13
  BOTTOM w0.127: 215.73,29.94 218.81,29.94 219.77,30.9 220.71,30.9 221.91,32.1 221.91,41.17 220.67,42.41 220.67,44 219.99,44.67 218.21,44.67 216.8,46.08 207.95,46.08 207.7,46.32 207.7,46.58 v2(207.48,46.81)
CLKOUT_LPC0: length 9.6
  TOP w0.127: RH27.1 195.13,15.84 195.13,17.91 195.28,18.06 CH70.1 195.28,19.64 v1(195.59,19.96) 195.85,20.22 195.85,20.96 196.12,21.23 196.12,21.81 v2(196.02,21.91)
  BOTTOM w0.127: UH1.BB36 196.6,20.3 196.32,20.58 196.32,21.35 196.02,21.65 v2(196.02,21.91)
