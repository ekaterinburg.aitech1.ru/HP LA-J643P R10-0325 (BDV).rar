# Allegro board LAJ643PR10-0325.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
CH751H-40PT_SOD323-2
  rect 0.711x0.711 smd: 1(0,0) 2(2.33,0)
CHILI_MHCD252012A-1R0M-A8S_2P
  rect 0.787x2.311 smd: 1(0,0) 2(2,0)
CHILI_MHCD252012A-2R2M-A8S_2P
  rect 0.787x2.007 smd: 1(0,0) 2(2,0)
CHILI_PBY160808T-121Y-N_2P
  rect 0.559x1.041 smd: 1(0,0) 2(1.3,0)
CK0402101V05_0402-2
  rect 0.508x0.559 smd: 1(0,0) 2(0.92,0)
CNP-H_BGA_874P-T
  round 0.305 smd: A2(0.354,0) A3(0.855,0) A4(1.355,0) A46(22.273,0) A47(22.773,0) A48(23.274,0) AA19(8.715,-9.765) AA20(9.49,-9.765) AA22(10.265,-9.765) AA23(11.039,-9.765) AA25(11.814,-9.765) AA27(12.589,-9.765) AA28(13.363,-9.765) AA30(14.138,-9.765) AA31(14.913,-9.765) AB19(8.715,-10.539) AB20(9.49,-10.539) AB22(10.265,-10.539) AB23(11.039,-10.539) AB25(11.814,-10.539) AB27(12.589,-10.539) AB28(13.363,-10.539) AB30(14.138,-10.539) AB31(14.913,-10.539) AC6(2.44,-10.735) AC7(3.202,-10.735) AC9(3.964,-10.735) AC11(4.726,-10.735) AC12(5.488,-10.735) AC14(6.25,-10.735) AC15(7.012,-10.735) AC17(7.774,-10.735) AC33(15.854,-10.735) AC35(16.616,-10.735) AC36(17.378,-10.735) AC38(18.14,-10.735) AC39(18.902,-10.735) AC41(19.664,-10.735) AC43(20.426,-10.735) AC44(21.188,-10.735) AD19(8.715,-11.314) AD20(9.49,-11.314) AD22(10.265,-11.314) AD23(11.039,-11.314) AD25(11.814,-11.314) AD27(12.589,-11.314) AD28(13.363,-11.314) AD30(14.138,-11.314) AD31(14.913,-11.314) AE6(2.44,-11.893) AE7(3.202,-11.893) AE9(3.964,-11.893) AE11(4.726,-11.893) AE12(5.488,-11.893) AE14(6.25,-11.893) AE15(7.012,-11.893) AE17(7.774,-11.893) AE33(15.854,-11.893) AE35(16.616,-11.893) AE36(17.378,-11.893) AE38(18.14,-11.893) AE39(18.902,-11.893) AE41(19.664,-11.893) AE43(20.426,-11.893) AE44(21.188,-11.893) AF19(8.715,-12.089) AF20(9.49,-12.089) AF22(10.265,-12.089) AF23(11.039,-12.089) AF25(11.814,-12.089) AF27(12.589,-12.089) AF28(13.363,-12.089) AF30(14.138,-12.089) AF31(14.913,-12.089) AG19(8.715,-12.863) AG20(9.49,-12.863) AG22(10.265,-12.863) AG23(11.039,-12.863) AG25(11.814,-12.863) AG27(12.589,-12.863) AG28(13.363,-12.863) AG30(14.138,-12.863) AG31(14.913,-12.863) AH9(3.895,-13.519) AH10(4.634,-13.328) AH12(5.412,-13.328) AH14(6.25,-13.328) AH15(7.025,-13.328) AH17(7.787,-13.328) AH33(15.841,-13.328) AH35(16.603,-13.328) AH36(17.378,-13.328) AH38(18.216,-13.328) AH40(18.994,-13.328) AH41(19.733,-13.519) AJ6(2.417,-13.9) AJ7(3.156,-13.709) AJ19(8.715,-13.638) AJ20(9.49,-13.638) AJ22(10.265,-13.638) AJ23(11.039,-13.638) AJ25(11.814,-13.638) AJ27(12.589,-13.638) AJ28(13.363,-13.638) AJ30(14.138,-13.638) AJ31(14.913,-13.638) AJ43(20.472,-13.709) AJ44(21.211,-13.9) AK19(8.715,-14.413) AK20(9.49,-14.413) AK22(10.265,-14.413) AK23(11.039,-14.413) AK25(11.814,-14.413) AK27(12.589,-14.413) AK28(13.363,-14.413) AK30(14.138,-14.413) AK31(14.913,-14.413) AL9(3.9,-14.809) AL10(4.633,-14.573) AL12(5.395,-14.573) AL13(6.157,-14.573) AL15(6.919,-14.573) AL17(7.681,-14.573) AL21(9.8,-14.892) AL24(11.235,-14.905) AL26(12.393,-14.905) AL29(13.828,-14.892) AL33(15.947,-14.573) AL35(16.709,-14.573) AL37(17.471,-14.573) AL38(18.233,-14.573) AL40(18.995,-14.573) AL41(19.728,-14.809) AM7(3.179,-15.157) AM18(8.555,-14.997) AM32(15.073,-14.997) AM43(20.449,-15.157) AN6(2.519,-15.538) AN10(4.633,-15.97) AN12(5.37,-15.665) AN13(6.132,-15.665) AN15(6.894,-15.665) AN16(7.463,-15.708) AN18(8.555,-15.708) AN21(9.8,-15.603) AN24(11.235,-15.616) AN26(12.393,-15.616) AN29(13.828,-15.603) AN32(15.073,-15.708) AN34(16.165,-15.708) AN35(16.734,-15.665) AN37(17.496,-15.665) AN38(18.258,-15.665) AN40(18.995,-15.97) AN44(21.109,-15.538) AP9(3.9,-16.282) AP21(9.8,-16.378) AP24(11.235,-16.378) AP26(12.393,-16.378) AP29(13.828,-16.378) AP41(19.728,-16.282) AR8(3.306,-16.783) AR12(5.37,-16.757) AR13(6.132,-16.757) AR15(6.894,-16.757) AR16(7.463,-16.496) AR18(8.555,-16.47) AR32(15.073,-16.47) AR34(16.165,-16.496) AR35(16.734,-16.757) AR37(17.496,-16.757) AR38(18.258,-16.757) AR42(20.322,-16.783) AT6(2.519,-16.973) AT10(4.633,-17.087) AT16(7.463,-17.258) AT18(8.555,-17.232) AT21(9.8,-17.216) AT24(11.235,-17.14) AT26(12.393,-17.14) AT29(13.828,-17.216) AT32(15.073,-17.232) AT34(16.165,-17.258) AT40(18.995,-17.087) AT44(21.109,-16.973) AU9(3.9,-17.73) AU24(11.235,-17.902) AU26(12.393,-17.902) AU41(19.728,-17.73) AV6(2.519,-18.408) AV7(3.217,-18.078) AV11(4.735,-18.289) AV13(6.066,-18.071) AV16(7.158,-18.032) AV18(8.555,-17.994) AV21(9.8,-17.993) AV29(13.828,-17.993) AV32(15.073,-17.994) AV34(16.47,-18.032) AV37(17.562,-18.071) AV39(18.893,-18.289) AV43(20.411,-18.078) AV44(21.109,-18.408) AW9(3.99,-18.891) AW10(4.552,-18.823) AW13(5.804,-18.804) AW15(6.922,-18.766) AW18(8.319,-18.727) AW21(9.609,-18.733) AW24(11.235,-18.664) AW26(12.393,-18.664) AW29(14.019,-18.733) AW32(15.309,-18.727) AW35(16.706,-18.766) AW37(17.824,-18.804) AW40(19.076,-18.823) AW41(19.638,-18.891) AY8(3.281,-19.212) AY42(20.347,-19.212) B1(0,-0.354) B2(0.484,-0.484) B3(1.105,-0.436) B47(22.523,-0.436) B48(23.144,-0.484) B49(23.628,-0.354) BA6(2.684,-19.517) BA12(5.329,-19.449) BA14(6.574,-19.449) BA17(7.971,-19.449) BA20(9.419,-19.472) BA24(11.235,-19.426) BA26(12.393,-19.426) BA30(14.209,-19.472) BA33(15.657,-19.449) BA36(17.054,-19.449) BA38(18.299,-19.449) BA44(20.944,-19.517) BB6(2.726,-20.02) BB7(3.225,-20.314) BB9(3.79,-20.088) BB11(4.948,-20.109) BB14(6.193,-20.109) BB16(7.59,-20.109) BB20(9.228,-20.211) BB24(11.235,-20.188) BB26(12.393,-20.188) BB30(14.4,-20.211) BB34(16.038,-20.109) BB36(17.435,-20.109) BB39(18.68,-20.109) BB41(19.838,-20.088) BB43(20.403,-20.314) BB44(20.902,-20.02) BC5(2.18,-20.568) BC45(21.448,-20.568) BD1(0,-21.273) BD4(1.34,-21.297) BD46(22.288,-21.297) BD49(23.628,-21.273) BE1(0,-21.773) BE2(0.441,-21.51) BE3(0.954,-21.625) BE4(1.423,-21.801) BE5(1.849,-21.526) BE45(21.779,-21.526) BE46(22.205,-21.801) BE47(22.674,-21.625) BE48(23.187,-21.51) BE49(23.628,-21.773) BF1(0,-22.274) BF2(0.484,-22.144) BF3(1.105,-22.192) BF47(22.523,-22.192) BF48(23.144,-22.144) BF49(23.628,-22.274) BG2(0.354,-22.628) BG3(0.855,-22.628) BG4(1.355,-22.628) BG46(22.273,-22.628) BG47(22.773,-22.628) BG48(23.274,-22.628) C1(0,-0.855) C2(0.441,-1.118) C3(0.954,-1.003) C4(1.423,-0.827) C5(1.849,-1.102) C45(21.779,-1.102) C46(22.205,-0.827) C47(22.674,-1.003) C48(23.187,-1.118) C49(23.628,-0.855) D1(0,-1.355) D4(1.34,-1.331) D46(22.288,-1.331) D49(23.628,-1.355) E5(2.18,-2.06) E45(21.448,-2.06) F6(2.726,-2.608) F7(3.225,-2.314) F9(3.79,-2.539) F11(4.948,-2.519) F14(6.193,-2.519) F16(7.59,-2.519) F20(9.228,-2.417) F24(11.235,-2.44) F26(12.393,-2.44) F30(14.4,-2.417) F34(16.038,-2.519) F36(17.435,-2.519) F39(18.68,-2.519) F41(19.838,-2.539) F43(20.403,-2.314) F44(20.902,-2.608) G6(2.684,-3.111) G12(5.329,-3.179) G14(6.574,-3.179) G17(7.971,-3.179) G20(9.419,-3.156) G24(11.235,-3.202) G26(12.393,-3.202) G30(14.209,-3.156) G33(15.657,-3.179) G36(17.054,-3.179) G38(18.299,-3.179) G44(20.944,-3.111) H8(3.281,-3.416) H42(20.347,-3.416) J9(3.99,-3.737) J10(4.552,-3.805) J13(5.804,-3.824) J15(6.922,-3.862) J18(8.319,-3.9) J21(9.609,-3.895) J24(11.235,-3.964) J26(12.393,-3.964) J29(14.019,-3.895) J32(15.309,-3.9) J35(16.706,-3.862) J37(17.824,-3.824) J40(19.076,-3.805) J41(19.638,-3.737) K6(2.519,-4.22) K7(3.217,-4.55) K11(4.735,-4.339) K13(6.066,-4.557) K16(7.158,-4.595) K18(8.555,-4.633) K21(9.8,-4.634) K29(13.828,-4.634) K32(15.073,-4.633) K34(16.47,-4.595) K37(17.562,-4.557) K39(18.893,-4.339) K43(20.411,-4.55) K44(21.109,-4.22) L9(3.9,-4.898) L24(11.235,-4.726) L26(12.393,-4.726) L41(19.728,-4.898) M6(2.519,-5.655) M10(4.633,-5.541) M16(7.463,-5.37) M18(8.555,-5.395) M21(9.8,-5.412) M24(11.235,-5.488) M26(12.393,-5.488) M29(13.828,-5.412) M32(15.073,-5.395) M34(16.165,-5.37) M40(18.995,-5.541) M44(21.109,-5.655) N8(3.306,-5.845) N12(5.37,-5.871) N13(6.132,-5.871) N15(6.894,-5.871) N16(7.463,-6.132) N18(8.555,-6.157) N32(15.073,-6.157) N34(16.165,-6.132) N35(16.734,-5.871) N37(17.496,-5.871) N38(18.258,-5.871) N42(20.322,-5.845) P9(3.9,-6.346) P21(9.8,-6.25) P24(11.235,-6.25) P26(12.393,-6.25) P29(13.828,-6.25) P41(19.728,-6.346) R6(2.519,-7.09) R10(4.633,-6.658) R12(5.37,-6.963) R13(6.132,-6.963) R15(6.894,-6.963) R16(7.463,-6.919) R18(8.555,-6.919) R21(9.8,-7.025) R24(11.235,-7.012) R26(12.393,-7.012) R29(13.828,-7.025) R32(15.073,-6.919) R34(16.165,-6.919) R35(16.734,-6.963) R37(17.496,-6.963) R38(18.258,-6.963) R40(18.995,-6.658) R44(21.109,-7.09) T7(3.179,-7.471) T17(8.003,-7.631) T18(8.555,-7.631) T32(15.073,-7.631) T43(20.449,-7.471) U9(3.9,-7.819) U10(4.633,-8.055) U12(5.395,-8.055) U13(6.157,-8.055) U15(6.919,-8.055) U17(7.681,-8.055) U21(9.8,-7.736) U24(11.235,-7.723) U26(12.393,-7.723) U29(13.828,-7.736) U33(15.947,-8.055) U35(16.709,-8.055) U37(17.471,-8.055) U38(18.233,-8.055) U40(18.995,-8.055) U41(19.728,-7.819) V19(8.715,-8.215) V20(9.49,-8.215) V22(10.265,-8.215) V23(11.039,-8.215) V25(11.814,-8.215) V27(12.589,-8.215) V28(13.363,-8.215) V30(14.138,-8.215) V31(14.913,-8.215) W6(2.417,-8.728) W7(3.156,-8.919) W19(8.715,-8.99) W20(9.49,-8.99) W22(10.265,-8.99) W23(11.039,-8.99) W25(11.814,-8.99) W27(12.589,-8.99) W28(13.363,-8.99) W30(14.138,-8.99) W31(14.913,-8.99) W43(20.472,-8.919) W44(21.211,-8.728) Y9(3.895,-9.109) Y10(4.634,-9.3) Y12(5.412,-9.3) Y14(6.25,-9.3) Y15(7.025,-9.3) Y17(7.787,-9.3) Y33(15.841,-9.3) Y35(16.603,-9.3) Y36(17.378,-9.3) Y38(18.216,-9.3) Y40(18.994,-9.3) Y41(19.733,-9.109)
  round 0.279 smd: A5(1.856,0) A45(21.772,0) BC1(0,-20.772) BC49(23.628,-20.772) BG5(1.856,-22.628) BG45(21.772,-22.628) E1(0,-1.856) E49(23.628,-1.856)
  oval 0.203x0.254 smd: A6(2.415,0) A8(3.52,0) A42(20.108,0) A44(21.213,0) BD8(3.403,-21.127) BD12(5.6,-21.127) BD17(7.797,-21.127) BD21(9.994,-21.127) BD29(13.634,-21.127) BD33(15.831,-21.127) BD38(18.028,-21.127) BD42(20.225,-21.127) BE9(4.03,-21.5) BE10(4.531,-21.373) BE14(6.227,-21.5) BE15(6.728,-21.373) BE18(8.424,-21.5) BE19(8.925,-21.373) BE23(10.621,-21.5) BE24(11.122,-21.373) BE26(12.506,-21.373) BE27(13.007,-21.5) BE31(14.703,-21.373) BE32(15.204,-21.5) BE35(16.9,-21.373) BE36(17.401,-21.5) BE40(19.097,-21.373) BE41(19.598,-21.5) BG6(2.415,-22.628) BG8(3.52,-22.628) BG42(20.108,-22.628) BG44(21.213,-22.628) C9(4.03,-1.128) C10(4.531,-1.255) C14(6.227,-1.128) C15(6.728,-1.255) C18(8.424,-1.128) C19(8.925,-1.255) C23(10.621,-1.128) C24(11.122,-1.255) C26(12.506,-1.255) C27(13.007,-1.128) C31(14.703,-1.255) C32(15.204,-1.128) C35(16.9,-1.255) C36(17.401,-1.128) C40(19.097,-1.255) C41(19.598,-1.128) D8(3.403,-1.501) D12(5.6,-1.501) D17(7.797,-1.501) D21(9.994,-1.501) D29(13.634,-1.501) D33(15.831,-1.501) D38(18.028,-1.501) D42(20.225,-1.501)
  oval 0.178x0.254 smd: A13(5.742,0) A17(7.939,0) A22(10.136,0) A25(11.814,0) A28(13.492,0) A33(15.689,0) A37(17.886,0) B10(4.691,-0.711) B12(5.549,-0.498) B14(6.227,-0.627) B15(6.888,-0.711) B17(7.746,-0.498) B18(8.424,-0.627) B19(9.085,-0.711) B21(9.943,-0.498) B23(10.621,-0.627) B24(11.282,-0.711) B25(11.814,-0.508) B26(12.346,-0.711) B27(13.007,-0.627) B29(13.685,-0.498) B31(14.543,-0.711) B32(15.204,-0.627) B33(15.882,-0.498) B35(16.74,-0.711) B36(17.401,-0.627) B38(18.079,-0.498) B40(18.937,-0.711) BE11(5.054,-21.432) BE12(5.519,-21.627) BE16(7.251,-21.432) BE17(7.716,-21.627) BE20(9.448,-21.432) BE21(9.913,-21.627) BE25(11.814,-21.612) BE29(13.715,-21.627) BE30(14.18,-21.432) BE33(15.912,-21.627) BE34(16.377,-21.432) BE38(18.109,-21.627) BE39(18.575,-21.432) BF10(4.691,-21.917) BF12(5.549,-22.129) BF14(6.227,-22) BF15(6.888,-21.917) BF17(7.746,-22.129) BF18(8.424,-22) BF19(9.085,-21.917) BF21(9.943,-22.129) BF23(10.621,-22) BF24(11.282,-21.917) BF25(11.814,-22.12) BF26(12.346,-21.917) BF27(13.007,-22) BF29(13.685,-22.129) BF31(14.543,-21.917) BF32(15.204,-22) BF33(15.882,-22.129) BF35(16.74,-21.917) BF36(17.401,-22) BF38(18.079,-22.129) BF40(18.937,-21.917) BG13(5.742,-22.628) BG17(7.939,-22.628) BG22(10.136,-22.628) BG25(11.814,-22.628) BG28(13.492,-22.628) BG33(15.689,-22.628) BG37(17.886,-22.628) C11(5.054,-1.196) C12(5.519,-1.001) C16(7.251,-1.196) C17(7.716,-1.001) C20(9.448,-1.196) C21(9.913,-1.001) C25(11.814,-1.016) C29(13.715,-1.001) C30(14.18,-1.196) C33(15.912,-1.001) C34(16.377,-1.196) C38(18.109,-1.001) C39(18.575,-1.196)
  oval 0.254x0.178 smd: AA1(0,-9.636) AA49(23.628,-9.636) AB2(0.627,-10.121) AB48(23.001,-10.121) AC2(0.711,-10.782) AC48(22.917,-10.782) AD1(0,-11.314) AD2(0.508,-11.314) AD3(1.016,-11.314) AD47(22.612,-11.314) AD48(23.12,-11.314) AD49(23.628,-11.314) AE2(0.711,-11.846) AE48(22.917,-11.846) AF2(0.627,-12.507) AF48(23.001,-12.507) AG1(0,-12.992) AG49(23.628,-12.992) AH2(0.498,-13.185) AH3(1.001,-13.215) AH47(22.627,-13.215) AH48(23.13,-13.185) AJ3(1.196,-13.68) AJ47(22.432,-13.68) AK2(0.711,-14.043) AK48(22.917,-14.043) AL2(0.627,-14.704) AL48(23.001,-14.704) AM1(0,-15.189) AM2(0.498,-15.382) AM3(1.001,-15.412) AM47(22.627,-15.412) AM48(23.13,-15.382) AM49(23.628,-15.189) AN3(1.196,-15.877) AN47(22.432,-15.877) AP2(0.711,-16.24) AP48(22.917,-16.24) P2(0.711,-6.388) P48(22.917,-6.388) R3(1.196,-6.751) R47(22.432,-6.751) T1(0,-7.439) T2(0.498,-7.246) T3(1.001,-7.216) T47(22.627,-7.216) T48(23.13,-7.246) T49(23.628,-7.439) U2(0.627,-7.924) U48(23.001,-7.924) V2(0.711,-8.585) V48(22.917,-8.585) W3(1.196,-8.948) W47(22.432,-8.948) Y2(0.498,-9.443) Y3(1.001,-9.413) Y47(22.627,-9.413) Y48(23.13,-9.443)
  round 0.254 smd: AA5(1.958,-9.712) AA45(21.67,-9.712) AC4(1.754,-10.735) AC46(21.874,-10.735) AE4(1.754,-11.893) AE46(21.874,-11.893) AG5(1.958,-12.915) AG45(21.67,-12.915) AJ4(1.716,-13.588) AJ46(21.912,-13.588) AK4(1.754,-14.09) AK46(21.874,-14.09) AM5(1.958,-15.112) AM45(21.67,-15.112) AN4(1.716,-15.785) AN46(21.912,-15.785) AP4(1.754,-16.287) AP46(21.874,-16.287) AT5(1.958,-17.31) AT45(21.67,-17.31) AV4(1.716,-17.982) AV46(21.912,-17.982) AW4(1.754,-18.484) AW46(21.874,-18.484) B6(2.417,-0.503) B44(21.211,-0.503) BA2(0.498,-19.84) BA3(1.005,-19.908) BA4(1.51,-19.782) BA5(1.958,-19.507) BA45(21.67,-19.507) BA46(22.118,-19.782) BA47(22.623,-19.908) BA48(23.13,-19.84) BB3(0.496,-20.629) BB4(0.989,-20.44) BB46(22.64,-20.44) BB47(23.132,-20.629) BC8(3.621,-20.67) BC10(4.644,-20.874) BC13(5.818,-20.67) BC15(6.841,-20.874) BC17(8.015,-20.67) BC19(9.038,-20.874) BC22(10.213,-20.67) BC24(11.235,-20.874) BC26(12.393,-20.874) BC28(13.416,-20.67) BC31(14.59,-20.874) BC33(15.613,-20.67) BC35(16.787,-20.874) BC37(17.81,-20.67) BC40(18.984,-20.874) BC42(20.007,-20.67) BD7(2.9,-21.186) BD11(5.146,-20.912) BD16(7.343,-20.912) BD20(9.54,-20.912) BD30(14.088,-20.912) BD34(16.285,-20.912) BD39(18.483,-20.912) BD43(20.728,-21.186) BE6(2.723,-21.671) BE44(20.905,-21.671) BF6(2.417,-22.125) BF44(21.211,-22.125) C6(2.723,-0.957) C44(20.905,-0.957) D7(2.9,-1.441) D11(5.146,-1.716) D16(7.343,-1.716) D20(9.54,-1.716) D30(14.088,-1.716) D34(16.285,-1.716) D39(18.483,-1.716) D43(20.728,-1.441) E8(3.621,-1.958) E10(4.644,-1.754) E13(5.818,-1.958) E15(6.841,-1.754) E17(8.015,-1.958) E19(9.038,-1.754) E22(10.213,-1.958) E24(11.235,-1.754) E26(12.393,-1.754) E28(13.416,-1.958) E31(14.59,-1.754) E33(15.613,-1.958) E35(16.787,-1.754) E37(17.81,-1.958) E40(18.984,-1.754) E42(20.007,-1.958) F3(0.496,-1.999) F4(0.989,-2.187) F46(22.64,-2.187) F47(23.132,-1.999) G2(0.498,-2.788) G3(1.005,-2.72) G4(1.51,-2.846) G5(1.958,-3.121) G45(21.67,-3.121) G46(22.118,-2.846) G47(22.623,-2.72) G48(23.13,-2.788) J4(1.754,-4.144) J46(21.874,-4.144) K4(1.716,-4.645) K46(21.912,-4.645) M5(1.958,-5.318) M45(21.67,-5.318) P4(1.754,-6.341) P46(21.874,-6.341) R4(1.716,-6.843) R46(21.912,-6.843) T5(1.958,-7.515) T45(21.67,-7.515) V4(1.754,-8.538) V46(21.874,-8.538) W4(1.716,-9.04) W46(21.912,-9.04)
  oval 0.254x0.203 smd: AB3(1.128,-10.121) AB47(22.5,-10.121) AC3(1.255,-10.622) AC47(22.373,-10.622) AE3(1.255,-12.006) AE47(22.373,-12.006) AF3(1.128,-12.507) AF47(22.5,-12.507) AH4(1.501,-13.134) AH46(22.127,-13.134) AK3(1.255,-14.197) AK47(22.373,-14.197) AL3(1.128,-14.704) AL47(22.5,-14.704) AM4(1.501,-15.331) AM46(22.127,-15.331) AP3(1.255,-16.394) AP47(22.373,-16.394) AR3(1.128,-16.901) AR47(22.5,-16.901) AT1(0,-17.411) AT49(23.628,-17.411) AU4(1.501,-17.528) AU46(22.127,-17.528) AW3(1.255,-18.591) AW47(22.373,-18.591) AY3(1.128,-19.098) AY47(22.5,-19.098) BA1(0,-19.634) BA49(23.628,-19.634) G1(0,-2.994) G49(23.628,-2.994) H3(1.128,-3.53) H47(22.5,-3.53) J3(1.255,-4.037) J47(22.373,-4.037) L4(1.501,-5.1) L46(22.127,-5.1) M1(0,-5.217) M49(23.628,-5.217) N3(1.128,-5.727) N47(22.5,-5.727) P3(1.255,-6.234) P47(22.373,-6.234) T4(1.501,-7.297) T46(22.127,-7.297) U3(1.128,-7.924) U47(22.5,-7.924) V3(1.255,-8.431) V47(22.373,-8.431) Y4(1.501,-9.494) Y46(22.127,-9.494)
  oval 0.305x0.152 smd: AR2(0.627,-16.901) AR48(23.001,-16.901) AU2(0.498,-17.579) AU3(1.001,-17.609) AU47(22.627,-17.609) AU48(23.13,-17.579) AV3(1.196,-18.074) AV47(22.432,-18.074) AW2(0.711,-18.437) AW48(22.917,-18.437) AY2(0.627,-19.098) AY48(23.001,-19.098) H2(0.627,-3.53) H48(23.001,-3.53) J2(0.711,-4.19) J48(22.917,-4.19) K3(1.196,-4.553) K47(22.432,-4.553) L2(0.498,-5.049) L3(1.001,-5.019) L47(22.627,-5.019) L48(23.13,-5.049) N2(0.627,-5.727) N48(23.001,-5.727)
  oval 0.152x0.305 smd: B8(3.352,-0.498) B9(4.03,-0.627) B41(19.598,-0.627) B42(20.276,-0.498) BE8(3.322,-21.627) BE42(20.307,-21.627) BF8(3.352,-22.129) BF9(4.03,-22) BF41(19.598,-22) BF42(20.276,-22.129) C8(3.322,-1.001) C42(20.307,-1.001)
CVILU_CF3112DD0R4-05-NH_12P
  oval 0.305x1.295 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0)
  rect 2.489x1.905 smd: 13(-2.15,-3.3) 14(7.65,-3.3)
CYNTE_PCMC063T-R82MN_2P
  rect 2.362x3.505 smd: 1(0,0) 2(6.05,0)
D_SOD323-2
  rect 0.787x0.889 smd: 1(0,0) 2(2.14,0)
DMN66D0LDW-7_SOT363-6
  oval 0.432x0.61 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0.65,1.9) 6(0,1.9)
EM5201V_DFN8_3X3
  oval 0.305x0.61 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0) 5(1.95,2.8)
  rect 1.6x0.61 smd: 6(0.65,2.8)
  rect 2.388x1.6 smd: 7(0.975,1.4)
EM5209VF_DFN14_3X2
  oval 0.203x0.711 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.4,2) 9(2,2) 10(1.6,2) 11(1.2,2) 12(0.8,2) 13(0.4,2) 14(0,2)
  rect 2.591x0.991 smd: 15(1.2,1)
F_MF-MSMF050-2
  rect 1.499x3.2 smd: 1(0,0) 2(4.2,0)
FIDUCIAL_C40M80
  round 1.016 smd: 1(0,0)
G517AH1TP1U_TSOT23-6
  oval 0.508x1.194 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,3) 5(0.95,3) 6(0,3)
G524B1T11U_SOT23-5
  oval 0.533x1.194 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,3) 5(0,3)
G5719CTB1U_SOT23-6
  oval 1.194x0.508 smd: 1(0,0) 2(0,-0.95) 3(0,-1.9) 4(3,-1.9) 5(3,-0.95) 6(3,0)
H_2P3-G
  round 2.819 hole 2.311: 1(0,0)
H_2P3N
  round 2.311 hole 2.311 unplated: (0,0)
H_2P3X2P8
  oval 2.819x3.302 hole 2.311x2.794: 1(0,0)
H_2P4-G
  round 2.896 hole 2.388: 1(0,0)
H_4P0-G
  round 4.496 hole 3.988: 1(0,0)
H_4P1
  round 4.597 hole 4.089: 1(0,0)
HP2DCTR_LGA12_2X2
  oval 0.305x0.381 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 7(1.5,1.5) 8(1,1.5) 9(0.5,1.5) 10(0,1.5)
  oval 0.381x0.254 smd: 5(1.5,0.5) 6(1.5,1) 11(0,1) 12(0,0.5)
INPAQ_HCM1012GH900BP_4P
  rect 0.711x0.305 smd: 1(0,0) 2(1.25,0) 3(1.25,-0.5) 4(0,-0.5)
ISL88739AHRZ-T_QFN32_4X4
  oval 0.889x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 8(0,-2.8) 17(4.1,-2.8) 18(4.1,-2.4) 19(4.1,-2) 20(4.1,-1.6) 21(4.1,-1.2) 22(4.1,-0.8) 23(4.1,-0.4) 24(4.1,0)
  oval 0.203x0.889 smd: 9(0.65,-3.45) 10(1.05,-3.45) 11(1.45,-3.45) 12(1.85,-3.45) 13(2.25,-3.45) 14(2.65,-3.45) 15(3.05,-3.45) 16(3.45,-3.45) 25(3.45,0.65) 26(3.05,0.65) 27(2.65,0.65) 28(2.25,0.65) 29(1.85,0.65) 30(1.45,0.65) 31(1.05,0.65) 32(0.65,0.65)
  rect 2.642x2.642 smd: 33(2.05,-1.4)
JUMP_43X39
  custom 0.191x0.191 smd: 1(0,0) 2(0.914,0)
JUMP_43X39_0805
  custom 0.191x0.191 smd: 1(0,0) 2(0,-0.914)
JUMP_43X79
  custom 0.188x0.188 smd: 1(0,0) 2(1.1,0)
JUMP_43X118
  custom 0.187x0.187 smd: 1(0,0) 2(1.1,0)
JXT_FP241AH-006GAAM_6P
  oval 0.305x0.965 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0)
  rect 0.305x1.143 smd: 7(-0.885,-2.965) 8(3.385,-2.965)
JXT_FP243A-036G1BM_36P
  oval 0.254x0.787 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0) 16(7.5,0) 17(8,0) 18(8.5,0) 19(9,0) 20(9.5,0) 21(10,0) 22(10.5,0) 23(11,0) 24(11.5,0) 25(12,0) 26(12.5,0) 27(13,0) 28(13.5,0) 29(14,0) 30(14.5,0) 31(15,0) 32(15.5,0) 33(16,0) 34(16.5,0) 35(17,0) 36(17.5,0)
  rect 0.406x0.787 smd: 37(-1,-2.5) 38(18.5,-2.5)
K4G41325FC-HC04_FBGA_170P
  round 0.343 smd: A1(0,0) A2(0.8,0) A3(1.6,0) A4(2.4,0) A5(3.2,0) A10(7.201,0) A11(8.001,0) A12(8.801,0) A13(9.601,0) A14(10.401,0) B1(0,-0.8) B2(0.8,-0.8) B3(1.6,-0.8) B4(2.4,-0.8) B5(3.2,-0.8) B10(7.201,-0.8) B11(8.001,-0.8) B12(8.801,-0.8) B13(9.601,-0.8) B14(10.401,-0.8) C1(0,-1.6) C2(0.8,-1.6) C3(1.6,-1.6) C4(2.4,-1.6) C5(3.2,-1.6) C10(7.201,-1.6) C11(8.001,-1.6) C12(8.801,-1.6) C13(9.601,-1.6) C14(10.401,-1.6) D1(0,-2.4) D2(0.8,-2.4) D3(1.6,-2.4) D4(2.4,-2.4) D5(3.2,-2.4) D10(7.201,-2.4) D11(8.001,-2.4) D12(8.801,-2.4) D13(9.601,-2.4) D14(10.401,-2.4) E1(0,-3.2) E2(0.8,-3.2) E3(1.6,-3.2) E4(2.4,-3.2) E5(3.2,-3.2) E10(7.201,-3.2) E11(8.001,-3.2) E12(8.801,-3.2) E13(9.601,-3.2) E14(10.401,-3.2) F1(0,-4) F2(0.8,-4) F3(1.6,-4) F4(2.4,-4) F5(3.2,-4) F10(7.201,-4) F11(8.001,-4) F12(8.801,-4) F13(9.601,-4) F14(10.401,-4) G1(0,-4.801) G2(0.8,-4.801) G3(1.6,-4.801) G4(2.4,-4.801) G5(3.2,-4.801) G10(7.201,-4.801) G11(8.001,-4.801) G12(8.801,-4.801) G13(9.601,-4.801) G14(10.401,-4.801) H1(0,-5.601) H2(0.8,-5.601) H3(1.6,-5.601) H4(2.4,-5.601) H5(3.2,-5.601) H10(7.201,-5.601) H11(8.001,-5.601) H12(8.801,-5.601) H13(9.601,-5.601) H14(10.401,-5.601) J1(0,-6.401) J2(0.8,-6.401) J3(1.6,-6.401) J4(2.4,-6.401) J5(3.2,-6.401) J10(7.201,-6.401) J11(8.001,-6.401) J12(8.801,-6.401) J13(9.601,-6.401) J14(10.401,-6.401) K1(0,-7.201) K2(0.8,-7.201) K3(1.6,-7.201) K4(2.4,-7.201) K5(3.2,-7.201) K10(7.201,-7.201) K11(8.001,-7.201) K12(8.801,-7.201) K13(9.601,-7.201) K14(10.401,-7.201) L1(0,-8.001) L2(0.8,-8.001) L3(1.6,-8.001) L4(2.4,-8.001) L5(3.2,-8.001) L10(7.201,-8.001) L11(8.001,-8.001) L12(8.801,-8.001) L13(9.601,-8.001) L14(10.401,-8.001) M1(0,-8.801) M2(0.8,-8.801) M3(1.6,-8.801) M4(2.4,-8.801) M5(3.2,-8.801) M10(7.201,-8.801) M11(8.001,-8.801) M12(8.801,-8.801) M13(9.601,-8.801) M14(10.401,-8.801) N1(0,-9.601) N2(0.8,-9.601) N3(1.6,-9.601) N4(2.4,-9.601) N5(3.2,-9.601) N10(7.201,-9.601) N11(8.001,-9.601) N12(8.801,-9.601) N13(9.601,-9.601) N14(10.401,-9.601) P1(0,-10.401) P2(0.8,-10.401) P3(1.6,-10.401) P4(2.4,-10.401) P5(3.2,-10.401) P10(7.201,-10.401) P11(8.001,-10.401) P12(8.801,-10.401) P13(9.601,-10.401) P14(10.401,-10.401) R1(0,-11.201) R2(0.8,-11.201) R3(1.6,-11.201) R4(2.4,-11.201) R5(3.2,-11.201) R10(7.201,-11.201) R11(8.001,-11.201) R12(8.801,-11.201) R13(9.601,-11.201) R14(10.401,-11.201) T1(0,-12.002) T2(0.8,-12.002) T3(1.6,-12.002) T4(2.4,-12.002) T5(3.2,-12.002) T10(7.201,-12.002) T11(8.001,-12.002) T12(8.801,-12.002) T13(9.601,-12.002) T14(10.401,-12.002) U1(0,-12.802) U2(0.8,-12.802) U3(1.6,-12.802) U4(2.4,-12.802) U5(3.2,-12.802) U10(7.201,-12.802) U11(8.001,-12.802) U12(8.801,-12.802) U13(9.601,-12.802) U14(10.401,-12.802)
KB9542Q-B_LQFP128_14X14
  oval 1.803x0.254 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 8(0,-2.8) 9(0,-3.2) 10(0,-3.6) 11(0,-4) 12(0,-4.4) 13(0,-4.8) 14(0,-5.2) 15(0,-5.6) 16(0,-6) 17(0,-6.4) 18(0,-6.8) 19(0,-7.2) 20(0,-7.6) 21(0,-8) 22(0,-8.4) 23(0,-8.8) 24(0,-9.2) 25(0,-9.6) 26(0,-10) 27(0,-10.4) 28(0,-10.8) 29(0,-11.2) 30(0,-11.6) 31(0,-12) 32(0,-12.4) 65(15.654,-12.4) 66(15.654,-12) 67(15.654,-11.6) 68(15.654,-11.2) 69(15.654,-10.8) 70(15.654,-10.4) 71(15.654,-10) 72(15.654,-9.6) 73(15.654,-9.2) 74(15.654,-8.8) 75(15.654,-8.4) 76(15.654,-8) 77(15.654,-7.6) 78(15.654,-7.2) 79(15.654,-6.8) 80(15.654,-6.4) 81(15.654,-6) 82(15.654,-5.6) 83(15.654,-5.2) 84(15.654,-4.8) 85(15.654,-4.4) 86(15.654,-4) 87(15.654,-3.6) 88(15.654,-3.2) 89(15.654,-2.8) 90(15.654,-2.4) 91(15.654,-2) 92(15.654,-1.6) 93(15.654,-1.2) 94(15.654,-0.8) 95(15.654,-0.4) 96(15.654,0)
  oval 0.254x1.803 smd: 33(1.627,-14.027) 34(2.027,-14.027) 35(2.427,-14.027) 36(2.827,-14.027) 37(3.227,-14.027) 38(3.627,-14.027) 39(4.027,-14.027) 40(4.427,-14.027) 41(4.827,-14.027) 42(5.227,-14.027) 43(5.627,-14.027) 44(6.027,-14.027) 45(6.427,-14.027) 46(6.827,-14.027) 47(7.227,-14.027) 48(7.627,-14.027) 49(8.027,-14.027) 50(8.427,-14.027) 51(8.827,-14.027) 52(9.227,-14.027) 53(9.627,-14.027) 54(10.027,-14.027) 55(10.427,-14.027) 56(10.827,-14.027) 57(11.227,-14.027) 58(11.627,-14.027) 59(12.027,-14.027) 60(12.427,-14.027) 61(12.827,-14.027) 62(13.227,-14.027) 63(13.627,-14.027) 64(14.027,-14.027) 97(14.027,1.627) 98(13.627,1.627) 99(13.227,1.627) 100(12.827,1.627) 101(12.427,1.627) 102(12.027,1.627) 103(11.627,1.627) 104(11.227,1.627) 105(10.827,1.627) 106(10.427,1.627) 107(10.027,1.627) 108(9.627,1.627) 109(9.227,1.627) 110(8.827,1.627) 111(8.427,1.627) 112(8.027,1.627) 113(7.627,1.627) 114(7.227,1.627) 115(6.827,1.627) 116(6.427,1.627) 117(6.027,1.627) 118(5.627,1.627) 119(5.227,1.627) 120(4.827,1.627) 121(4.427,1.627) 122(4.027,1.627) 123(3.627,1.627) 124(3.227,1.627) 125(2.827,1.627) 126(2.427,1.627) 127(2.027,1.627) 128(1.627,1.627)
L2N7002DW1T1G_SC88-6
  oval 0.406x0.508 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0.65,1.9) 6(0,1.9)
L2N7002WT1G_SC-70-3
  oval 0.711x0.889 smd: 1(0,0) 2(-0.65,-1.9) 3(0.65,-1.9)
L03ESDL5V0CC3-2_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
L30ESD24VC3-2_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
L_5X5X3_M
  custom 0.54x0.54 smd: 1(0,0) 4(4.35,0)
  rect 0.762x0.508 smd: 2(0.699,0) 3(3.652,0)
L_5X5X3_M_2P
  rect 2.159x2.794 smd: 1(0,0) 2(4.35,0)
L_7X7X3_M
  custom 0.591x0.591 smd: 1(0,0) 4(6.05,0)
  rect 0.762x0.508 smd: 2(0.8,0) 3(5.25,0)
L_7X7X3_M_2P
  rect 2.362x3.505 smd: 1(0,0) 2(6.05,0)
LED_LTST-S270KFKT-5A_2P
  rect 1.092x1.092 smd: 1(0,0) 2(2,0)
LED_LTW-482DS5_2P
  rect 0.838x1.194 smd: 1(0,0) 2(1.65,0)
LOTES_APCI0019-P003H_67P
  round 1.092 hole 1.092 unplated: (-0.75,-5.275)
  round 1.6 hole 1.6 unplated: (19.25,-5.275)
  oval 0.305x1.549 smd: 1(0,0) 2(0.25,-7.55) 3(0.5,0) 4(0.75,-7.55) 5(1,0) 6(1.25,-7.55) 7(1.5,0) 8(1.75,-7.55) 9(2,0) 10(2.25,-7.55) 11(2.5,0) 12(2.75,-7.55) 13(3,0) 14(3.25,-7.55) 15(3.5,0) 16(3.75,-7.55) 17(4,0) 18(4.25,-7.55) 19(4.5,0) 20(4.75,-7.55) 21(5,0) 22(5.25,-7.55) 23(5.5,0) 24(7.75,-7.55) 25(8,0) 26(8.25,-7.55) 27(8.5,0) 28(8.75,-7.55) 29(9,0) 30(9.25,-7.55) 31(9.5,0) 32(9.75,-7.55) 33(10,0) 34(10.25,-7.55) 35(10.5,0) 36(10.75,-7.55) 37(11,0) 38(11.25,-7.55) 39(11.5,0) 40(11.75,-7.55) 41(12,0) 42(12.25,-7.55) 43(12.5,0) 44(12.75,-7.55) 45(13,0) 46(13.25,-7.55) 47(13.5,0) 48(13.75,-7.55) 49(14,0) 50(14.25,-7.55) 51(14.5,0) 52(14.75,-7.55) 53(15,0) 54(15.25,-7.55) 55(15.5,0) 56(15.75,-7.55) 57(16,0) 58(16.25,-7.55) 59(16.5,0) 60(16.75,-7.55) 61(17,0) 62(17.25,-7.55) 63(17.5,0) 64(17.75,-7.55) 65(18,0) 66(18.25,-7.55) 67(18.5,0)
  rect 1.194x2.743 smd: 68(-1.1,-0.775) 69(19.6,-0.775)
LP2301ALT1G_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
LP2305LT1G_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
LRB521S-40T1G_SOD523-2-2
  rect 0.483x0.406 smd: 1(0,0) 2(1.32,0)
LUDZS3P6BT1G_SOD323-2
  rect 0.635x0.838 smd: 1(0,0) 2(2.225,0)
MAG_MMD06BZER15MEM_4P
  custom 0.591x0.591 smd: 1(0,0) 4(6.05,0)
  rect 0.762x0.508 smd: 2(0.8,0) 3(5.25,0)
MC74VHC1G09DFT2G_SC70-5
  oval 0.406x0.508 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0,1.9)
MESS138W-G_SOT323-3
  oval 0.711x0.889 smd: 1(0,0) 2(-0.65,-1.9) 3(0.65,-1.9)
MMBF170-7-F_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
MMBT3904W_SOT323-3
  oval 0.813x0.914 smd: 1(0,0) 2(0.65,1.6) 3(-0.65,1.6)
MMBT3904WH_SOT323-3
  oval 0.61x0.787 smd: 1(0,0) 2(-0.65,-1.6) 3(0.65,-1.6)
MURAT_BLM15AX221SN1D_2P
  rect 0.457x0.508 smd: 1(0,0) 2(0.85,0)
MURAT_BLM15AX601SN1D_2P
  rect 0.457x0.508 smd: 1(0,0) 2(0.85,0)
MURAT_BLM15BD601SN1D_2P
  rect 0.508x0.762 smd: 1(0,0) 2(0.75,0)
MURAT_BLM18PG330SN1D_2P
  rect 0.66x1.041 smd: 1(0,0) 2(1.2,0)
MURAT_DLM0NSN900HY2D_4P
  rect 0.305x0.305 smd: 1(0,0) 2(0.6,0) 3(0.6,-0.5) 4(0,-0.5)
N17P-G1-A1_FCBGA_908P
  round 0.381 smd: A2(0.8,0) A3(1.6,0) A5(3.3,0) A6(4.1,0) A8(5.8,0) A9(6.6,0) A11(8.3,0) A12(9.1,0) A14(10.8,0) A15(11.6,0) A17(13.3,0) A18(14.1,0) A20(15.8,0) A21(16.6,0) A23(18.3,0) A24(19.1,0) A26(20.8,0) A27(21.6,0) A29(23.3,0) A30(24.1,0) A32(25.8,0) A33(26.6,0) AA1(0,-16.6) AA2(0.8,-16.6) AA3(1.6,-16.6) AA4(2.4,-16.6) AA5(3.2,-16.6) AA6(4.05,-16.6) AA7(4.9,-16.6) AA8(5.7,-16.6) AA27(21.7,-16.6) AA28(22.5,-16.6) AA29(23.35,-16.6) AA30(24.2,-16.6) AA31(25,-16.6) AA32(25.8,-16.6) AA33(26.6,-16.6) AA34(27.4,-16.6) AB2(0.8,-17.45) AB3(1.6,-17.45) AB4(2.4,-17.45) AB5(3.2,-17.45) AB7(4.9,-17.45) AB8(5.7,-17.45) AB27(21.7,-17.45) AB28(22.5,-17.45) AB30(24.2,-17.45) AB31(25,-17.45) AB32(25.8,-17.45) AB33(26.6,-17.45) AC1(0,-18.3) AC2(0.8,-18.3) AC3(1.6,-18.3) AC4(2.4,-18.3) AC5(3.2,-18.3) AC6(4.05,-18.3) AC7(4.9,-18.3) AC8(5.7,-18.3) AC27(21.7,-18.3) AC28(22.5,-18.3) AC29(23.35,-18.3) AC30(24.2,-18.3) AC31(25,-18.3) AC32(25.8,-18.3) AC33(26.6,-18.3) AC34(27.4,-18.3) AD1(0,-19.1) AD2(0.8,-19.1) AD3(1.6,-19.1) AD4(2.4,-19.1) AD5(3.2,-19.1) AD6(4.05,-19.1) AD7(4.9,-19.1) AD8(5.7,-19.1) AD27(21.7,-19.1) AD28(22.5,-19.1) AD29(23.35,-19.1) AD30(24.2,-19.1) AD31(25,-19.1) AD32(25.8,-19.1) AD33(26.6,-19.1) AD34(27.4,-19.1) AE2(0.8,-19.95) AE3(1.6,-19.95) AE4(2.4,-19.95) AE5(3.2,-19.95) AE7(4.9,-19.95) AE8(5.7,-19.95) AE27(21.7,-19.95) AE28(22.5,-19.95) AE30(24.2,-19.95) AE31(25,-19.95) AE32(25.8,-19.95) AE33(26.6,-19.95) AF1(0,-20.8) AF2(0.8,-20.8) AF3(1.6,-20.8) AF4(2.4,-20.8) AF5(3.2,-20.8) AF6(4.05,-20.8) AF7(4.9,-20.8) AF8(5.7,-20.8) AF27(21.7,-20.8) AF28(22.5,-20.8) AF29(23.35,-20.8) AF30(24.2,-20.8) AF31(25,-20.8) AF32(25.8,-20.8) AF33(26.6,-20.8) AF34(27.4,-20.8) AG1(0,-21.6) AG2(0.8,-21.6) AG3(1.6,-21.6) AG4(2.4,-21.6) AG5(3.2,-21.6) AG6(4.05,-21.6) AG7(4.9,-21.6) AG8(5.7,-21.7) AG9(6.6,-21.7) AG10(7.45,-21.7) AG11(8.3,-21.7) AG12(9.1,-21.7) AG13(9.95,-21.7) AG14(10.8,-21.7) AG15(11.6,-21.7) AG16(12.45,-21.7) AG17(13.3,-21.7) AG18(14.1,-21.7) AG19(14.95,-21.7) AG20(15.8,-21.7) AG21(16.6,-21.7) AG22(17.45,-21.7) AG23(18.3,-21.7) AG24(19.1,-21.7) AG25(19.95,-21.7) AG26(20.8,-21.7) AG27(21.7,-21.7) AG28(22.5,-21.6) AG29(23.35,-21.6) AG30(24.2,-21.6) AG31(25,-21.6) AG32(25.8,-21.6) AG33(26.6,-21.6) AG34(27.4,-21.6) AH2(0.8,-22.45) AH3(1.6,-22.45) AH4(2.4,-22.45) AH5(3.2,-22.45) AH6(4.05,-22.45) AH7(4.9,-22.5) AH8(5.8,-22.5) AH9(6.6,-22.5) AH10(7.45,-22.5) AH11(8.3,-22.5) AH12(9.1,-22.5) AH13(9.95,-22.5) AH14(10.8,-22.5) AH15(11.6,-22.5) AH16(12.45,-22.5) AH17(13.3,-22.5) AH18(14.1,-22.5) AH19(14.95,-22.5) AH20(15.8,-22.5) AH21(16.6,-22.5) AH22(17.45,-22.5) AH23(18.3,-22.5) AH24(19.1,-22.5) AH25(19.95,-22.5) AH26(20.8,-22.5) AH27(21.6,-22.5) AH28(22.5,-22.5) AH29(23.35,-22.45) AH30(24.2,-22.45) AH31(25,-22.45) AH32(25.8,-22.45) AH33(26.6,-22.45) AJ1(0,-23.3) AJ2(0.8,-23.3) AJ3(1.6,-23.3) AJ4(2.4,-23.3) AJ5(3.2,-23.3) AJ6(4.05,-23.35) AJ7(4.95,-23.35) AJ8(5.8,-23.35) AJ9(6.6,-23.35) AJ11(8.3,-23.35) AJ12(9.1,-23.35) AJ14(10.8,-23.35) AJ15(11.6,-23.35) AJ17(13.3,-23.35) AJ18(14.1,-23.35) AJ20(15.8,-23.35) AJ21(16.6,-23.35) AJ23(18.3,-23.35) AJ24(19.1,-23.35) AJ26(20.8,-23.35) AJ27(21.6,-23.35) AJ28(22.45,-23.35) AJ29(23.35,-23.35) AJ30(24.2,-23.3) AJ31(25,-23.3) AJ32(25.8,-23.3) AJ33(26.6,-23.3) AJ34(27.4,-23.3) AK1(0,-24.1) AK2(0.8,-24.1) AK3(1.6,-24.1) AK4(2.4,-24.1) AK5(3.2,-24.2) AK6(4.1,-24.2) AK7(4.95,-24.2) AK8(5.8,-24.2) AK9(6.6,-24.2) AK10(7.45,-24.2) AK11(8.3,-24.2) AK12(9.1,-24.2) AK13(9.95,-24.2) AK14(10.8,-24.2) AK15(11.6,-24.2) AK16(12.45,-24.2) AK17(13.3,-24.2) AK18(14.1,-24.2) AK19(14.95,-24.2) AK20(15.8,-24.2) AK21(16.6,-24.2) AK22(17.45,-24.2) AK23(18.3,-24.2) AK24(19.1,-24.2) AK25(19.95,-24.2) AK26(20.8,-24.2) AK27(21.6,-24.2) AK28(22.45,-24.2) AK29(23.3,-24.2) AK30(24.2,-24.2) AK31(25,-24.1) AK32(25.8,-24.1) AK33(26.6,-24.1) AK34(27.4,-24.1) AL2(0.8,-24.95) AL3(1.6,-24.95) AL4(2.4,-25) AL5(3.3,-25) AL6(4.1,-25) AL7(4.95,-25) AL8(5.8,-25) AL9(6.6,-25) AL10(7.45,-25) AL11(8.3,-25) AL12(9.1,-25) AL13(9.95,-25) AL14(10.8,-25) AL15(11.6,-25) AL16(12.45,-25) AL17(13.3,-25) AL18(14.1,-25) AL19(14.95,-25) AL20(15.8,-25) AL21(16.6,-25) AL22(17.45,-25) AL23(18.3,-25) AL24(19.1,-25) AL25(19.95,-25) AL26(20.8,-25) AL27(21.6,-25) AL28(22.45,-25) AL29(23.3,-25) AL30(24.1,-25) AL31(25,-25) AL32(25.8,-24.95) AL33(26.6,-24.95) AM1(0,-25.8) AM2(0.8,-25.8) AM3(1.6,-25.8) AM4(2.45,-25.8) AM5(3.3,-25.8) AM6(4.1,-25.8) AM7(4.95,-25.8) AM8(5.8,-25.8) AM9(6.6,-25.8) AM10(7.45,-25.8) AM11(8.3,-25.8) AM12(9.1,-25.8) AM13(9.95,-25.8) AM14(10.8,-25.8) AM15(11.6,-25.8) AM16(12.45,-25.8) AM17(13.3,-25.8) AM18(14.1,-25.8) AM19(14.95,-25.8) AM20(15.8,-25.8) AM21(16.6,-25.8) AM22(17.45,-25.8) AM23(18.3,-25.8) AM24(19.1,-25.8) AM25(19.95,-25.8) AM26(20.8,-25.8) AM27(21.6,-25.8) AM28(22.45,-25.8) AM29(23.3,-25.8) AM30(24.1,-25.8) AM31(24.95,-25.8) AM32(25.8,-25.8) AM33(26.6,-25.8) AM34(27.4,-25.8) AN1(0,-26.6) AN2(0.8,-26.6) AN3(1.6,-26.6) AN4(2.45,-26.6) AN5(3.3,-26.6) AN6(4.1,-26.6) AN7(4.95,-26.6) AN8(5.8,-26.6) AN9(6.6,-26.6) AN10(7.45,-26.6) AN11(8.3,-26.6) AN12(9.1,-26.6) AN13(9.95,-26.6) AN14(10.8,-26.6) AN15(11.6,-26.6) AN16(12.45,-26.6) AN17(13.3,-26.6) AN18(14.1,-26.6) AN19(14.95,-26.6) AN20(15.8,-26.6) AN21(16.6,-26.6) AN22(17.45,-26.6) AN23(18.3,-26.6) AN24(19.1,-26.6) AN25(19.95,-26.6) AN26(20.8,-26.6) AN27(21.6,-26.6) AN28(22.45,-26.6) AN29(23.3,-26.6) AN30(24.1,-26.6) AN31(24.95,-26.6) AN32(25.8,-26.6) AN33(26.6,-26.6) AN34(27.4,-26.6) AP2(0.8,-27.4) AP3(1.6,-27.4) AP5(3.3,-27.4) AP6(4.1,-27.4) AP8(5.8,-27.4) AP9(6.6,-27.4) AP11(8.3,-27.4) AP12(9.1,-27.4) AP14(10.8,-27.4) AP15(11.6,-27.4) AP17(13.3,-27.4) AP18(14.1,-27.4) AP20(15.8,-27.4) AP21(16.6,-27.4) AP23(18.3,-27.4) AP24(19.1,-27.4) AP26(20.8,-27.4) AP27(21.6,-27.4) AP29(23.3,-27.4) AP30(24.1,-27.4) AP32(25.8,-27.4) AP33(26.6,-27.4) B1(0,-0.8) B2(0.8,-0.8) B3(1.6,-0.8) B4(2.45,-0.8) B5(3.3,-0.8) B6(4.1,-0.8) B7(4.95,-0.8) B8(5.8,-0.8) B9(6.6,-0.8) B10(7.45,-0.8) B11(8.3,-0.8) B12(9.1,-0.8) B13(9.95,-0.8) B14(10.8,-0.8) B15(11.6,-0.8) B16(12.45,-0.8) B17(13.3,-0.8) B18(14.1,-0.8) B19(14.95,-0.8) B20(15.8,-0.8) B21(16.6,-0.8) B22(17.45,-0.8) B23(18.3,-0.8) B24(19.1,-0.8) B25(19.95,-0.8) B26(20.8,-0.8) B27(21.6,-0.8) B28(22.45,-0.8) B29(23.3,-0.8) B30(24.1,-0.8) B31(24.95,-0.8) B32(25.8,-0.8) B33(26.6,-0.8) B34(27.4,-0.8) C1(0,-1.6) C2(0.8,-1.6) C3(1.6,-1.6) C4(2.45,-1.6) C5(3.3,-1.6) C6(4.1,-1.6) C7(4.95,-1.6) C8(5.8,-1.6) C9(6.6,-1.6) C10(7.45,-1.6) C11(8.3,-1.6) C12(9.1,-1.6) C13(9.95,-1.6) C14(10.8,-1.6) C15(11.6,-1.6) C16(12.45,-1.6) C17(13.3,-1.6) C18(14.1,-1.6) C19(14.95,-1.6) C20(15.8,-1.6) C21(16.6,-1.6) C22(17.45,-1.6) C23(18.3,-1.6) C24(19.1,-1.6) C25(19.95,-1.6) C26(20.8,-1.6) C27(21.6,-1.6) C28(22.45,-1.6) C29(23.3,-1.6) C30(24.1,-1.6) C31(24.95,-1.6) C32(25.8,-1.6) C33(26.6,-1.6) C34(27.4,-1.6) D2(0.8,-2.45) D3(1.6,-2.45) D4(2.4,-2.4) D5(3.3,-2.4) D6(4.1,-2.4) D7(4.95,-2.4) D8(5.8,-2.4) D9(6.6,-2.4) D10(7.45,-2.4) D11(8.3,-2.4) D12(9.1,-2.4) D13(9.95,-2.4) D14(10.8,-2.4) D15(11.6,-2.4) D16(12.45,-2.4) D17(13.3,-2.4) D18(14.1,-2.4) D19(14.95,-2.4) D20(15.8,-2.4) D21(16.6,-2.4) D22(17.45,-2.4) D23(18.3,-2.4) D24(19.1,-2.4) D25(19.95,-2.4) D26(20.8,-2.4) D27(21.6,-2.4) D28(22.45,-2.4) D29(23.3,-2.4) D30(24.1,-2.4) D31(25,-2.4) D32(25.8,-2.45) D33(26.6,-2.45) E1(0,-3.3) E2(0.8,-3.3) E3(1.6,-3.3) E4(2.4,-3.3) E5(3.2,-3.2) E6(4.1,-3.2) E7(4.95,-3.2) E8(5.8,-3.2) E9(6.6,-3.2) E10(7.45,-3.2) E11(8.3,-3.2) E12(9.1,-3.2) E13(9.95,-3.2) E14(10.8,-3.2) E15(11.6,-3.2) E16(12.45,-3.2) E17(13.3,-3.2) E18(14.1,-3.2) E19(14.95,-3.2) E20(15.8,-3.2) E21(16.6,-3.2) E22(17.45,-3.2) E23(18.3,-3.2) E24(19.1,-3.2) E25(19.95,-3.2) E26(20.8,-3.2) E27(21.6,-3.2) E28(22.45,-3.2) E29(23.3,-3.2) E30(24.2,-3.2) E31(25,-3.3) E32(25.8,-3.3) E33(26.6,-3.3) E34(27.4,-3.3) F1(0,-4.1) F2(0.8,-4.1) F3(1.6,-4.1) F4(2.4,-4.1) F5(3.2,-4.1) F6(4.05,-4.05) F7(4.95,-4.05) F8(5.8,-4.05) F9(6.6,-4.05) F11(8.3,-4.05) F12(9.1,-4.05) F14(10.8,-4.05) F15(11.6,-4.05) F17(13.3,-4.05) F18(14.1,-4.05) F20(15.8,-4.05) F21(16.6,-4.05) F23(18.3,-4.05) F24(19.1,-4.05) F26(20.8,-4.05) F27(21.6,-4.05) F28(22.45,-4.05) F29(23.35,-4.05) F30(24.2,-4.1) F31(25,-4.1) F32(25.8,-4.1) F33(26.6,-4.1) F34(27.4,-4.1) G2(0.8,-4.95) G3(1.6,-4.95) G4(2.4,-4.95) G5(3.2,-4.95) G6(4.05,-4.95) G7(4.9,-4.9) G8(5.8,-4.9) G9(6.6,-4.9) G10(7.45,-4.9) G11(8.3,-4.9) G12(9.1,-4.9) G13(9.95,-4.9) G14(10.8,-4.9) G15(11.6,-4.9) G16(12.45,-4.9) G17(13.3,-4.9) G18(14.1,-4.9) G19(14.95,-4.9) G20(15.8,-4.9) G21(16.6,-4.9) G22(17.45,-4.9) G23(18.3,-4.9) G24(19.1,-4.9) G25(19.95,-4.9) G26(20.8,-4.9) G27(21.6,-4.9) G28(22.5,-4.9) G29(23.35,-4.95) G30(24.2,-4.95) G31(25,-4.95) G32(25.8,-4.95) G33(26.6,-4.95) H1(0,-5.8) H2(0.8,-5.8) H3(1.6,-5.8) H4(2.4,-5.8) H5(3.2,-5.8) H6(4.05,-5.8) H7(4.9,-5.8) H8(5.7,-5.7) H9(6.6,-5.7) H10(7.45,-5.7) H11(8.3,-5.7) H12(9.1,-5.7) H13(9.95,-5.7) H14(10.8,-5.7) H15(11.6,-5.7) H16(12.45,-5.7) H17(13.3,-5.7) H18(14.1,-5.7) H19(14.95,-5.7) H20(15.8,-5.7) H21(16.6,-5.7) H22(17.45,-5.7) H23(18.3,-5.7) H24(19.1,-5.7) H25(19.95,-5.7) H26(20.8,-5.7) H27(21.7,-5.7) H28(22.5,-5.8) H29(23.35,-5.8) H30(24.2,-5.8) H31(25,-5.8) H32(25.8,-5.8) H33(26.6,-5.8) H34(27.4,-5.8) J1(0,-6.6) J2(0.8,-6.6) J3(1.6,-6.6) J4(2.4,-6.6) J5(3.2,-6.6) J6(4.05,-6.6) J7(4.9,-6.6) J8(5.7,-6.6) J27(21.7,-6.6) J28(22.5,-6.6) J29(23.35,-6.6) J30(24.2,-6.6) J31(25,-6.6) J32(25.8,-6.6) J33(26.6,-6.6) J34(27.4,-6.6) K2(0.8,-7.45) K3(1.6,-7.45) K4(2.4,-7.45) K5(3.2,-7.45) K7(4.9,-7.45) K8(5.7,-7.45) K27(21.7,-7.45) K28(22.5,-7.45) K30(24.2,-7.45) K31(25,-7.45) K32(25.8,-7.45) K33(26.6,-7.45) L1(0,-8.3) L2(0.8,-8.3) L3(1.6,-8.3) L4(2.4,-8.3) L5(3.2,-8.3) L6(4.05,-8.3) L7(4.9,-8.3) L8(5.7,-8.3) L27(21.7,-8.3) L28(22.5,-8.3) L29(23.35,-8.3) L30(24.2,-8.3) L31(25,-8.3) L32(25.8,-8.3) L33(26.6,-8.3) L34(27.4,-8.3) M1(0,-9.1) M2(0.8,-9.1) M3(1.6,-9.1) M4(2.4,-9.1) M5(3.2,-9.1) M6(4.05,-9.1) M7(4.9,-9.1) M8(5.7,-9.1) M27(21.7,-9.1) M28(22.5,-9.1) M29(23.35,-9.1) M30(24.2,-9.1) M31(25,-9.1) M32(25.8,-9.1) M33(26.6,-9.1) M34(27.4,-9.1) N2(0.8,-9.95) N3(1.6,-9.95) N4(2.4,-9.95) N5(3.2,-9.95) N7(4.9,-9.95) N8(5.7,-9.95) N27(21.7,-9.95) N28(22.5,-9.95) N30(24.2,-9.95) N31(25,-9.95) N32(25.8,-9.95) N33(26.6,-9.95) P1(0,-10.8) P2(0.8,-10.8) P3(1.6,-10.8) P4(2.4,-10.8) P5(3.2,-10.8) P6(4.05,-10.8) P7(4.9,-10.8) P8(5.7,-10.8) P27(21.7,-10.8) P28(22.5,-10.8) P29(23.35,-10.8) P30(24.2,-10.8) P31(25,-10.8) P32(25.8,-10.8) P33(26.6,-10.8) P34(27.4,-10.8) R1(0,-11.6) R2(0.8,-11.6) R3(1.6,-11.6) R4(2.4,-11.6) R5(3.2,-11.6) R6(4.05,-11.6) R7(4.9,-11.6) R8(5.7,-11.6) R27(21.7,-11.6) R28(22.5,-11.6) R29(23.35,-11.6) R30(24.2,-11.6) R31(25,-11.6) R32(25.8,-11.6) R33(26.6,-11.6) R34(27.4,-11.6) T2(0.8,-12.45) T3(1.6,-12.45) T4(2.4,-12.45) T5(3.2,-12.45) T7(4.9,-12.45) T8(5.7,-12.45) T27(21.7,-12.45) T28(22.5,-12.45) T30(24.2,-12.45) T31(25,-12.45) T32(25.8,-12.45) T33(26.6,-12.45) U1(0,-13.3) U2(0.8,-13.3) U3(1.6,-13.3) U4(2.4,-13.3) U5(3.2,-13.3) U6(4.05,-13.3) U7(4.9,-13.3) U8(5.7,-13.3) U27(21.7,-13.3) U28(22.5,-13.3) U29(23.35,-13.3) U30(24.2,-13.3) U31(25,-13.3) U32(25.8,-13.3) U33(26.6,-13.3) U34(27.4,-13.3) V1(0,-14.1) V2(0.8,-14.1) V3(1.6,-14.1) V4(2.4,-14.1) V5(3.2,-14.1) V6(4.05,-14.1) V7(4.9,-14.1) V8(5.7,-14.1) V27(21.7,-14.1) V28(22.5,-14.1) V29(23.35,-14.1) V30(24.2,-14.1) V31(25,-14.1) V32(25.8,-14.1) V33(26.6,-14.1) V34(27.4,-14.1) W2(0.8,-14.95) W3(1.6,-14.95) W4(2.4,-14.95) W5(3.2,-14.95) W7(4.9,-14.95) W8(5.7,-14.95) W27(21.7,-14.95) W28(22.5,-14.95) W30(24.2,-14.95) W31(25,-14.95) W32(25.8,-14.95) W33(26.6,-14.95) Y1(0,-15.8) Y2(0.8,-15.8) Y3(1.6,-15.8) Y4(2.4,-15.8) Y5(3.2,-15.8) Y6(4.05,-15.8) Y7(4.9,-15.8) Y8(5.7,-15.8) Y27(21.7,-15.8) Y28(22.5,-15.8) Y29(23.35,-15.8) Y30(24.2,-15.8) Y31(25,-15.8) Y32(25.8,-15.8) Y33(26.6,-15.8) Y34(27.4,-15.8)
  round 0.406 smd: AA12(8.2,-17.2) AA13(9.2,-17.2) AA14(10.2,-17.2) AA15(11.2,-17.2) AA16(12.2,-17.2) AA17(13.2,-17.2) AA18(14.2,-17.2) AA19(15.2,-17.2) AA20(16.2,-17.2) AA21(17.2,-17.2) AA22(18.2,-17.2) AA23(19.2,-17.2) AB12(8.2,-18.2) AB13(9.2,-18.2) AB14(10.2,-18.2) AB15(11.2,-18.2) AB16(12.2,-18.2) AB17(13.2,-18.2) AB18(14.2,-18.2) AB19(15.2,-18.2) AB20(16.2,-18.2) AB21(17.2,-18.2) AB22(18.2,-18.2) AB23(19.2,-18.2) AC12(8.2,-19.2) AC13(9.2,-19.2) AC14(10.2,-19.2) AC15(11.2,-19.2) AC16(12.2,-19.2) AC17(13.2,-19.2) AC18(14.2,-19.2) AC19(15.2,-19.2) AC20(16.2,-19.2) AC21(17.2,-19.2) AC22(18.2,-19.2) AC23(19.2,-19.2) M12(8.2,-8.2) M13(9.2,-8.2) M14(10.2,-8.2) M15(11.2,-8.2) M16(12.2,-8.2) M17(13.2,-8.2) M18(14.2,-8.2) M19(15.2,-8.2) M20(16.2,-8.2) M21(17.2,-8.2) M22(18.2,-8.2) M23(19.2,-8.2) N12(8.2,-9.2) N13(9.2,-9.2) N14(10.2,-9.2) N15(11.2,-9.2) N16(12.2,-9.2) N17(13.2,-9.2) N18(14.2,-9.2) N19(15.2,-9.2) N20(16.2,-9.2) N21(17.2,-9.2) N22(18.2,-9.2) N23(19.2,-9.2) P12(8.2,-10.2) P13(9.2,-10.2) P14(10.2,-10.2) P15(11.2,-10.2) P16(12.2,-10.2) P17(13.2,-10.2) P18(14.2,-10.2) P19(15.2,-10.2) P20(16.2,-10.2) P21(17.2,-10.2) P22(18.2,-10.2) P23(19.2,-10.2) R12(8.2,-11.2) R13(9.2,-11.2) R14(10.2,-11.2) R15(11.2,-11.2) R16(12.2,-11.2) R17(13.2,-11.2) R18(14.2,-11.2) R19(15.2,-11.2) R20(16.2,-11.2) R21(17.2,-11.2) R22(18.2,-11.2) R23(19.2,-11.2) T12(8.2,-12.2) T13(9.2,-12.2) T14(10.2,-12.2) T15(11.2,-12.2) T16(12.2,-12.2) T17(13.2,-12.2) T18(14.2,-12.2) T19(15.2,-12.2) T20(16.2,-12.2) T21(17.2,-12.2) T22(18.2,-12.2) T23(19.2,-12.2) U12(8.2,-13.2) U13(9.2,-13.2) U14(10.2,-13.2) U15(11.2,-13.2) U16(12.2,-13.2) U17(13.2,-13.2) U18(14.2,-13.2) U19(15.2,-13.2) U20(16.2,-13.2) U21(17.2,-13.2) U22(18.2,-13.2) U23(19.2,-13.2) V12(8.2,-14.2) V13(9.2,-14.2) V14(10.2,-14.2) V15(11.2,-14.2) V16(12.2,-14.2) V17(13.2,-14.2) V18(14.2,-14.2) V19(15.2,-14.2) V20(16.2,-14.2) V21(17.2,-14.2) V22(18.2,-14.2) V23(19.2,-14.2) W12(8.2,-15.2) W13(9.2,-15.2) W14(10.2,-15.2) W15(11.2,-15.2) W16(12.2,-15.2) W17(13.2,-15.2) W18(14.2,-15.2) W19(15.2,-15.2) W20(16.2,-15.2) W21(17.2,-15.2) W22(18.2,-15.2) W23(19.2,-15.2) Y12(8.2,-16.2) Y13(9.2,-16.2) Y14(10.2,-16.2) Y15(11.2,-16.2) Y16(12.2,-16.2) Y17(13.2,-16.2) Y18(14.2,-16.2) Y19(15.2,-16.2) Y20(16.2,-16.2) Y21(17.2,-16.2) Y22(18.2,-16.2) Y23(19.2,-16.2)
NCP81151MNTBG_DFN8_2X2
  oval 0.254x0.787 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(1.5,2.2) 6(1,2.2) 7(0.5,2.2) 8(0,2.2)
  rect 1.194x0.787 smd: 9(0.75,1.1)
NCP81215PMNTXG_QFN52_6X6
  oval 0.711x0.254 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 8(0,-2.8) 9(0,-3.2) 10(0,-3.6) 11(0,-4) 12(0,-4.4) 13(0,-4.8) 27(5.95,-4.8) 28(5.95,-4.4) 29(5.95,-4) 30(5.95,-3.6) 31(5.95,-3.2) 32(5.95,-2.8) 33(5.95,-2.4) 34(5.95,-2) 35(5.95,-1.6) 36(5.95,-1.2) 37(5.95,-0.8) 38(5.95,-0.4) 39(5.95,0)
  oval 0.254x0.711 smd: 14(0.575,-5.375) 15(0.975,-5.375) 16(1.375,-5.375) 17(1.775,-5.375) 18(2.175,-5.375) 19(2.575,-5.375) 20(2.975,-5.375) 21(3.375,-5.375) 22(3.775,-5.375) 23(4.175,-5.375) 24(4.575,-5.375) 25(4.975,-5.375) 26(5.375,-5.375) 40(5.375,0.575) 41(4.975,0.575) 42(4.575,0.575) 43(4.175,0.575) 44(3.775,0.575) 45(3.375,0.575) 46(2.975,0.575) 47(2.575,0.575) 48(2.175,0.575) 49(1.775,0.575) 50(1.375,0.575) 51(0.975,0.575) 52(0.575,0.575)
  rect 4.699x4.699 smd: 53(2.975,-2.4)
NCP81253MNTBG_DFN8_2X2
  oval 0.254x0.787 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(1.5,2.2) 6(1,2.2) 7(0.5,2.2) 8(0,2.2)
  rect 1.194x0.787 smd: 9(0.75,1.1)
NCT7718W_MSOP8
  oval 0.381x1.575 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0) 5(1.95,4.35) 6(1.3,4.35) 7(0.65,4.35) 8(0,4.35)
NL17SZ08DFT2G_SC70-5
  oval 0.406x0.508 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0,1.9)
PJT138KA_SOT363-6
  oval 0.457x0.508 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0.65,1.9) 6(0,1.9)
PS8409QFN48GTR2-A1_QFN48_6X6
  oval 0.889x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 8(0,-2.8) 9(0,-3.2) 10(0,-3.6) 11(0,-4) 12(0,-4.4) 25(6.1,-4.4) 26(6.1,-4) 27(6.1,-3.6) 28(6.1,-3.2) 29(6.1,-2.8) 30(6.1,-2.4) 31(6.1,-2) 32(6.1,-1.6) 33(6.1,-1.2) 34(6.1,-0.8) 35(6.1,-0.4) 36(6.1,0)
  oval 0.203x0.889 smd: 13(0.85,-5.25) 14(1.25,-5.25) 15(1.65,-5.25) 16(2.05,-5.25) 17(2.45,-5.25) 18(2.85,-5.25) 19(3.25,-5.25) 20(3.65,-5.25) 21(4.05,-5.25) 22(4.45,-5.25) 23(4.85,-5.25) 24(5.25,-5.25) 37(5.25,0.85) 38(4.85,0.85) 39(4.45,0.85) 40(4.05,0.85) 41(3.65,0.85) 42(3.25,0.85) 43(2.85,0.85) 44(2.45,0.85) 45(2.05,0.85) 46(1.65,0.85) 47(1.25,0.85) 48(0.85,0.85)
  rect 4.496x4.496 smd: 49(3.05,-2.2)
PUSB3FR4_DFN2510A-10-10
  oval 0.254x0.889 smd: 1(0,0)
  oval 0.254x0.838 smd: 2(0.5,-0.025) 3(1,-0.025) 4(1.5,-0.025) 5(2,-0.025) 6(2,1.125) 7(1.5,1.125) 8(1,1.125) 9(0.5,1.125) 10(0,1.125)
Q_N_DFN56-8-5
  oval 0.61x1.27 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0)
  custom 1.105x1.105 smd: 5(1.905,3.715)
R0201_0OHM
  custom 0.089x0.089 smd: 1(0,0)
  rect 0.381x0.356 smd: 2(0.584,0)
R0402_0OHM
  custom 0.14x0.14 smd: 1(0,0)
  rect 0.508x0.559 smd: 2(0.914,0)
R0603_0OHM
  custom 0.222x0.222 smd: 1(0,0)
  rect 0.635x0.889 smd: 2(1.397,0)
R0805_0OHM
  custom 0.349x0.349 smd: 1(0,0)
  rect 0.813x1.397 smd: 2(1.702,0)
R1206_0OHM
  custom 0.413x0.413 smd: 1(0,0)
  rect 1.016x1.651 smd: 2(2.667,0)
R_0201
  rect 0.381x0.356 smd: 1(0,0) 2(0.584,0)
R_0402
  rect 0.508x0.559 smd: 1(0,0) 2(0.914,0)
R_0603
  rect 0.635x0.889 smd: 1(0,0) 2(1.397,0)
R_0805
  rect 0.813x1.397 smd: 1(0,0) 2(1.702,0)
R_1206
  rect 1.016x1.651 smd: 1(0,0) 2(2.667,0)
R_1206_4P-D
  custom 0.371x0.371 smd: 1(0,0) 4(3.327,0)
  custom 0.114x0.114 smd: 2(0.775,0) 3(2.553,0)
RB751S40T1G_SOD523-2
  rect 0.61x0.787 smd: 1(0,0) 2(1.7,0)
RB751V-40_SOD323-2
  rect 0.787x0.889 smd: 1(0,0) 2(2.14,0)
RT8207PGQW_WQFN20_3X3
  oval 0.203x0.889 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 11(1.6,3.1) 12(1.2,3.1) 13(0.8,3.1) 14(0.4,3.1) 15(0,3.1)
  oval 0.889x0.203 smd: 6(2.35,0.75) 7(2.35,1.15) 8(2.35,1.55) 9(2.35,1.95) 10(2.35,2.35) 16(-0.75,2.35) 17(-0.75,1.95) 18(-0.75,1.55) 19(-0.75,1.15) 20(-0.75,0.75)
  rect 1.702x1.702 smd: 21(0.8,1.55)
RT8237EZQW-2_WDFN10_3X3
  oval 0.254x0.889 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2,3.1) 7(1.5,3.1) 8(1,3.1) 9(0.5,3.1) 10(0,3.1)
  rect 2.464x1.626 smd: 11(1,1.55)
RT8813DGQW_WQFN24_4X4
  oval 0.889x0.254 smd: 1(0,0) 2(0,-0.5) 3(0,-1) 4(0,-1.5) 5(0,-2) 6(0,-2.5) 13(4.1,-2.5) 14(4.1,-2) 15(4.1,-1.5) 16(4.1,-1) 17(4.1,-0.5) 18(4.1,0)
  oval 0.254x0.889 smd: 7(0.8,-3.3) 8(1.3,-3.3) 9(1.8,-3.3) 10(2.3,-3.3) 11(2.8,-3.3) 12(3.3,-3.3) 19(3.3,0.8) 20(2.8,0.8) 21(2.3,0.8) 22(1.8,0.8) 23(1.3,0.8) 24(0.8,0.8)
  rect 2.438x2.438 smd: 25(2.05,-1.25)
RT9053AZQW_WDFN6_2X2
  oval 0.457x0.838 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,2.15) 5(0.65,2.15) 6(0,2.15)
  rect 1.219x0.686 smd: 7(0.65,1.075)
RT9610CGQW_WDFN8_2X2
  oval 0.254x0.838 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(1.5,2.15) 6(1,2.15) 7(0.5,2.15) 8(0,2.15)
  rect 1.118x0.533 smd: 9(0.75,1.075)
RTL8118AS-CG_QFN32_4X4
  oval 0.889x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 8(0,-2.8) 17(4.1,-2.8) 18(4.1,-2.4) 19(4.1,-2) 20(4.1,-1.6) 21(4.1,-1.2) 22(4.1,-0.8) 23(4.1,-0.4) 24(4.1,0)
  oval 0.203x0.889 smd: 9(0.65,-3.45) 10(1.05,-3.45) 11(1.45,-3.45) 12(1.85,-3.45) 13(2.25,-3.45) 14(2.65,-3.45) 15(3.05,-3.45) 16(3.45,-3.45) 25(3.45,0.65) 26(3.05,0.65) 27(2.65,0.65) 28(2.25,0.65) 29(1.85,0.65) 30(1.45,0.65) 31(1.05,0.65) 32(0.65,0.65)
  rect 2.692x2.692 smd: 33(2.05,-1.4)
SDAN_601051-008041_8P
  round 1.295 hole 0.889: 1(0,0) 2(-1.02,1.1) 3(-2.04,0) 4(-3.06,1.1) 5(-4.08,0) 6(-5.1,1.1) 7(-6.12,0) 8(-7.14,1.1)
  oval 0.991x2.007 hole 0.61x1.6: 9(-11.97,-2.3) 10(-11.97,-8.3) 11(4.83,-2.3) 12(4.83,-8.3)
SDAN_606011-032241_32P
  oval 0.305x1.295 smd: 1(0,0) 2(-1,0) 3(-2,0) 4(-3,0) 5(-4,0) 6(-5,0) 7(-6,0) 8(-7,0) 9(-8,0) 10(-9,0) 11(-10,0) 12(-11,0) 13(-12,0) 14(-13,0) 15(-14,0) 16(-15,0) 17(-16,0) 18(-17,0) 19(-18,0) 20(-19,0) 21(-20,0) 22(-21,0) 23(-22,0) 24(-23,0) 25(-24,0) 26(-25,0) 27(-26,0) 28(-27,0) 29(-28,0) 30(-29,0) 31(-30,0) 32(-31,0)
  rect 1.803x2.21 smd: 33(2.4,-3.25) 34(-33.4,-3.25)
SHORTPADS
  custom 0.19x0.19 smd: 1(-0.483,0) 2(0.483,0)
SLB9670VQ1P2-FW4P4X_VQFN32_5X5
  oval 0.889x0.254 smd: 1(0,0) 2(0,-0.5) 3(0,-1) 4(0,-1.5) 5(0,-2) 6(0,-2.5) 7(0,-3) 8(0,-3.5) 17(5.1,-3.5) 18(5.1,-3) 19(5.1,-2.5) 20(5.1,-2) 21(5.1,-1.5) 22(5.1,-1) 23(5.1,-0.5) 24(5.1,0)
  oval 0.254x0.889 smd: 9(0.8,-4.3) 10(1.3,-4.3) 11(1.8,-4.3) 12(2.3,-4.3) 13(2.8,-4.3) 14(3.3,-4.3) 15(3.8,-4.3) 16(4.3,-4.3) 25(4.3,0.8) 26(3.8,0.8) 27(3.3,0.8) 28(2.8,0.8) 29(2.3,0.8) 30(1.8,0.8) 31(1.3,0.8) 32(0.8,0.8)
  rect 3.607x3.607 smd: 33(2.55,-1.75)
SN74LVC1G123DCUR_VSSOP8
  oval 0.254x1.295 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(1.5,2.825) 6(1,2.825) 7(0.5,2.825) 8(0,2.825)
SUYIN_020090HB024M51HZL_24P-T-S
  round 0.711 hole 0.711 unplated: (-0.7,0.03)
  oval 0.838x0.711 hole 0.838x0.711 unplated: (6.2,0.03)
  oval 0.813x1.295 hole 0.508x0.991: 1(7.225,0.43) 6(-1.725,0.43)
  oval 0.991x2.108 hole 0.508x1.6: 2(8.825,-1.93) 3(8.825,-4.77) 4(-3.325,-4.77) 5(-3.325,-1.93)
  rect 0.508x0.279 smd: 7(-0.45,0.733) 10(5.95,0.733)
  rect 0.508x0.305 smd: 8(1.75,0.72) 9(3.75,0.72)
  oval 0.254x0.61 smd: A1(0,0)
  oval 0.305x0.61 smd: A2(0.5,0) A3(1,0) A4(1.5,0) A5(2,0) A6(2.5,0) A7(3,0) A8(3.5,0) A9(4,0) A10(4.5,0) A11(5,0)
  oval 0.229x0.61 smd: A12(5.462,0)
  oval 1.194x0.711 hole 0.889x0.406: B1(5.95,-1.11) B12(-0.45,-1.11)
  oval 0.61x0.787 hole 0.457: B2(5.25,-2.01) B3(4.45,-2.01) B4(4.05,-1.11) B5(3.6,-2.01) B6(3.15,-1.11) B7(2.35,-1.11) B8(1.9,-2.01) B9(1.45,-1.11) B10(1.05,-2.01) B11(0.25,-2.01)
SX34_SMA2
  rect 2.057x2.057 smd: 1(0,0) 2(3.73,0)
SY8003ADFC_DFN8_2X2
  oval 0.254x0.787 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(1.5,2.2) 6(1,2.2) 7(0.5,2.2) 8(0,2.2)
  rect 1.549x0.838 smd: 9(0.75,1.1)
SY8270CTMC_QFN13_3X4
  custom 0.337x0.337 smd: 1(0,0)
  rect 0.457x1.702 smd: 2(1.18,-0.75) 12(1.18,1.25)
  rect 0.838x1.702 smd: 3(2.06,-0.75) 11(2.06,1.25)
  oval 0.203x0.787 smd: 4(2.81,-1.2) 10(2.81,1.7)
  oval 0.787x0.254 smd: 5(3.625,-0.65) 6(3.625,-0.2) 7(3.625,0.25) 8(3.625,0.7) 9(3.625,1.15)
  oval 0.254x0.787 smd: 13(0.55,1.7)
SY8284BRAC_QFN20_3X3
  oval 0.889x0.254 smd: 1(0,0) 2(0,-0.45) 3(0,-0.9) 4(0,-1.35) 5(0,-1.8) 11(3.1,-1.8) 12(3.1,-1.35) 13(3.1,-0.9) 14(3.1,-0.45) 15(3.1,0)
  oval 0.254x0.889 smd: 6(0.65,-2.45) 7(1.1,-2.45) 8(1.55,-2.45) 9(2,-2.45) 10(2.45,-2.45) 16(2.45,0.65) 17(2,0.65) 18(1.55,0.65) 19(1.1,0.65) 20(0.65,0.65)
  custom 0.15x0.15 smd: 21(1.55,-0.9)
