# Allegro board LAJ643PR10-0325.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+5VALW on TOP (solid shape): 23.39,82.87 23.86,82.87 23.99,82.74 24.2,81.29 23.73,80.82 20.87,80.82 20.76,80.93 20.76,82.06 20.33,82.49 20.33,82.94 20.5,83.12 23.14,83.12
+5VALW on TOP (solid shape): 43.91,42.11 43.91,41.7 43.91,41.7 43.91,41.61 43.87,41.57 43.02,41.57 41.94,40.49 39.61,40.49 39.34,40.76 39.34,41.82 39.53,42.01 42.17,42.01 42.32,42.15 43.86,42.15
+5VALW on TOP (solid shape): 80.8,36.67 81.85,36.67 82.01,36.51 82.01,35.97 81.9,35.86 77.84,35.86 77.74,35.77 77.71,35.73 77.71,34.08 77.67,34.03 77.13,34.03 77.05,34.11 77.05,37.75 77.22,37.92 79.55,37.92
+5VALW on TOP (solid shape): 269.36,43.11 269.36,42.99 269.35,42.9 269.37,42.81 269.35,42.72 269.27,42.68 268.32,42.68 268.23,42.78 267.3,42.78 267.25,42.83 267.25,42.93 267.3,42.99 268.19,42.99 268.4,43.19 269.28,43.19
+5VALW on TOP (solid shape): 271.11,45.5 271.11,44.47 270.91,44.27 268.98,44.27 268.87,44.16 268.72,44.16 268.13,43.58 267.3,43.58 267.25,43.63 267.25,43.74 267.29,43.79 267.89,43.79 267.95,43.85 267.95,43.94 267.91,43.97 267.32,43.97 267.25,44.04 267.25,44.43 267.26,44.5 267.25,44.57 267.25,44.6 267.26,44.6 267.26,45.34 267.38,45.47 267.53,45.47 267.64,45.57 267.64,46.27 267.86,46.5 270.12,46.5
+5VALW on BOTTOM (solid shape): 73.17,15.41 73.17,11.51 72.92,11.26 68.83,11.26 68.33,11.76 68.33,13.08 68.64,13.38 68.64,14.44 69.17,14.44 69.17,15.14 68.62,15.14 68.62,15.64 69.17,15.64 69.17,16.34 68.62,16.34 68.62,16.79 71.79,16.79
+5VALW on BOTTOM (solid shape): 310.48,46.38 312.34,46.38 312.42,46.29 312.42,42.38 312.26,42.21 310.68,42.21 309.31,43.58 307.77,43.58 307.47,43.89 307.47,44.92 305.67,44.92 305.55,45.04 305.55,45.38 305.14,45.78 305.14,46.57 305.29,46.72 310.14,46.72
+5VALW on VCC: outline of 196 points within 21.16,11.33 312.43,136.65 ; 2 cut-outs
+5VALWP on TOP (solid shape): 66.54,12.24 66.54,8.68 68.11,7.11 68.11,5.43 67.85,5.18 64.3,5.18 64.04,5.43 64.04,6.32 63.79,6.57 62.9,6.57 62.77,6.7 62.77,7.44 62.6,7.61 62.6,7.82 62.77,7.99 62.77,8.71 62.6,8.88 62.6,9.09 62.77,9.26 62.77,9.98 62.6,10.15 62.6,10.36 62.77,10.53 62.77,11.14 64.15,12.51 66.27,12.51
+5VALWP on BOTTOM (solid shape): 68.49,16.22 69.04,16.22 69.04,15.77 68.49,15.77 68.49,15.02 69.04,15.02 69.04,14.57 68.49,14.57 68.49,13.94 68.49,13.94 68.49,13.82 67.91,13.24 67.91,7.66 68.11,7.46 68.11,5.43 67.85,5.18 64.3,5.18 64.04,5.43 64.04,6.32 63.79,6.57 62.9,6.57 62.77,6.7 62.77,7.44 62.6,7.61 62.6,7.82 62.77,7.99 62.77,8.71 62.6,8.88 62.6,9.09 62.77,9.26 62.77,9.98 62.6,10.15 62.6,10.36 62.77,10.53 62.77,11.4 64.52,13.15 64.52,14.63 66.68,16.79 68.49,16.79
+5VL on TOP (solid shape): outline of 87 points within 75.36,12.97 80.09,20.77
+5VL on BOTTOM (solid shape): 24.89,76.43 24.89,75.38 24.82,75.31 21.27,75.31 21.21,75.37 21.21,76.27 21.28,76.34 21.85,76.34 22.04,76.53 24.8,76.53
+5VL on BOTTOM (solid shape): 80.06,13.34 80.06,12.6 80.01,12.55 79.61,12.55 79.6,12.54 79.6,12.02 79.57,11.99 79.46,11.99 79.43,12.02 79.43,12.54 79.41,12.56 79,12.56 78.91,12.64 78.91,13.33 79.01,13.43 79.98,13.43
+5VLP on BOTTOM (solid shape): 79.3,11.86 79.73,11.86 79.73,12.42 80.03,12.42 80.09,12.36 80.09,11.3 79.91,11.12 79.34,11.12 79.27,11.05 79.27,10.23 79.17,10.13 78.35,10.13 77.72,9.5 76.96,9.5 76.88,9.59 76.88,10.26 77.17,10.26 78.07,11.17 78.07,11.18 78.5,11.61 78.8,11.61 78.93,11.75 78.93,12.33 79.02,12.42 79.3,12.42
+5VS on TOP (solid shape): 287.61,17.42 287.61,15.9 287.48,15.77 285.2,15.77 284.69,16.28 284.69,17.42 285.2,17.93 287.1,17.93
+5VS on TOP (solid shape): 18.24,113.92 18.24,113.08 17.84,112.67 16.08,112.67 15.91,112.85 15.91,113.69 15.98,113.76 16.68,113.76 17,113.78 17.17,114.05 17.33,114.21 17.95,114.21
+5VS on TOP (solid shape): 265.36,45.36 265.36,44.73 265.97,44.12 265.97,44.03 265.91,43.97 265.31,43.97 265.24,43.9 265.24,43.86 265.31,43.79 265.92,43.79 265.97,43.74 265.97,43.63 265.92,43.57 264.44,43.57 264.11,43.24 264.11,43.12 263.91,42.91 262.03,42.91 261.72,42.6 261.18,42.6 261.02,42.77 261.02,43.23 263.22,45.44 265.29,45.44
+5VS on BOTTOM (solid shape): 206.47,10.91 205.84,10.91 205.48,11.26 205.48,11.59 205.84,11.95 206.11,11.95 206.22,12.06 206.22,13.05 206.27,13.09 206.47,13.09
+5VS on BOTTOM (solid shape): 286.24,17.4 286.24,16.26 286.01,16.03 283.85,16.03 283.52,16.36 283.52,17.4 283.64,17.52 283.7,17.55 284.74,17.55 284.76,17.57 286.06,17.57
+5VS on BOTTOM (solid shape): 201.49,13.03 201.49,12.01 201.76,11.74 202.18,11.74 202.31,11.61 202.31,11.07 202,10.77 201.03,10.77 200.89,10.91 200.89,11.92 201.22,12.26 201.22,13.05 201.27,13.1 201.42,13.1
+5VS on BOTTOM (solid shape): 28.77,46.23 30.87,46.23 32.26,44.84 32.26,44.69 32.06,44.48 31.32,44.48 30.14,45.66 28.66,45.66 28.54,45.79 27.91,45.79 27.84,45.86 27.84,46.52 27.87,46.54 28.45,46.54
+5VS on BOTTOM (solid shape): 274.85,48.16 275.98,47.69 277.12,47.25 277.23,47.22 277.57,46.88 277.57,45.29 277.82,45.04 277.82,44.62 277.78,44.58 275.28,44.58 274.64,45.22 274.64,47.95
+5VS on BOTTOM (solid shape): 276.73,16.72 276.73,14.65 275.96,13.88 265.43,13.88 265.28,14.02 259.53,14.02 259.47,13.96 259.44,13.96 259.21,13.73 257.99,13.73 257.86,13.87 257.86,14.41 273.95,14.41 273.95,14.36 273.95,14.31 273.97,14.26 273.99,14.21 274.02,14.17 274.06,14.13 274.1,14.09 274.15,14.07 274.2,14.05 274.25,14.03 274.3,14.03 274.36,14.03 274.41,14.05 274.46,14.07 274.5,14.09 274.54,14.13 274.58,14.17 274.61,14.21 274.63,14.26 274.65,14.31 274.66,14.36 274.66,14.41 274.65,14.47 274.63,14.52 274.61,14.57 274.58,14.61 274.54,14.65 274.5,14.68 274.46,14.71 274.41,14.73 274.36,14.74 274.3,14.74 274.25,14.74 274.2,14.73 274.15,14.71 274.1,14.68 274.06,14.65 274.02,14.61 273.99,14.57 273.97,14.52 273.95,14.47 273.95,14.41 257.86,14.41 257.86,14.51 258.03,14.69 258.22,14.69 258.31,14.78 258.31,16.88 258.41,16.98 276.47,16.98
+5VS on BOTTOM (solid shape): outline of 90 points within 53.82,31.06 57.02,40.82
+5VS on IN2 (solid shape): 17.09,113.15 17.09,112.34 15.98,111.22 15.52,111.22 15.12,111.63 15.12,112.09 15.12,112.09 15.12,112.46 16.06,113.4 16.85,113.4
+5VS on IN2 (solid shape): 264.02,43.9 264.02,43.06 263.84,42.88 261.79,42.88 261.58,42.67 261.21,42.67 261.1,42.77 261.1,43.9 261.21,44 261.37,44 261.37,44.01 263.91,44.01
+5VS on IN2 (solid shape): outline of 108 points within 56.37,29.23 59.28,32.6
+5VS on IN3 (solid shape): outline of 213 points within 95,11.52 99.02,24.8
+5VS on VCC: 178.47,9.68 176.59,11.55 172.22,11.55 169.53,14.25 154.61,14.25 150.22,9.85 94.55,9.85 94.11,10.29 94.11,12.06 94.34,12.29 98.66,12.29 99.26,11.68 149.79,11.68 153.88,15.77 170.18,15.77 172.8,13.15 177.57,13.15 178.66,12.06 199.61,12.06 201.14,13.6 217.26,13.6 218.94,15.27 237.88,15.27 239.78,17.18 270.8,17.18 272.05,18.42 272.05,25.6 271.46,26.19 258.12,26.19 257.89,26.42 257.89,39.07 256.77,40.18 256.77,42.18 257.19,42.59 257.76,42.59 257.95,42.79 257.95,43.06 257.8,43.21 258.59,43.99 263.85,43.99 264.04,43.81 264.04,30.47 264.84,29.68 275.39,29.68 276.08,28.99 276.08,15.11 275.8,14.83 249.35,14.83 247.79,13.28 226.52,13.28 222.91,9.68 ; 1 cut-out
+5VS on IN2: 52.06,39.66 50.53,39.66 50.19,39.33 46.68,39.33 46.35,39 44.25,39 43.92,39.33 39.86,39.33 38.59,40.59 38.59,43.21 36.84,44.96 35.88,45.91 34.29,45.91 33.43,46.77 32.72,46.77 32.71,46.76 31.93,46.76 30.97,47.72 30.65,47.72 29.46,48.92 25.07,48.92 24.46,49.53 24.46,51.33 24.81,51.67 24.83,51.67 25.03,51.69 25.19,51.81 27.35,51.81 27.82,51.33 29.66,51.33 30.09,50.9 32.98,50.9 34.05,49.84 34.58,49.84 35.09,49.33 38.22,46.2 38.72,46.2 43.77,41.15 43.77,40.73 44.18,40.32 48.65,40.32 49.17,40.84 53.61,40.84 53.7,40.79 53.7,40.69 53.93,40.16 54.37,40.53 54.43,40.63 54.54,40.6 54.62,40.53 55.41,40.53 55.59,40.35 55.59,39.55 55.45,39.41 54.95,39.41 54.82,39.28 52.44,39.28
+5VS on IN2: 91.92,26.98 91.91,26.96 92.02,26.7 92.29,26.59 92.31,26.59 93.63,25.27 97.25,25.27 97.68,24.84 97.68,23.81 97.16,23.29 96.78,23.29 96.77,23.3 96.63,23.33 96.49,23.3 96.48,23.29 90.23,23.29 88.13,25.39 85.22,25.39 82.09,28.53 77.81,28.53 77.81,29.69 77.95,29.82 84.57,29.82 86.2,28.19 88.22,28.19 88.47,28.1 88.71,28.19 88.93,28.19 88.98,28.09 89.04,28.01 89.06,27.92 89,27.85 88.97,27.2 89.48,27.61 89.5,27.7 89.58,27.74 89.79,27.76 89.99,27.84 90.71,27.12 90.7,27.09 90.98,26.59 91.38,27 91.4,27.08 91.48,27.11 91.79,27.11
+5VS on IN3: 261,43.94 261,42.74 261.54,42.2 273.25,42.2 273.56,42.51 273.56,42.69 274.41,43.54 276.98,43.54 277.2,43.75 277.2,45.64 276.81,46.03 275.03,46.03 273.15,47.91 265.88,47.91 262.26,44.29 261.35,44.29
+5VS_HDD1 on TOP (solid shape): 248.82,14.97 248.82,12.8 248.69,12.68 248.15,12.68 248.1,12.72 248.1,12.89 248.1,12.94 248.1,12.98 248.1,13.14 247.97,13.28 247.86,13.28 247.75,13.3 247.64,13.28 246.1,13.28 245.9,13.48 245.9,15.13 246.07,15.31 248.47,15.31
+5VS_HDD1 on BOTTOM (solid shape): 257.61,16.93 257.61,14.78 257.58,14.75 256.96,14.75 256.78,14.93 256.53,14.93 256.52,14.93 254.01,14.93 254,14.92 252.33,14.92 250.11,12.7 248.24,12.7 248.13,12.81 248.13,14.47 248.72,15.06 249.86,15.06 249.98,15.17 249.98,16.74 250.23,16.99 257.55,16.99
+5VS_KBL on BOTTOM (solid shape): 213.63,12.7 214.21,12.7 215.15,11.76 215.15,11 215.11,10.97 213.84,10.97 212.93,11.87 212.36,11.87 212.3,11.93 212.3,12.88 213.46,12.88
+5VS_PVDD on TOP (solid shape): 289.39,21.23 289.39,18.95 289.64,18.69 290.91,18.69 291.04,18.57 291.04,18.18 290.91,18.06 290.02,18.06 289.64,17.68 289.64,16.03 289.39,15.77 288.5,15.77 288.42,15.85 288.42,20.27 288.88,20.72 288.88,21.23 289.01,21.36 289.26,21.36
+16.8V_BATT on TOP (solid shape): 274.48,10.82 274.48,7.92 273.39,6.83 269.91,6.83 269.32,7.41 269.32,10.69 269.6,10.97 274.32,10.97
+16.8V_BATT on BOTTOM (solid shape): 272.75,10.56 272.75,5.87 272.27,5.38 269.22,5.38 268.74,5.87 268.74,6.51 269.26,6.51 269.61,6.87 269.26,7.23 268.74,7.23 268.74,8.63 269.35,9.24 269.35,10.55 269.47,10.67 272.65,10.67
+16.8V_BATT+ on TOP (solid shape): 276.46,9.18 276.46,6.77 276.23,6.54 274.95,6.54 274.69,6.79 274.69,9.48 274.78,9.56 276.08,9.56
+16.8V_BATT+ on BOTTOM (solid shape): outline of 510 points within 273.02,5.26 289.21,14.53
+16.8V_BATT_CHG on BOTTOM (solid shape): 264.43,12.81 264.43,11.16 264.82,10.77 265.86,10.77 266.01,10.62 266.01,8.87 266.48,8.41 267.39,8.41 267.71,8.09 267.71,7.23 267.17,7.23 266.82,6.87 267.17,6.51 267.71,6.51 267.71,5.65 267.67,5.61 260.8,5.61 260.58,5.83 260.58,12.98 260.66,13.05 264.19,13.05
+19V_ADPIN on TOP (solid shape): 281.51,39.39 281.51,38 283.8,35.71 283.8,31.18 281.98,29.36 279.35,29.36 277.07,31.65 277.07,37.39 278.04,38.36 279.59,38.36 280.24,39.01 280.24,39.39 280.5,39.65 281.26,39.65
+19V_P1 on TOP (solid shape): 268.39,35.1 268.39,32.11 268.12,31.84 265.29,31.84 265.17,31.96 265.17,34.25 265.3,34.39 266.13,34.39 266.38,34.64 266.38,35.04 265.96,35.47 265.96,36.54 266.02,36.6 266.9,36.6
+19V_P2 on TOP (solid shape): 264.62,35.52 264.62,32.67 264.48,32.53 260.52,32.53 260.27,32.78 260.27,34.11 260.36,34.19 260.8,34.19 261.16,34.54 260.8,34.9 260.32,34.9 260.27,34.96 260.27,35.56 260.39,35.68 264.46,35.68
+19V_VIN on TOP (solid shape): 276.63,36.07 276.63,30.44 276.46,30.27 270.36,30.27 269.23,29.14 267.74,29.14 267.68,29.2 267.68,30.08 267.85,30.26 268.55,30.26 269.01,30.72 269.01,35.33 269.35,35.66 271.93,35.66 272.54,36.27 276.43,36.27
+19VB on TOP (solid shape): 187.58,95.67 187.58,93.36 187.17,92.95 185.73,92.95 185.32,93.36 185.32,95.63 185.84,96.15 187.1,96.15
+19VB on TOP (solid shape): 177.63,82.62 177.65,82.56 177.68,82.5 177.68,80.81 177.43,80.56 175.34,80.56 175.06,80.84 175.06,82.64 175.73,83.31 176.94,83.31
+19VB on TOP (solid shape): 84.27,19.03 84.27,13.3 84.19,13.22 84.19,12.91 84.27,12.83 84.27,12.65 83.71,12.08 83.71,7.65 83.4,7.34 82.66,7.34 82.64,7.32 82.64,6.8 82.62,6.78 82.44,6.78 82.42,6.8 82.42,7.32 82.41,7.33 81.86,7.33 81.85,7.32 81.85,6.79 81.83,6.78 81.62,6.78 81.61,6.79 81.61,7.31 81.59,7.32 81.14,7.32 81.1,7.37 81.1,7.53 81.27,7.72 81.26,7.98 81.26,7.99 81.26,8.28 81.1,8.44 81.1,8.44 80.66,8.89 80.65,8.9 80.55,9.11 80.35,9.21 80.33,9.21 80.26,9.28 80.26,19.65 81.26,20.64 82.66,20.64
+19VB on TOP (solid shape): 170.87,95.21 170.87,93.81 170.78,93.72 168.67,93.72 168.65,93.74 168.6,93.76 168.55,93.77 168.5,93.78 168.45,93.78 168.39,93.77 168.34,93.76 168.32,93.75 167.99,94.07 167.99,95.19 168.02,95.19 168.03,95.14 168.04,95.09 168.06,95.04 168.09,94.99 168.12,94.95 168.16,94.91 168.2,94.88 168.25,94.86 168.3,94.84 168.35,94.83 168.41,94.83 168.46,94.84 168.51,94.86 168.56,94.88 168.6,94.91 168.64,94.95 168.68,94.99 168.7,95.04 168.72,95.09 168.73,95.14 168.74,95.19 168.73,95.24 168.72,95.3 168.7,95.35 168.68,95.39 168.64,95.43 168.6,95.47 168.56,95.5 168.51,95.52 168.46,95.54 168.41,95.55 168.35,95.55 168.3,95.54 168.25,95.52 168.2,95.5 168.16,95.47 168.12,95.43 168.09,95.39 168.06,95.35 168.04,95.3 168.03,95.24 168.02,95.19 167.99,95.19 167.99,95.46 168.27,95.73 170.35,95.73
+19VB on TOP (solid shape): outline of 800 points within 82.68,35.74 110.24,75.41
+19VB on BOTTOM (solid shape): 269.04,13.26 269.04,9.22 268.78,8.95 266.67,8.95 266.37,9.24 266.37,13.23 266.6,13.46 268.84,13.46
+19VB on BOTTOM (solid shape): 185.91,97.22 186.46,97.22 186.46,97.77 186.71,97.77 186.71,97.22 187.19,97.22 187.2,97.19 187.24,97.13 187.3,97.08 187.33,97.07 187.33,94.89 187.24,94.8 187.24,92.91 187.08,92.75 185.08,92.75 184.61,93.22 184.61,97.02 184.84,97.25 184.99,97.25 184.99,97.22 185.66,97.22 185.66,97.77 185.91,97.77
+19VB on BOTTOM (solid shape): outline of 90 points within 238.07,30.02 252.21,44.3
+19VB on IN1 (solid shape): 169.11,94.88 169.11,94.76 170.27,93.6 170.27,93.6 170.76,93.11 170.76,91.43 170.27,90.94 169.76,90.94 168.75,91.95 168.4,91.95 167.98,92.38 167.98,93.13 168.14,93.13 168.14,93.11 168.15,93.05 168.16,93 168.19,92.95 168.22,92.91 168.25,92.87 168.29,92.84 168.34,92.81 168.39,92.79 168.44,92.78 168.49,92.78 168.55,92.78 168.6,92.79 168.65,92.81 168.7,92.84 168.74,92.87 168.77,92.91 168.8,92.95 168.83,93 168.84,93.05 168.85,93.11 168.85,93.16 168.84,93.21 168.83,93.26 168.8,93.31 168.77,93.36 168.74,93.39 168.7,93.43 168.65,93.45 168.6,93.47 168.55,93.49 168.49,93.49 168.44,93.49 168.39,93.47 168.34,93.45 168.29,93.43 168.25,93.39 168.22,93.36 168.19,93.31 168.16,93.26 168.15,93.21 168.14,93.16 168.14,93.13 167.98,93.13 167.98,93.9 167.92,93.95 167.92,94.69 168.05,94.82 168.53,94.82 168.68,94.97 169.03,94.97
+19VB on IN3 (solid shape): outline of 1270 points within 78.82,18.11 91.76,45.62
+19VB on TOP: outline of 228 points within 163.12,11.42 270.43,66.55
+19VB on IN1: 176,82.37 176,83.23 176.52,83.75 176.52,84.23 176.66,84.37 178,84.37 178.15,84.22 178.15,83.4 177.6,82.85 177.6,82.31 177.53,82.23 176.14,82.23
+19VB_1.35VSDGPUP on TOP (solid shape): 257.76,46.49 257.76,44.73 255.35,44.73 254.97,45.11 254.97,46.41 255.12,46.56 257.69,46.56
+19VB_1.35VSDGPUP on BOTTOM (solid shape): 256.88,52.22 256.88,47.38 257.64,46.62 257.64,44.6 257.3,44.27 252.52,44.27 252.32,44.46 251.74,44.46 251.73,44.45 251.73,43.93 251.71,43.9 251.5,43.9 251.49,43.92 251.49,44.45 251.48,44.46 250.94,44.46 250.93,44.45 250.93,43.92 250.92,43.9 250.71,43.9 250.69,43.92 250.69,44.45 250.69,44.46 250.25,44.46 250.22,44.49 250.22,46.7 251.99,48.47 251.99,52.16 252.26,52.43 256.67,52.43
+19VB_1V5 on BOTTOM (solid shape): 239.95,31 239.96,31 239.96,30.92 240.03,30.92 240.04,30.91 240.38,30.91 240.4,30.92 240.46,30.92 240.46,30.99 240.47,31 240.47,31.47 241.12,31.47 242.12,30.47 242.12,30.03 242.25,29.9 242.71,29.9 242.8,29.81 242.8,28.94 242.57,28.7 240.34,28.7 240.23,28.81 240.16,28.81 240.15,28.81 239.98,28.85 239.82,28.81 239.8,28.81 239.58,28.81 239.57,28.81 239.4,28.86 239.23,28.81 239.21,28.81 239.2,28.81 238.93,28.54 238.93,28.33 238.82,28.22 237.36,28.22 237.24,28.34 237.24,29.57 237.02,29.79 237.02,30.29 237.19,30.46 238.04,30.46 238.05,30.48 238.05,31.16 238.36,31.46 239.14,31.46 239.14,31 239.16,30.99 239.16,30.92 239.22,30.92 239.23,30.92 239.44,30.92 239.67,30.92 239.67,31.47 239.95,31.47
+19VB_3V on BOTTOM (solid shape): 247.87,34.72 247.87,33.71 248.02,33.57 248.02,31.4 248.28,31.14 248.28,31.11 248.34,31.06 248.34,29.6 248.26,29.52 247.36,29.52 247.04,29.21 247.04,28.73 246.87,28.55 246.29,28.55 246.22,28.63 246.22,29.41 246.07,29.56 245.31,29.56 245.06,29.81 245.06,30.25 245.06,30.56 245.09,30.59 245.62,30.59 245.66,30.63 245.66,31.89 245.62,31.93 245.14,31.93 245.08,31.98 245.08,32.92 247.02,34.85 247.74,34.85
+19VB_5V on TOP (solid shape): 82.24,7.16 82.24,6.62 82.25,6.61 82.8,6.61 82.81,6.62 82.81,7.15 82.83,7.17 83.11,7.17 83.13,7.14 83.13,4.96 82.89,4.72 74.79,4.72 74.58,4.92 74.58,5.3 75.22,5.94 79.45,5.94 80.46,6.95 80.85,6.95 81.06,7.16 81.41,7.16 81.44,7.14 81.44,6.63 81.46,6.6 81.99,6.6 82.01,6.62 82.01,7.15 82.03,7.17 82.23,7.17
+19VB_5V on BOTTOM (solid shape): 77.12,6.45 78.43,6.45 78.78,6.1 79.96,6.1 80.02,6.04 81.67,6.04 81.82,5.89 81.82,4.92 81.57,4.67 74.84,4.67 74.58,4.92 74.58,6.83 74.71,6.95 76.62,6.95
+19VB_CHG on TOP (solid shape): 251.58,14.09 251.58,13.56 251.59,13.55 252.33,13.55 252.35,13.57 252.35,14.07 252.38,14.1 253.03,14.1 253.09,14.03 253.09,12.33 252.91,12.15 252.91,10.64 253.07,10.49 253.47,10.49 253.52,10.44 253.52,10.06 253.5,10.03 250.85,10.03 250.64,9.83 250.64,9.75 246.46,9.75 246.18,10.03 246.18,11.78 246.84,12.44 248.92,12.44 249.18,12.7 249.18,13.26 249.46,13.54 249.86,13.54 249.86,14.07 249.89,14.09 250.38,14.09 250.39,14.09 250.39,13.57 250.4,13.56 251.14,13.56 251.14,13.57 251.14,14.09 251.16,14.1 251.58,14.1
+19VB_CPU on TOP (solid shape): 106.15,80.11 106.15,75.54 103.03,75.54 102.85,75.72 102.85,80.13 103.05,80.34 105.92,80.34
+19VB_CPU on TOP (solid shape): 115.78,92.1 115.78,91.72 115.52,91.46 109.68,91.46 109.56,91.59 109.56,92.48 109.68,92.61 115.27,92.61
+19VB_CPU on TOP (solid shape): outline of 842 points within 123.78,125.25 158.45,132.99
+19VB_CPU on BOTTOM (solid shape): outline of 93 points within 122.26,124.1 158.2,133.12
+19VB_CPU on BOTTOM (solid shape): outline of 227 points within 103.23,75.84 115.78,93.75
+19VB_CPU on VCC: 103.44,75.97 102.8,76.6 101.99,76.6 102.55,79.15 102.94,81.73 106,81.73 109.17,84.9 106,88.07 103.18,88.07 103.05,90 102.82,91.92 102.57,93.72 103.4,93.72 105.04,94.47 105.55,96.19 103.93,107.72 103.93,107.72 107.28,107.72 114.59,110.49 118.72,117.12 118.72,131 120.52,132.07 121.57,133.88 127.1,133.88 128.25,132.74 131.25,132.74 132.27,133.75 134.72,133.75 135.74,132.74 138.74,132.74 139.76,133.75 142.34,133.75 143.36,132.74 146.49,132.74 147.51,133.75 150.09,133.75 151.11,132.74 152.33,132.74 153.35,133.75 157.33,133.75 159.87,131.21 161.65,131.21 162.26,130.6 162.26,127.38 162.03,127.15 157.54,127.15 157.18,127.51 157.18,129.29 156.78,129.69 156.52,129.69 155.89,130.33 127.74,130.33 126.83,129.41 126.83,127.55 128.1,126.28 128.1,124.63 131.15,121.58 131.15,119.89 130.64,119.38 130.64,117.73 130,117.1 130,115.7 125.94,111.63 125.94,110.49 125.71,110.26 118.72,110.26 112.73,104.27 112.73,95.04 117.56,90.21 117.56,86.36 117.2,86 114.4,86 110.95,82.55 110.95,76.55 110.37,75.97
+19VB_CPU on IN2: outline of 155 points within 102.32,74.95 127.46,134.07
+19VB_DDR on TOP (solid shape): 91.49,41.38 91.49,40.84 91.5,40.83 92.05,40.83 92.07,40.85 92.07,41.38 92.08,41.39 92.39,41.39 92.54,41.24 92.54,40.66 94.06,39.14 94.06,37.62 94.57,37.11 94.57,34.44 93.76,33.63 92.92,33.63 92.84,33.55 92.84,32.99 92.77,32.92 92.38,32.92 92.31,32.99 92.31,35.38 92.33,35.41 92.49,35.41 92.79,35.71 92.79,36.98 92.28,37.49 91.52,37.49 91.39,37.62 91.39,39.39 90.89,39.9 90.52,39.9 90.32,40.1 90.32,41.35 90.37,41.4 90.68,41.4 90.69,41.39 90.69,40.86 90.71,40.84 91.24,40.84 91.25,40.85 91.25,41.37 91.28,41.4 91.47,41.4
+19VB_GPU_NVVDD on TOP (solid shape): outline of 81 points within 194.73,44.71 229.61,56.47
+19VB_GPU_NVVDD on BOTTOM (solid shape): outline of 210 points within 194.69,45.67 232.29,56.39
+19VB_INVPWR on TOP (solid shape): 82.51,43.69 82.51,43.31 82.53,43.29 83.06,43.29 83.08,43.27 83.08,43.14 83.07,43.12 82.58,43.12 82.54,43.09 82.54,37.79 82.34,37.59 80.25,37.59 80.06,37.78 80.06,40.75 80.51,41.2 80.51,42.57 80.78,42.84 80.78,43.5 80.97,43.7 82.5,43.7
+19VB_VCCIOP on BOTTOM (solid shape): 187.9,103.36 187.9,100.32 187.81,100.23 187.81,97.53 187.62,97.35 186.84,97.35 186.84,97.9 186.33,97.9 186.33,97.35 186.04,97.35 186.04,97.9 185.53,97.9 185.53,97.35 185.12,97.35 185.12,98.75 185.83,99.46 185.83,101.95 185.73,102.05 185.73,103.5 185.78,103.55 187.71,103.55
+VCC_CORE on TOP (solid shape): outline of 1580 points within 125.68,90.37 160.84,119.91
+VCC_CORE on BOTTOM (solid shape): outline of 542 points within 142.96,90.07 162.9,91.97
+VCC_CORE on BOTTOM (solid shape): outline of 1660 points within 125.94,102.32 159.97,119.15
+VCC_CORE on IN1: 129.49,120.67 154.89,120.67 156.04,119.53 156.04,115.21 159.72,111.53 159.72,93.62 161.63,91.72 161.63,91.21 160.74,90.32 150.96,90.32 150.7,90.57 149.05,90.57 148.93,90.45 142.7,90.45 141.05,92.1 141.05,92.61 141.94,93.5 141.94,101.88 143.34,103.27 143.34,109.37 142.32,110.39 127.46,110.39 126.7,111.15 126.7,116.23 127.21,116.74 127.21,118.39
+VCC_CORE on VCC: 142.93,90.57 142.7,90.81 142.7,91.57 140.8,93.47 140.8,99.61 140.9,99.72 142.43,99.72 143.46,100.76 143.46,103.25 142.83,103.89 142.83,109.86 142.43,110.26 126.68,110.26 126.45,110.49 126.45,111.42 130.51,115.49 130.51,116.88 131.15,117.52 131.15,119.17 131.5,119.53 132.77,119.53 133.16,119.91 156.19,119.91 156.93,119.17 156.93,111.68 159.59,109.01 159.59,105.03 158.45,103.89 158.45,94.53 158.98,94 161.14,94 161.37,93.77 161.37,92.5 162.51,91.36 162.51,90.57
+VCC_CORE on IN2: 130.51,119.15 146.51,119.15 146.89,118.77 155.4,118.77 156.42,117.75 156.42,112.8 159.85,109.37 159.85,93.11 162.39,90.57 162.39,90.32 162.26,90.19 143.34,90.19 141.18,92.35 141.18,92.61 142.45,93.88 142.45,101.88 143.34,102.77 143.34,110.26 142.58,111.02 127.08,111.02 126.7,111.4 126.7,115.34 ; 1 cut-out
+VCC_GT on TOP (solid shape): outline of 4326 points within 112.86,89.69 142.83,110.64
+VCC_GT on BOTTOM (solid shape): outline of 2423 points within 112.73,90.07 142.32,109.75
+VCC_GT on VCC: 117.92,90.57 113.24,95.25 113.24,104.06 118.93,109.75 142.22,109.75 142.32,109.65 142.32,103.68 142.96,103.04 142.96,100.97 142.22,100.23 140.69,100.23 140.29,99.82 140.29,93.26 142.19,91.36 142.19,90.81 141.96,90.57
+VCC_GT on IN2: outline of 95 points within 126.34,90.4 142.26,110
+VCC_SA on TOP (solid shape): outline of 426 points within 156.8,93.25 163.15,118.26
+VCC_SA on BOTTOM (solid shape): outline of 568 points within 157.43,102.52 163.28,118.51
+VCC_SA on VCC: 159.19,94.51 158.96,94.74 158.96,103.68 160.1,104.82 160.1,109.22 157.43,111.89 157.43,118.79 157.67,119.02 162.66,119.02 162.77,118.92 162.77,103.38 161.37,101.98 161.37,94.74 161.14,94.51
+VCC_SA on IN2: 160.74,93.62 160.36,94 160.36,105.9 160.54,106.16 160.44,106.47 160.41,106.54 160.44,106.62 160.54,106.92 160.36,107.18 160.36,109.5 159.68,110.17 159.65,110.25 159.7,110.33 159.73,110.35 159.75,110.37 159.83,110.4 159.9,110.37 160.15,110.26 160.41,110.36 160.48,110.39 160.55,110.37 161.15,110.63 160.54,110.87 160.47,110.84 160.4,110.87 160.16,110.97 159.91,110.87 159.84,110.84 159.77,110.88 159.47,110.98 159.21,110.82 159.13,110.77 159.05,110.8 157.05,112.8 157.05,114.76 157.1,114.77 157.41,115.12 157.1,115.47 157.05,115.48 157.05,115.97 157.56,116.48 165.05,116.48 165.56,115.97 165.56,110.44 165.53,110.36 165.44,110.34 165.02,109.99 165.44,109.64 165.53,109.61 165.56,109.54 165.56,104.67 165.03,104.13 165,104.14 164.85,104.12 164.72,104.04 163.89,104.04 163.68,104.11 163.47,104.04 163.28,104.04 163.02,103.78 163.02,103.33 162.98,103.32 162.69,102.97 162.98,102.62 163.02,102.61 163.02,97.1 163.01,97.07 162.97,97.05 162.63,96.79 162.79,96.39 162.84,96.3 162.62,95.91 162.84,95.51 162.79,95.43 162.62,95.16 162.72,94.87 162.75,94.79 162.72,94.72 161.63,93.62
GND on TOP (solid shape): 254.5,90.77 254.48,90.53 254.45,90.3 251.2,90.3 251.2,93.29 254.79,93.29
GND on TOP (solid shape): 134.02,100.05 134.02,98.78 133.56,98.32 132.19,98.32 131.92,98.59 131.92,100.16 132.16,100.4 133.66,100.4
GND on TOP (solid shape): 78.99,31.62 78.99,29.58 78.88,29.47 78.09,29.47 77.93,29.62 77.93,31.67 78,31.74 78.87,31.74
GND on TOP (solid shape): 137.34,93.11 137.34,91.69 137.27,91.62 135.08,91.62 134.9,91.79 134.9,93.06 135.16,93.32 137.14,93.32
GND on TOP (solid shape): 209.4,91.23 209.3,91.13 208.95,91.13 207.83,92.26 207.83,92.78 207.98,92.93 209.4,92.93
GND on TOP (solid shape): 263.17,42.72 263.17,41.27 263.16,41.26 262.43,41.26 262.42,41.25 261.81,41.25 261.62,41.43 261.62,41.9 262.47,42.75 263.15,42.75
GND on TOP (solid shape): 274.21,12.97 274.21,11.46 274.07,11.31 269.59,11.31 269.46,11.44 269.46,13.55 269.61,13.7 273.48,13.7
GND on TOP (solid shape): 30.96,45.42 30.96,44.85 31.12,44.69 31.12,44.07 30.98,43.92 29.47,43.92 29.27,44.13 29.27,44.39 29.81,44.93 29.81,45.45 29.86,45.51 30.87,45.51
GND on TOP (solid shape): 65.79,36.28 65.79,34.95 65.92,34.82 67.27,34.82 67.54,34.55 67.54,32.35 67.47,32.28 65.34,32.28 65.23,32.39 65.23,36.3 65.37,36.43 65.64,36.43
GND on TOP (solid shape): 80.63,43.68 80.63,42.87 80.39,42.63 80.39,41.68 80.1,41.4 79.49,41.4 78.99,41.89 78.99,42.98 78.06,43.92 78.06,44.36 78.4,44.71 79.6,44.71
GND on TOP (solid shape): 88.72,33.72 88.72,31.41 88.62,31.3 87.51,31.3 87.21,31.61 87.21,32.65 87.44,32.88 87.76,32.88 88.07,33.19 88.07,33.65 88.22,33.8 88.65,33.8
GND on TOP (solid shape): 132.2,57.7 132.2,54.86 131.81,54.47 126.44,54.47 126.26,54.65 126.26,57.76 126.37,57.88 132.02,57.88
GND on TOP (solid shape): 133.44,95.2 133.44,94.11 133.05,93.73 131.4,93.73 131.26,93.87 131.26,94.25 131.52,94.5 131.78,94.5 131.97,94.7 131.97,95.34 132.08,95.44 133.2,95.44
GND on TOP (solid shape): 161.83,98.73 161.83,96.89 161.54,96.59 161.18,96.59 161.02,96.76 161.02,96.95 160.84,97.13 160.69,97.13 160.58,97.23 160.58,98.85 160.63,98.91 161.65,98.91
GND on TOP (solid shape): 173.05,32.71 173.05,32.41 171.69,31.05 171.69,30.19 171.65,30.15 171.18,30.15 171.14,30.2 171.14,31.76 171.25,31.87 171.25,32.43 171.71,32.9 172.86,32.9
GND on TOP (solid shape): 199.87,121.56 199.87,120.99 199.75,120.88 199.06,120.88 198.79,120.61 198.08,120.61 197.94,120.75 197.94,121.5 198.07,121.64 199.79,121.64
GND on TOP (solid shape): 248.79,81.32 248.79,81.23 249.25,80.77 249.25,79.99 249.11,79.85 248.15,79.85 248.03,79.97 248.03,80.79 248.25,81 248.25,81.36 248.38,81.5 248.61,81.5
GND on TOP (solid shape): 23.96,75.7 23.96,74.19 23.79,74.02 20.32,74.02 20.1,74.24 20.1,75.67 20.19,75.76 23.9,75.76
GND on TOP (solid shape): 42.25,42.83 42.25,42.37 42.06,42.18 38.77,42.18 38.55,42.4 38.55,43.21 38.6,43.26 41.81,43.26
GND on TOP (solid shape): 98.95,42.24 98.95,40.71 98.8,40.56 98.06,40.56 97.89,40.73 96.84,40.73 96.71,40.86 96.71,43.36 96.82,43.47 97.72,43.47
GND on TOP (solid shape): 161.5,129.18 161.5,124.23 161.37,124.1 161.18,124.1 159.91,125.37 158.83,125.37 158.7,125.5 158.7,128.04 159.72,129.06 160.74,129.06 160.99,129.31 161.37,129.31
GND on TOP (solid shape): 178.13,28.04 178.5,28.04 178.51,28.05 178.77,28.05 178.84,27.98 178.84,27.46 178.56,27.18 176.59,27.18 176.34,27.42 176.34,27.68 176.94,28.27 177.9,28.27
GND on TOP (solid shape): 262.6,46.93 262.6,46.19 262.54,46.12 261.11,44.69 258.15,44.69 258.09,44.75 258.09,46.56 258.59,47.05 262.48,47.05
GND on TOP (solid shape): 43.92,46.71 43.92,46 43.94,45.98 43.94,44.85 43.85,44.76 42.53,44.76 42.37,44.93 42.37,45.44 42.45,45.52 42.45,46.59 42.63,46.77 43.85,46.77
GND on TOP (solid shape): 109.05,95.4 109.3,95.4 109.43,95.27 109.43,95.02 109.94,94.51 114.13,94.51 114.25,94.38 114.25,93.11 114.13,92.99 108.03,92.99 107.9,93.11 107.9,95.53 108.03,95.65 108.79,95.65
GND on TOP (solid shape): 204.34,92.73 204.34,92.38 203.91,91.95 203.81,91.88 203.74,91.78 203.17,91.21 203,91.21 202.76,91.46 202.76,92.76 202.78,92.78 204.28,92.78
GND on TOP (solid shape): 19.39,116.41 19.39,115.49 19.22,115.33 18.19,115.33 18.04,115.47 18.04,116.22 18.04,116.23 18.06,116.35 18.05,116.47 18.04,116.5 18.14,116.6 19.2,116.6
GND on TOP (solid shape): 21.14,56.49 21.57,56.49 21.62,56.44 21.62,55.9 21.52,55.8 21.52,55.09 21.59,55.01 21.85,55.01 22.28,54.58 22.28,54.18 22.2,54.1 21.26,54.1 20.35,55.01 20.35,56.64 20.38,56.67 20.96,56.67
GND on TOP (solid shape): 62.39,11.4 62.39,6.57 62.65,6.32 63.54,6.32 63.66,6.19 63.66,5.43 63.41,5.18 59.85,5.18 59.6,5.43 59.6,8.1 60.48,8.98 60.48,10.12 61.88,11.53 62.27,11.53
GND on TOP (solid shape): 171.28,131.92 171.28,126.39 171.15,126.26 166.83,126.26 165.82,127.28 165.82,127.53 165.69,127.66 165.69,128.48 165.44,128.74 165.44,129.37 165.69,129.63 165.69,131.6 166.07,131.98 171.22,131.98
GND on TOP (solid shape): 207.79,82.33 208.53,82.33 208.6,82.33 208.73,82.2 208.73,81.59 208.63,81.49 207.32,81.49 207.31,81.49 206.93,81.49 206.75,81.67 206.75,82.41 206.83,82.49 207.63,82.49
GND on TOP (solid shape): 212.01,125.6 212.01,125.08 212.27,124.81 213.34,124.81 213.42,124.73 213.42,124.46 213.32,124.36 212.35,124.36 212.1,124.1 211.67,124.1 211.34,124.43 211.34,125.26 211.35,125.26 211.35,125.64 211.4,125.69 211.91,125.69
GND on TOP (solid shape): 197.21,96.11 197.21,95.4 197.31,95.3 197.31,95.15 197.52,94.94 197.52,93.83 197.29,93.6 197.29,92.68 197.06,92.45 196.68,92.45 195.94,93.19 195.94,95.76 196.25,96.06 196.68,96.06 196.88,96.26 197.06,96.26
GND on TOP (solid shape): 213.11,80.43 213.11,79.84 212.98,79.71 212.98,78.36 212.91,78.29 212.72,78.29 212.33,78.68 212.33,79.16 212.16,79.32 211.61,79.32 211.57,79.36 211.57,79.82 211.62,79.87 211.62,80.43 211.72,80.52 213.02,80.52
GND on TOP (solid shape): 120.22,89.94 120.22,86.13 119.32,85.22 114.31,85.22 114.2,85.33 114.2,85.81 114.67,86.29 114.67,86.85 114.75,86.93 117.09,86.93 118.95,88.8 118.95,89.18 119.21,89.43 119.21,90.07 119.33,90.19 119.97,90.19
GND on TOP (solid shape): 213.3,90.89 213.3,89.77 213.18,89.65 213.18,89 213.08,88.91 212.62,88.91 212.43,89.09 212.37,89.09 212.21,89.25 212.21,90.16 212.33,90.28 212.63,90.28 212.8,90.45 212.8,90.88 212.87,90.95 213.24,90.95
GND on TOP (solid shape): 248.2,98.19 248.2,97.56 248.08,97.44 248.08,95.56 247.99,95.48 246.94,95.48 246.85,95.57 246.85,95.83 246.93,95.9 247.43,95.9 247.53,96 247.53,96.64 247.37,96.8 247.37,97.27 247.61,97.51 247.61,98.26 247.62,98.27 248.13,98.27
GND on TOP (solid shape): 23.88,83.55 23.88,83.24 23.78,83.14 23.41,83.14 23.2,83.36 21.32,83.36 21.28,83.32 20.45,83.32 20.4,83.37 20.4,83.73 21.38,84.72 22.67,84.72 22.69,84.73 22.94,84.73 23.3,85.09 23.66,85.09
GND on TOP (solid shape): 214.08,95.28 214.23,95.28 214.51,95.55 214.74,95.55 214.9,95.39 214.9,95.11 214.81,95.02 212.76,95.02 212.72,95.06 212.72,95.4 212.77,95.46 213.58,95.46 213.71,95.59 213.77,95.59
GND on TOP (solid shape): 24.74,56.78 24.74,56.41 24.82,56.33 25.79,56.33 25.88,56.24 25.88,55.99 25.79,55.9 24.87,55.9 24.74,55.78 24.74,55.2 23.99,54.45 23.09,54.45 22.98,54.56 22.98,54.79 23.31,55.12 23.79,55.12 24.06,55.39 24.06,56.77 24.09,56.8 24.72,56.8
GND on TOP (solid shape): 91.01,39.39 91.01,38.38 91.14,38.25 91.14,37.62 91.01,37.49 90.89,37.49 90.63,37.23 90.63,35.46 90.73,35.35 90.73,33.78 90.63,33.68 90,33.68 89.74,33.93 89.24,33.93 88.73,34.44 88.73,35.96 89.36,36.6 89.36,39.27 89.74,39.65 90.76,39.65
GND on TOP (solid shape): 226.47,57.12 227.87,57.12 227.94,57.2 228.25,57.2 228.3,57.15 228.3,54.89 228.17,54.76 226.06,54.76 225.96,54.86 225.96,55.8 225.86,55.9 225.43,55.9 225.38,55.95 225.38,56.49 225.4,56.51 225.61,56.51 225.86,56.77 225.86,57.07 226.04,57.25 226.34,57.25
GND on TOP (solid shape): 172.4,3.6 165.9,3.6 165.34,3.84 165.1,4.4 165.1,5.1 172.4,5.1
GND on TOP (solid shape): 312.6,47.7 313.16,47.46 313.4,46.9 313.4,43.9 308.6,43.9 308.6,47.7
GND on TOP (solid shape): 250.57,9.25 250.57,8.86 251,8.43 252.8,8.43 252.92,8.3 252.92,7.62 252.8,7.5 252.8,5.99 252.63,5.82 251.85,5.82 251.85,5.82 251.75,5.82 251.65,5.93 251.65,6.74 250.88,7.5 248.07,7.5 248.05,7.52 246.64,7.52 246.48,7.68 246.48,9.59 246.51,9.62 250.19,9.62
GND on TOP (solid shape): 255.32,105.7 255.91,105.43 256.11,104.81 255.84,102.51 250.92,102.51 251.29,105.7
GND on TOP (solid shape): 207.21,87.69 207.21,87.38 206.93,87.1 206.93,86.72 206.73,86.52 206.73,86.11 206.8,86.04 206.8,83.7 206.15,83.05 205.94,83.05 205.82,83.17 205.82,83.35 206.13,83.66 206.13,84.25 205.68,84.7 205.68,86.28 206.17,86.77 206.17,87.03 206.47,87.33 206.47,87.36 206.86,87.74 207.16,87.74
GND on TOP (solid shape): 285.27,23.54 285.27,23.54 287.42,21.39 288.6,21.39 288.65,21.33 288.65,20.85 288.61,20.85 288.18,20.42 288.18,17.88 288.03,17.73 287.63,17.73 287.56,17.8 287.56,18.04 287.45,18.15 285.88,18.15 285.81,18.22 285.81,18.33 283.75,20.39 283.75,23.54 284.04,23.83 284.98,23.83
GND on TOP (solid shape): 135.43,104.25 135.43,104.18 135.44,104.13 135.44,104.01 135.44,102.83 134.82,102.21 134.35,102.21 133.99,102.56 133.99,103.83 134.03,103.87 134.12,103.87 134.21,103.86 134.29,103.87 134.51,103.87 134.7,104.06 134.7,104.37 134.88,104.54 135.13,104.54
GND on TOP (solid shape): 137.36,104.54 137.57,104.54 137.72,104.39 137.72,104.16 137.82,104.06 137.84,104.03 137.86,104 137.86,102.7 138.6,101.96 138.6,101.13 138.57,101.1 136.91,101.1 136.81,101.2 136.81,102.24 136.81,102.28 136.81,102.74 136.76,102.79 136.76,103.83 137.06,104.14 137.06,104.37 137.24,104.54
GND on TOP (solid shape): 194.84,98.73 194.84,98.7 194.87,98.43 195.09,98.27 195.11,98.27 195.14,98.23 195.14,97.59 195.06,97.51 194.37,97.51 194.31,97.56 194.31,97.76 194.2,97.87 193.52,97.87 193.35,98.03 193.35,98.75 193.58,98.98 194.59,98.98
GND on TOP (solid shape): 234.28,8.16 234.28,7.58 233.94,7.23 233.94,5.45 233.75,5.26 232.9,5.26 232.8,5.36 232.79,5.43 232.77,5.49 232.77,6.03 232.77,6.04 233.18,7.08 233.25,8.2 233.25,8.22 233.32,8.29 234.16,8.29
GND on TOP (solid shape): 267.48,46.03 267.48,45.63 267.45,45.61 267.27,45.61 267.11,45.46 267.11,42.26 267.06,42.2 267.06,42 267.11,41.95 267.11,40.33 267.25,40.2 267.25,39.61 267.23,39.6 266.38,39.6 265.85,40.13 265.85,40.86 266.11,41.13 266.11,42.71 266.05,42.77 265.3,42.77 265.24,42.84 265.24,42.92 265.32,43 266.05,43 266.12,43.06 266.12,44.34 265.64,44.82 265.64,45.9 265.79,46.06 267.45,46.06
GND on TOP (solid shape): 254.41,40.8 254.41,40.09 254.49,40.01 255.81,40.01 255.95,40.15 255.95,40.4 256.25,40.7 257.39,40.7 257.97,40.12 257.97,39.33 257.66,39.03 256.1,39.03 256.1,39.03 255.42,39.03 255.42,39.03 255.24,39.03 255.24,39.03 255.03,39.03 255.03,39.03 252.71,39.03 252.43,38.75 251.64,38.75 251.58,38.81 251.58,40.49 251.65,40.56 252.41,40.56 253,39.97 254.18,39.97 254.21,40 254.21,40.79 254.26,40.85 254.36,40.85
GND on TOP (solid shape): 42.33,38.32 42.33,37.76 42.03,37.47 41.48,37.51 41.53,36.97 41.44,36.88 39.67,36.88 39.49,37.06 39.49,38.32 39.54,38.37 42.28,38.37
GND on TOP (solid shape): 175.79,108.21 175.79,107.51 176.22,107.08 176.22,106.73 176.1,106.62 175.46,106.62 175.08,106.24 172.87,106.24 172.81,106.18 172.59,106.18 172.46,106.31 172.46,106.71 172.7,106.96 172.74,106.94 173.13,106.96 173.3,107.32 173.3,107.34 174.25,108.3 175.7,108.3
GND on TOP (solid shape): 72.66,33.2 72.66,32.36 72.45,32.14 72.05,32.14 71.96,32.06 71.95,32.05 71.75,31.75 71.92,31.43 71.92,30.79 71.83,30.7 71.35,30.7 71.18,30.87 71.18,31.18 71.02,31.34 70.57,31.34 70.5,31.4 70.5,31.58 70.5,31.59 70.5,32.95 70.92,33.37 72.49,33.37
GND on TOP (solid shape): 47.48,49.49 47.48,49.16 47.52,49.12 47.52,48.98 47.65,48.98 47.82,48.81 48.15,48.81 48.3,48.65 48.3,48.04 48.57,48.04 48.83,47.78 48.83,46.25 48.85,46.22 49.6,46.22 49.7,46.12 49.7,40.79 49.62,40.7 46.57,40.7 46.44,40.57 46.44,39.52 46.39,39.48 46.3,39.48 46.23,39.54 46.23,46.06 46.4,46.22 47.54,46.22 47.85,46.53 47.85,46.54 47.85,47.44 47.77,47.52 47.77,47.56 47.24,48.09 47.24,48.52 46.55,49.21 46.55,49.55 46.79,49.79 47.17,49.79
GND on TOP (solid shape): 199.28,84.48 199.28,83.61 199.32,83.56 199.32,83.53 199.51,83.35 199.94,83.35 200.02,83.26 200.02,82.73 199.93,82.64 199.37,82.64 199.37,81.4 199.32,81.36 198.89,81.36 198.71,81.53 198.35,81.53 198.25,81.63 198.25,81.96 198.36,82.06 198.66,82.06 198.72,82.13 198.76,82.13 198.76,82.76 198.71,82.76 198.65,82.83 198.12,82.83 198.06,82.76 196.88,82.76 196.88,82.75 196.04,82.75 195.99,82.79 195.99,83.79 196.11,83.91 197.85,83.91 198.06,84.13 198.55,84.13 198.66,84.23 198.66,84.56 198.69,84.59 199.17,84.59
GND on TOP (solid shape): 28.35,63.24 28.35,62.06 28.33,62.04 28.33,59.42 27.97,59.06 27.79,59.06 27.63,59.22 27.59,59.27 27.57,59.27 27.53,59.31 26.89,59.31 26.85,59.27 26.8,59.27 26.6,59.06 26.42,59.06 26.18,59.3 25.53,59.3 25.43,59.2 25.42,59.19 25.28,59.05 25.07,59.05 24.88,59.25 24.81,59.25 24.81,59.25 24.13,59.25 23.78,58.9 22.94,58.9 22.89,58.95 22.89,59.43 22.94,59.48 23.2,59.48 23.32,59.61 23.32,60.8 23.33,60.81 23.33,63.22 23.65,63.54 28.05,63.54
GND on TOP (solid shape): 13.94,8.01 14.81,7.14 14.81,0.42 14.6,0.2 1,0.2 0.44,0.44 0.2,1 0.2,12.27 0.44,12.83 1,13.07 13.94,13.07
GND on TOP (solid shape): 112.7,14.91 112.7,14.27 112.56,14.13 112.3,14.13 111.78,14.11 111.85,13.59 111.89,13.51 111.86,13.43 111.71,13.28 108.4,13.28 108.31,13.37 108.31,13.92 108.34,13.95 109.87,13.95 110.06,14.14 110.06,14.48 110.53,14.95 112.66,14.95
GND on TOP (solid shape): 83.08,36.03 83.08,35.84 83.25,35.67 84.03,35.67 84.11,35.59 84.11,35.34 84.01,35.25 83.14,35.25 83.08,35.19 83.08,34.62 83.35,34.34 83.95,34.34 84.13,34.16 84.13,33.62 84.02,33.51 83.63,33.51 83.31,33.2 82.85,33.2 82.49,33.2 81.77,32.48 81.35,32.48 81.28,32.55 81.28,33.97 81.56,34.25 81.9,34.25 82.2,34.55 82.2,35.12 82.09,35.24 81.2,35.24 80.44,34.48 80.41,34.48 80.32,34.39 79.26,34.39 78.82,33.96 77.92,33.96 77.85,34.03 77.85,35.64 77.91,35.7 82.12,35.7 82.24,35.82 82.24,36.02 82.32,36.1 83,36.1
GND on TOP (solid shape): 275.26,39.25 275.25,39.23 275.43,38.86 275.84,38.91 275.9,38.93 275.97,38.91 276.36,38.88 276.54,39.23 276.54,39.26 276.59,39.31 276.72,39.18 276.72,36.76 276.5,36.54 274.29,36.54 274.15,36.68 274.15,39.18 274.36,39.4 275.12,39.4
GND on TOP (solid shape): 211.64,93.4 211.64,93.36 211.78,93.06 212.11,93.01 212.15,93.01 212.24,92.92 212.66,92.92 212.66,92.62 212.65,92.61 212.65,92.51 212.81,92.35 212.86,92.35 212.9,92.31 213.84,92.31 213.89,92.26 213.89,91.63 213.81,91.55 212.83,91.55 212.83,91.55 212.6,91.78 211.99,91.78 211.53,91.32 211,91.32 210.89,91.42 210.89,91.65 211.31,92.07 211.32,92.07 211.46,92.16 211.55,92.3 211.55,92.31 211.57,92.33 211.57,92.63 211.42,92.78 211.12,92.78 210.76,93.14 210.76,93.54 210.98,93.75 211.29,93.75
GND on TOP (solid shape): 148.67,104.28 148.67,104.24 148.69,104.22 148.69,104.14 148.95,103.89 148.95,102.96 148.73,102.75 148.73,102.73 148.73,102.39 148.31,101.96 148.31,93.12 148.7,92.73 148.7,91.56 148.09,90.96 146.7,90.96 146.63,90.99 146.56,91 146.54,91.01 146.29,91.26 146.29,96.44 146.3,96.45 146.3,102.27 145.73,102.84 145.64,102.84 145.61,102.87 145.47,102.87 145.43,102.91 145.43,103.92 145.45,103.94 145.49,103.97 145.61,104.09 145.61,104.22 145.83,104.44 146.13,104.44 146.41,104.16 146.41,104.08 146.54,103.95 146.54,102.88 146.58,102.84 146.58,102.82 146.6,102.82 146.64,102.77 147.79,102.77 147.85,102.83 147.85,102.95 147.85,104.04 148.1,104.29 148.1,104.28 148.3,104.48 148.47,104.48
GND on TOP (solid shape): 214.91,87.25 214.91,86.86 216.01,85.76 216.01,85.63 215.81,85.42 215.63,85.42 215.36,85.69 215.17,85.69 215.04,85.56 215.04,85.46 215.03,85.45 214.97,85.26 215.04,85.07 215.04,84.64 214.97,84.45 215.03,84.26 215.04,84.24 215.04,84.22 215.97,83.29 215.97,83.16 215.83,83.02 215.51,83.02 215.4,83.13 215.4,83.16 215.39,83.25 215.34,83.33 215.29,83.38 215.25,83.39 215.14,83.45 215.08,83.56 215.07,83.6 214.91,83.76 214.77,83.76 214.56,83.97 214.56,85.35 214.54,85.38 214.54,85.7 214.48,85.76 214.48,85.82 214.47,85.83 214.47,85.85 214.45,85.85 214.24,86.06 214.24,86.3 214.37,86.43 214.37,87.27 214.42,87.32 214.84,87.32
GND on TOP (solid shape): 273.22,50.14 273.66,49.77 275.54,48.92 277.46,48.16 277.99,48.09 278.49,48.26 277.55,46.23 276.57,46.57 276.44,46.62 275.79,46.87 275.7,46.91 275.53,46.98 275.28,47.08 274.98,47.2 274.38,47.46 273.71,47.76 273.48,47.87 272.87,48.16 272.5,48.34 272.38,48.4 273,50.67
GND on TOP (solid shape): outline of 86 points within 73.42,6.35 81.13,9.96
GND on TOP (solid shape): 142.08,105.14 142.25,104.75 142.18,104.6 142.24,104.44 142.29,104.39 142.32,104.36 142.35,104.35 142.35,104.32 142.83,104.32 143.03,104.52 143.77,104.52 143.94,104.35 143.94,103.98 144.09,103.83 144.09,102.94 143.77,102.62 143.77,98.56 143.42,98.21 143.42,91.54 142.91,91.04 142.16,91.04 141.5,91.69 140.16,91.69 140.12,91.69 139.49,91.69 139.27,91.91 139.27,92.81 140.14,93.67 140.14,99.95 141.23,101.04 141.23,103.76 141.26,103.83 141.32,103.86 141.38,103.87 141.7,103.87 141.87,104.04 141.87,104.18 141.86,104.21 141.85,104.33 141.91,104.44 141.98,104.6 141.92,104.76
GND on TOP (solid shape): 14.94,83.08 14.94,82.07 14.56,81.68 14.44,81.68 14.27,81.52 14.25,81.52 13.84,81.19 14.2,80.81 14.27,80.78 14.31,80.71 14.31,80.64 3.41,80.64 3.38,80.65 3.35,80.66 2.96,80.66 2.92,80.71 2.73,80.71 2.73,81 2.97,81.56 3.53,81.8 10.3,81.8 11.22,81.8 12,81.3 12.6,82 12.6,83.51 14.51,83.51
GND on TOP (solid shape): outline of 85 points within 150.31,91.04 159.31,104.52
GND on TOP (solid shape): 14.12,128.7 14.54,128.57 14.84,128.24 16.3,125.17 16.3,125.07 16.21,125.03 16.18,124.99 7.83,124.99 7.29,124.45 7.29,121.98 7.29,121.97 7.29,121.29 7.9,120.68 10.36,120.68 11.18,119.86 11.19,119.86 11.36,119.68 13.14,119.68 13.54,119.28 13.54,118.51 13.16,118.13 11.82,118.13 11.82,118.13 10.8,117.11 9.95,117.11 9.95,118.23 10.45,119 9.75,119.6 1,119.6 0.44,119.84 0.2,120.4 0.2,127.9 0.44,128.46 1,128.7
GND on TOP (solid shape): outline of 116 points within 0.65,55.06 8.69,59.45
GND on TOP (solid shape): 15.7,105.56 15.7,95.27 14.69,94.26 12.6,94.26 12.6,95.01 12.6,95.01 12.6,95.65 12.52,95.98 12.29,96.24 11.68,96.32 11.24,95.9 1.75,95.9 1.19,96.14 0.95,96.7 0.95,100.95 1.19,101.51 1.75,101.75 2,101.75 2.5,101.95 2.7,102.45 2.7,102.9 2.94,103.46 3.5,103.7 9.75,103.7 10.32,103.99 10.42,104.62 10.44,104.62 10.26,104.92 9.96,105.09 9.96,106.28 10.2,106.28 10.37,106.45 14.81,106.45
GND on TOP (solid shape): outline of 139 points within 0.65,41.79 33.56,49.85
GND on TOP (solid shape): outline of 192 points within 207.8,82.38 213.36,88.76
GND on TOP (solid shape): outline of 268 points within 128.61,117.4 157.57,129.82
GND on TOP (solid shape): outline of 260 points within 194.36,76.68 211.84,98.07
GND on TOP (solid shape): outline of 509 points within 192.3,56.18 217.63,65.05
GND on TOP (solid shape): outline of 398 points within 0.2,0.2 313.4,137.62
GND on BOTTOM (solid shape): 20.5,54.9 12.5,54.9 12.5,62.9 20.5,62.9
GND on BOTTOM (solid shape): 53.1,3.6 44.8,3.6 44.8,9.9 53.1,9.9
GND on BOTTOM (solid shape): 171.45,24.21 171.45,19.58 167.98,19.58 166.69,20.87 166.69,22.96 167.96,24.24 171.43,24.24
GND on BOTTOM (solid shape): 98.92,42.44 98.92,40.82 98.73,40.63 97.14,40.63 96.73,41.04 96.73,43.33 96.86,43.46 97.9,43.46
GND on BOTTOM (solid shape): 122.13,112.29 122.13,111.15 120.48,109.5 120.1,109.5 118.45,111.15 118.45,112.42 120.1,114.07 120.35,114.07
GND on BOTTOM (solid shape): 125.05,126.77 125.05,124.1 124.16,123.21 122.64,123.21 122.13,123.72 122.13,126.9 122.51,127.28 124.54,127.28
GND on BOTTOM (solid shape): 156.42,134.52 156.42,133.37 156.29,133.25 154.26,133.25 154.2,133.31 154.2,134.52 154.26,134.58 156.35,134.58
GND on BOTTOM (solid shape): 177.16,111.97 177.16,111.65 175.82,110.31 174.5,110.31 173.74,111.07 173.74,111.66 174.38,112.29 176.84,112.29
GND on BOTTOM (solid shape): 206.67,73.56 206.67,70.35 206.61,70.29 204.57,70.29 204.5,70.35 204.5,73.57 204.52,73.59 206.64,73.59
GND on BOTTOM (solid shape): 248.97,59.61 248.97,56.97 248.66,56.66 246.18,56.66 245.93,56.91 245.93,59.81 246.27,60.14 248.44,60.14
GND on BOTTOM (solid shape): 18.48,10 18.48,8.5 18.66,8.31 18.66,7.43 18.4,7.17 15.73,7.17 15.63,7.27 15.63,9.98 15.71,10.07 18.41,10.07
GND on BOTTOM (solid shape): 149.56,134.52 149.56,133.37 149.43,133.25 148.35,133.25 147.4,133.25 147.34,133.31 147.34,134.52 147.4,134.58 149.5,134.58
GND on BOTTOM (solid shape): 169.1,77.33 169.1,77.06 168.71,76.68 165.23,76.68 165.07,76.84 165.07,78.16 165.21,78.29 168.13,78.29
GND on BOTTOM (solid shape): 180.68,108.12 179.94,107.39 179.91,107.39 179.14,106.61 179.09,106.61 178.52,107.19 178.52,107.67 179.63,108.79 180.01,108.79
GND on BOTTOM (solid shape): 189.91,37.48 189.91,36.54 189.76,36.39 189,36.39 188.91,36.47 188.17,36.47 188.04,36.6 188.04,37.62 188.17,37.74 189.65,37.74
GND on BOTTOM (solid shape): 200.94,73.49 200.94,70.34 200.9,70.29 198.86,70.29 198.8,70.35 198.8,72.37 198.85,72.42 199.05,72.42 200.18,73.55 200.88,73.55
GND on BOTTOM (solid shape): 237.22,23.67 237.22,21.77 237.69,21.29 237.69,18.68 237.06,18.06 235.67,18.06 235.51,18.21 235.51,23.57 235.69,23.75 237.14,23.75
GND on BOTTOM (solid shape): 239.96,20.62 239.96,16.69 239.79,16.52 238.46,16.52 238.31,16.67 238.31,20.58 238.68,20.95 239.63,20.95
GND on BOTTOM (solid shape): 48.09,46.23 48.19,46.23 48.56,46.09 49.73,44.93 49.73,41.05 49.31,40.63 46.58,40.63 46.28,40.94 46.28,45.95 46.55,46.23 48.09,46.23
GND on BOTTOM (solid shape): 146.64,103.91 146.64,103.15 146.51,103.02 146.33,103.02 146.2,103.15 146.2,103.78 145.82,104.16 145.82,104.35 145.94,104.48 146.07,104.48
GND on BOTTOM (solid shape): 274.66,12.57 274.66,10.98 274.55,10.87 271.51,10.87 271.5,10.87 269.69,10.87 269.34,11.21 269.34,13.29 269.71,13.66 273.57,13.66
GND on BOTTOM (solid shape): 28.61,45.49 30.13,45.49 31.02,44.6 31.02,44.27 30.93,44.18 29.27,44.18 28.97,44.48 28.33,44.48 27.79,45.02 27.79,45.58 27.84,45.63 28.47,45.63
GND on BOTTOM (solid shape): 51.26,12.83 52.02,12.83 52.08,12.88 52.45,12.88 52.56,12.77 52.56,12.38 52.32,12.15 50.44,12.15 50.03,12.55 50.03,13.02 50.15,13.14 50.96,13.14
GND on BOTTOM (solid shape): 71.71,31.91 71.71,31.47 71.23,30.99 71.23,29.84 71.14,29.76 70.45,29.76 70.37,29.84 70.37,31.49 70.37,31.49 70.37,31.89 70.59,32.11 71.52,32.11
GND on BOTTOM (solid shape): 88.73,32.77 88.73,29.23 88.47,28.98 87.97,28.98 87.84,29.11 87.84,30.88 87.12,31.6 87.12,32.65 87.38,32.92 88.58,32.92
GND on BOTTOM (solid shape): 134.32,134.52 134.32,133.37 134.19,133.25 133.11,133.25 132.16,133.25 132.07,133.34 132.07,134.52 132.13,134.58 134.26,134.58
GND on BOTTOM (solid shape): 141.81,134.52 141.81,133.37 141.69,133.25 140.73,133.25 140.61,133.25 139.65,133.25 139.59,133.31 139.59,134.52 139.65,134.58 141.75,134.58
GND on BOTTOM (solid shape): 245.15,15.04 245.15,13.53 244.77,13.15 244.77,11.73 244.72,11.68 242.36,11.68 242.2,11.84 242.2,14.45 242.61,14.86 242.61,15.12 242.75,15.26 244.93,15.26
GND on BOTTOM (solid shape): 21.08,76.3 21.08,75.32 21.13,75.27 21.13,75.27 21.16,75.24 21.16,74.21 21.03,74.08 20.77,74.08 20.35,74.5 20.35,76.33 20.38,76.36 21.02,76.36
GND on BOTTOM (solid shape): 24.46,79.57 24.56,79.02 24.66,78.48 24.66,77.98 24.54,77.86 23.81,77.86 23.4,78.27 23.4,79.63 23.44,79.66 24.37,79.66
GND on BOTTOM (solid shape): 139.24,104.19 139.24,104.17 139.5,103.91 139.5,103.1 139.43,103.02 139.24,103.02 139.11,103.15 139.11,103.7 138.7,104.12 138.7,104.32 138.86,104.48 138.95,104.48
GND on BOTTOM (solid shape): 153.73,103.92 153.73,103.72 153.73,103.72 153.73,103.15 153.6,103.02 153.41,103.02 153.29,103.15 153.29,103.71 152.86,104.13 152.86,104.32 153.03,104.48 153.17,104.48
GND on BOTTOM (solid shape): 180.17,103.67 180.17,103.12 180.17,103.12 180.24,103.06 180.83,103.06 180.93,102.95 180.93,101.7 180.85,101.62 179.89,101.62 178.52,102.99 178.52,103.12 179.35,103.96 179.88,103.96
GND on BOTTOM (solid shape): 185.76,124.81 186.69,124.81 186.75,124.75 186.75,124.38 186.61,124.24 184.2,124.24 183.8,124.64 183.8,125.29 183.85,125.33 184.53,125.33 184.67,125.48 185.09,125.48
GND on BOTTOM (solid shape): 194.33,61.25 194.33,60.36 192.65,58.68 189.57,58.68 189.43,58.82 189.43,59.26 189.43,59.27 189.43,61.15 189.73,61.45 194.12,61.45
GND on BOTTOM (solid shape): 279.51,46.85 279.51,44.54 279.41,44.44 278.09,44.44 277.96,44.57 277.96,45.14 277.77,45.33 277.77,46.8 277.99,47.02 279.34,47.02
GND on BOTTOM (solid shape): 23.66,85.08 23.83,83.88 23.83,83.23 23.6,83 22.71,83 22.46,83.26 22.46,84.43 22.46,84.44 22.73,84.71 22.73,85.07 22.77,85.11 23.63,85.11
GND on BOTTOM (solid shape): 158.39,103.97 158.39,103.78 158.45,103.72 158.45,103.72 158.45,103.15 158.32,103.02 158.14,103.02 158.01,103.15 158.01,103.71 157.6,104.12 157.6,104.32 157.76,104.48 157.88,104.48
GND on BOTTOM (solid shape): 182,100.55 182,99.84 181.83,99.67 180.65,99.67 179.41,98.43 179.23,98.43 178.55,99.11 178.55,99.52 179.71,100.68 181.87,100.68
GND on BOTTOM (solid shape): 195.21,72.32 195.21,70.33 195.05,70.16 194.73,70.16 194.69,70.12 194.69,69.27 194.5,69.08 193.88,69.08 193.66,69.3 193.66,72.21 193.84,72.39 195.14,72.39
GND on BOTTOM (solid shape): 200.56,121.39 200.56,120.72 200.46,120.63 198.01,120.63 197.92,120.71 197.92,121.09 197.77,121.25 197.51,121.25 197.41,121.34 197.41,121.49 197.51,121.59 200.36,121.59
GND on BOTTOM (solid shape): 161.5,129.18 161.5,124.23 161.37,124.1 161.18,124.1 160.48,124.8 159.59,124.8 159.47,124.93 159.47,126.77 158.96,127.28 158.96,128.29 159.72,129.06 160.74,129.06 160.99,129.31 161.37,129.31
GND on BOTTOM (solid shape): 216.46,43.91 216.46,43.36 216.41,43.3 216.11,43.3 215.5,42.7 214.51,42.7 214.18,43.03 214.18,43.45 214.2,43.52 214.2,43.58 214.2,43.76 214.44,43.99 216.39,43.99
GND on BOTTOM (solid shape): 239.89,105.77 239.89,105.24 239.76,105.11 239.3,105.11 238.92,104.73 238.92,103.76 238.86,103.7 238.52,103.7 238.41,103.81 238.41,104.82 238.68,105.09 238.68,105.44 239.08,105.84 239.82,105.84
GND on BOTTOM (solid shape): 62.39,11.4 62.39,6.57 62.65,6.32 63.54,6.32 63.66,6.19 63.66,5.43 63.41,5.18 59.85,5.18 59.6,5.43 59.6,8.1 60.5,9 60.5,10.14 61.88,11.53 62.27,11.53
GND on BOTTOM (solid shape): 151.37,103.96 151.37,103.12 151.27,103.02 151.05,103.02 150.95,103.12 150.95,103.56 150.59,103.92 150.59,103.94 150.56,104 150.53,104.06 150.53,104.39 150.63,104.5 150.83,104.5
GND on BOTTOM (solid shape): 262.83,48.3 262.83,45.47 262.14,44.79 260.12,44.79 259.75,44.42 258.45,44.42 258.27,44.6 258.27,46.6 258.36,46.68 259.27,46.68 259.7,47.12 259.7,48.34 259.85,48.48 262.64,48.48
