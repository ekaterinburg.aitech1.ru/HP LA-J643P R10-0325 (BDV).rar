# Allegro board LAJ643PR10-0325.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+19VB_1.35VSDGPUP:
  vias: v1(255.83,46.2) v2(255.48,45.13) v2(256.04,45.11) v2(256.61,45.11)
+19VB_1V5: length 1.8
  BOTTOM w0.127: 238.29,31.25 238.15,31.25 237.24,32.16 v1(237.24,32.55)
+19VB_3V:
  vias: v1(246.45,33.98)
+19VB_5V:
  vias: v1(76.36,5.55) v2(74.84,5.18) v2(75.85,5.18) v2(76.87,5.18) v2(78.15,5.07) v2(78.78,5.07) v2(79.62,5.04) v2(80.25,5.04) v2(80.89,5.04) v2(81.49,5.03)
+19VB_CHG:
  vias: v1(247.39,11.9)
+19VB_CPU: length 13.6
  IN1 w0.254: v2(156.8,130.58) 157.69,131.47 161.12,131.47 161.63,131.98 162.13,131.98 163.53,130.58 163.53,128.17 162.9,127.53 v2(161.88,127.53)
  BOTTOM w0.254: PRZ55.1 v2(161.88,127.53)
  BOTTOM w0.508: PCZ48.1 v2(148.67,131.21)
  vias: v1(105.48,79.54) v2(108.96,89.75) v2(109.54,89.75) v2(110.1,91.75) v2(111.35,91.75) v2(112.59,91.75) v2(113.83,91.75) v2(115.45,92.31) v2(115.46,91.71) v2(124.29,132.61) v2(124.29,131.98) v2(124.29,131.34) v2(124.92,132.61) v2(124.92,131.98) v2(124.92,131.34) v2(125.56,132.61) v2(125.56,131.98) v2(125.56,131.34) v2(126.19,132.61) v2(126.19,131.98) v2(126.19,131.34) v2(127.63,130.5) v2(128.87,130.5) v2(130.12,130.5) v2(131.36,130.5) v2(133.11,131.47) v2(134.99,130.5) v2(136.24,130.5) v2(137.48,130.5) v2(138.73,130.5) v2(140.73,131.4) v2(142.61,130.5) v2(143.86,130.5) v2(145.1,130.5) v2(146.35,130.5) v2(150.23,130.5) v2(151.48,130.5) v2(152.72,130.5) v2(153.97,130.5) v2(154.07,132.1) v2(157.38,128.72) v2(157.97,128.75) v6(103.55,79.5) v6(103.54,78.88) v6(103.55,78.25) v6(103.56,77.61) v6(103.57,77) v6(103.58,76.38) v6(104.1,79.22) v6(104.09,78.61) v6(104.1,77.98) v6(104.11,77.34) v6(104.12,76.72) v6(104.67,78.99) v6(104.65,78.38) v6(104.67,77.75) v6(104.68,77.11) v6(104.69,76.49)
+19VB_DDR: length 18.2
  TOP w0.254: v2(90.68,24.47) 90.98,24.77 v1(93.45,24.77) 93.54,24.77 95.17,26.39 95.17,28.71 96.53,30.07 96.53,33.82 95.83,34.53 94.25,34.53
  BOTTOM w0.254: PRM7.1 90.3,23.06 90.3,24.09 v2(90.68,24.47)
+19VB_GPU_NVVDD: length 21.7
  IN3 w0.254: v2(228.77,61.35) 230.66,61.35 231.99,60.02 233.23,60.02 233.48,59.77 233.48,54.34 232.64,53.49 232.64,49.71 v2(229.32,46.39)
  BOTTOM w0.254: PRV18.1 228.08,61.35 v2(228.77,61.35)
  vias: v1(223.26,51.43) v2(195.01,54.92) v2(196.26,54.92) v2(197.5,54.92) v2(198.74,54.92) v2(199.41,55.46) v2(199.39,54.73) v2(201.43,55.06) v2(202.18,55.05) v2(202.4,55.69) v2(202.98,54.97) v2(204.22,54.97) v2(205.47,54.97) v2(206.71,54.97) v2(207.33,55.33) v2(207.34,54.74) v2(207.39,55.93) v2(209.52,55) v2(210.27,55.61) v2(210.25,54.99) v2(210.91,54.96) v2(212.15,54.96) v2(213.4,54.96) v2(214.64,54.96) v2(215.24,55.33) v2(215.24,54.75) v2(215.26,55.9) v2(217.33,54.91) v2(217.91,54.92) v2(225.82,46.39) v2(225.82,45.81) v2(226.4,46.39) v2(226.4,45.81) v2(226.98,46.39) v2(226.98,45.81) v2(227.57,46.39) v2(227.57,45.81) v2(228.15,46.39) v2(228.15,45.81) v2(228.74,46.39) v2(228.74,45.81) v2(229.32,45.81)
+19VB_INVPWR: length 2.1
  TOP w0.127: PCP1.1 v3(81.18,45.29)
+19VB_VCCIOP:
  vias: v1(187.56,100.58)
+AVDD33: length 12.6
  IN1 w0.508: v2(44.81,15.21) 44.09,15.93 44.09,18.18 v2(44.73,18.82)
  BOTTOM w0.127: RR1.2 45.39,21.21 v1(45.78,21.59)
  BOTTOM w0.203: RR11.2 46.31,17.04 45.89,17.46 CR6.1 44.65,17.93 44.17,17.46 UR1.27
  BOTTOM w0.254: RR12.1 44.99,15.39 v2(44.81,15.21)
  BOTTOM w0.508: CR3.1 CR6.1 ; CR3.1 45.42,19.68 RR2.2 RR1.2 ; CR3.1 v2(44.73,18.82)
+DVDD: length 11.4
  TOP w0.127: v1(293.91,13.24) 294.09,13.42 CA2.1
  TOP w0.203: UA1.3 293.62,17.43 293.83,17.21
  TOP w0.381: 293.83,17.21 CA1.1 293.91,16.21 v2(293.91,15.01) 294.01,14.9 294.01,14.43 294.09,14.35 CA2.1 ; v2(290.53,14.67) RA16.2
  IN2 w0.381: v2(293.91,15.01) 293.91,14.78 293.21,14.08 290.78,14.08 290.53,14.34 v2(290.53,14.67)
  BOTTOM w0.508: RA3.2 293.46,15.74 293.91,15.29 v2(293.91,15.01)
+V12_I: length 6.2
  TOP w0.127: RR14.2 37.8,17.26 v1(37.11,17.94)
  TOP w0.254: RR14.2 38.42,17.31 v2(38.42,17.46)
  BOTTOM w0.203: UR1.14 39.09,17.46 38.36,18.18 CR9.1
  BOTTOM w0.254: v2(38.42,17.46) 38.26,17.3 CR10.1 CR9.1
+V12_O: length 4.2
  TOP w0.127: RR14.1 37.41,15.77 36.81,16.37 v1(36.81,16.48)
  TOP w0.254: CR16.1 39.63,15.77 38.64,15.77 v2(38.61,15.8) 37.83,15.8 RR14.1
  BOTTOM w0.203: UR1.10 38.67,15.86 v2(38.61,15.8)
+VCC0: length 44.6
  TOP w0.254: v2(111.63,27.86) 111.63,27.65 111.14,27.16 RK32.2 109.82,27.16 109.47,27.52 108.92,27.52 RK33.2 ; v2(133.29,16.86) 133.08,16.65 CK13.1 134,16.18 134.44,16.62 UK1.111
  IN3 w0.254: v2(111.63,27.86) 111.63,28.07 112.07,28.51 113.38,28.51 114.43,27.46 115.95,27.46 117.08,28.58 118.86,28.58 119.27,28.18 119.27,27.55 119.89,26.92 120.88,26.92 121.12,26.69 129.03,26.69 129.76,25.96 129.76,24.61 128.9,23.75 128.9,20.68 127.78,19.57 127.78,17.01 129.27,15.51 131.94,15.51 v2(133.29,16.86)
+VCC_CORE:
  vias: v2(126.95,113.94) v2(127.34,114.45) v2(127.34,113.43) v2(127.59,115.09) v2(127.59,113.94) v2(127.72,112.8) v2(127.97,115.72) v2(127.97,114.45) v2(127.97,113.43) v2(128.22,115.09) v2(128.22,113.94) v2(128.35,112.8) v2(128.61,115.72) v2(128.61,114.45) v2(128.61,113.43) v2(128.86,115.09) v2(128.86,113.94) v2(128.99,112.8) v2(129.24,115.72) v2(129.24,114.45) v2(129.24,113.43) v2(129.49,115.09) v2(129.49,113.94) v2(129.62,112.8) v2(129.88,115.72) v2(129.88,114.45) v2(129.88,113.43) v2(130.13,115.09) v2(130.13,113.94) v2(130.26,112.8) v2(130.51,115.72) v2(130.51,114.45) v2(130.51,113.43) v2(130.76,115.09) v2(130.76,113.94) v2(130.89,112.8) v2(131.15,115.72) v2(131.15,114.45) v2(131.15,113.43) v2(131.4,118.84) v2(131.4,118.23) v2(131.4,117.63) v2(131.4,116.99) v2(131.4,116.36) v2(131.4,115.09) v2(131.4,113.94) v2(131.78,114.45) v2(131.78,113.43) v2(132.03,113.94) v2(132.42,113.43) v2(134.32,115.09) v2(134.27,113.89) v2(134.55,118.72) v2(134.55,118.13) v2(134.52,116.33) v2(134.57,117.57) v2(134.57,116.94) v2(134.7,115.72) v2(134.7,114.45) v2(134.96,115.09) v2(134.98,113.87) v2(135.34,115.72) v2(135.34,114.45) v2(135.59,115.09) v2(135.62,113.87) v2(135.97,115.72) v2(135.97,114.45) v2(136.23,115.09) v2(136.25,113.87) v2(136.61,115.72) v2(136.61,114.45) v2(136.86,115.09) v2(137.24,115.72) v2(137.24,114.45) v2(137.5,115.09) v2(137.6,118.82) v2(137.88,115.72) v2(137.88,114.45) v2(138.13,115.09) v2(138.23,118.82) v2(138.51,115.72) v2(138.51,114.45) v2(138.77,115.09) v2(138.87,118.82) v2(138.94,118.26) v2(138.94,117.7) v2(138.94,117.14) v2(138.94,116.33) v2(139.15,115.72) v2(139.15,114.45) v2(139.4,115.09) v2(139.5,118.82) v2(139.58,118.26) v2(139.55,117.7) v2(139.55,117.14) v2(139.58,116.33) v2(139.78,115.72) v2(139.78,114.45) v2(140.04,115.09) v2(140.14,118.82) v2(140.21,118.26) v2(140.19,117.7) v2(140.19,117.14) v2(140.21,116.33) v2(140.42,115.72) v2(140.42,114.45) v2(140.67,115.09) v2(140.77,118.82) v2(140.85,118.26) v2(140.82,117.7) v2(140.77,117.12) v2(140.82,116.3) v2(141.05,115.72) v2(141.05,114.45) v2(141.31,115.09) v2(141.41,118.82) v2(141.43,118.23) v2(141.38,117.68) v2(141.38,117.12) v2(141.46,116.3) v2(141.69,115.72) v2(141.69,114.45) v2(141.91,117.5) v2(141.89,116.74) v2(141.94,115.09) v2(142.04,118.82) v2(141.99,118.23) v2(142.32,115.72) v2(142.32,114.45) v2(142.4,117.83) v2(142.4,117.12) v2(142.37,116.33) v2(142.58,115.09) v2(142.68,118.82) v2(142.96,115.72) v2(142.96,114.45) v2(143.21,115.09) v2(143.29,118.82) v2(143.59,115.72) v2(143.59,114.45) v2(143.66,109.47) v2(143.66,108.82) v2(143.66,108.17) v2(143.66,107.52) v2(143.66,105.57) v2(143.66,104.92) v2(143.85,115.09) v2(143.75,90.65) v2(143.87,118.82) v2(144.23,115.72) v2(144.23,114.45) v2(144.44,109.47) v2(144.44,108.82) v2(144.44,108.17) v2(144.44,107.52) v2(144.44,106.87) v2(144.44,106.22) v2(144.44,105.57) v2(144.44,104.92) v2(144.42,104.24) v2(144.48,115.09) v2(144.71,92.25) v2(144.71,91.59) v2(144.67,90.65) v2(144.86,115.72) v2(144.86,114.45) v2(145.12,115.09) v2(145.06,98.16) v2(145.06,97.6) v2(145.06,97.04) v2(145.23,108.17) v2(145.23,107.52) v2(145.23,106.87) v2(145.23,106.22) v2(145.23,105.57) v2(145.23,104.92) v2(145.5,115.72) v2(145.5,114.45) v2(145.62,98.16) v2(145.62,97.6) v2(145.62,97.04) v2(145.75,115.09) v2(146.02,109.47) v2(146.02,108.82) v2(146.02,108.17) v2(146.02,107.52) v2(146.02,105.57) v2(146.02,104.92) v2(146.13,115.72) v2(146.13,114.45) v2(146.39,115.09) v2(146.69,118.72) v2(146.69,118.16) v2(146.69,117.6) v2(146.72,117.02) v2(146.72,116.38) v2(146.77,115.72) v2(146.77,114.45) v2(146.81,108.82) v2(146.81,108.17) v2(146.81,107.52) v2(146.81,106.87) v2(146.81,106.22) v2(146.81,105.57) v2(146.81,104.92) v2(146.83,104.24) v2(147.59,108.82) v2(147.59,107.52) v2(147.59,106.87) v2(147.59,106.22) v2(147.59,105.57) v2(147.59,104.92) v2(148.38,105.57) v2(148.38,104.92) v2(149.17,108.17) v2(149.17,107.52) v2(149.17,106.87) v2(149.17,106.22) v2(149.17,105.57) v2(149.17,104.92) v2(149.17,104.25) v2(149.96,109.47) v2(149.96,108.82) v2(149.96,108.17) v2(149.96,107.52) v2(149.96,106.87) v2(149.96,106.22) v2(149.96,105.57) v2(149.96,104.92) v2(150.07,115.59) v2(150.07,114.45) v2(150.2,118.79) v2(150.45,114.96) v2(150.7,115.59) v2(150.7,114.45) v2(150.74,109.47) v2(150.74,108.82) v2(150.74,108.17) v2(150.74,107.52) v2(150.74,105.57) v2(150.74,104.92) v2(150.78,118.82) v2(151.08,114.96) v2(151.08,98.16) v2(151.08,97.6) v2(151.08,97.04) v2(151.08,90.7) v2(151.34,115.59) v2(151.34,114.45) v2(151.36,118.79) v2(151.53,109.47) v2(151.53,108.82) v2(151.53,108.17) v2(151.53,107.52) v2(151.53,106.87) v2(151.53,106.22) v2(151.53,105.57) v2(151.53,104.92) v2(151.55,104.23) v2(151.72,114.96) v2(151.67,98.16) v2(151.67,97.6) v2(151.67,97.04) v2(151.97,115.59) v2(151.97,114.45) v2(151.97,90.7) v2(152.32,108.17) v2(152.32,107.52) v2(152.32,106.87) v2(152.32,106.22) v2(152.32,105.57) v2(152.32,104.92) v2(152.35,114.96) v2(152.61,115.59) v2(152.61,114.45) v2(152.81,118.79) v2(152.91,90.68) v2(152.99,114.96) v2(153.11,109.47) v2(153.11,108.82) v2(153.11,108.17) v2(153.11,107.52) v2(153.11,105.57) v2(153.11,104.92) v2(153.24,115.59) v2(153.24,114.45) v2(153.42,118.79) v2(153.62,114.96) v2(153.78,90.65) v2(153.88,115.59) v2(153.88,114.45) v2(153.89,109.47) v2(153.89,108.82) v2(153.89,108.17) v2(153.89,107.52) v2(153.89,106.87) v2(153.89,106.22) v2(153.89,105.57) v2(153.89,104.92) v2(154.01,118.77) v2(154.26,116.1) v2(154.26,114.96) v2(154.51,115.59) v2(154.51,114.45) v2(154.59,118.79) v2(154.68,108.17) v2(154.68,107.52) v2(154.68,106.87) v2(154.68,106.22) v2(154.68,105.57) v2(154.68,104.92) v2(154.72,91.29) v2(154.89,116.1) v2(154.89,114.96) v2(155.15,115.59) v2(155.15,114.45) v2(155.17,118.79) v2(155.53,116.1) v2(155.53,114.96) v2(155.47,109.47) v2(155.47,108.82) v2(155.47,108.17) v2(155.47,107.52) v2(155.47,105.57) v2(155.47,104.92) v2(155.63,90.7) v2(155.91,114.45) v2(156.25,109.47) v2(156.25,108.82) v2(156.25,108.17) v2(156.25,107.52) v2(156.25,106.87) v2(156.25,106.22) v2(156.25,105.57) v2(156.25,104.92) v2(156.57,90.65) v2(157.04,108.17) v2(157.04,107.52) v2(157.04,106.87) v2(157.04,106.22) v2(157.04,105.57) v2(157.04,104.92) v2(157.54,90.62) v2(157.73,109.54) v2(157.83,108.82) v2(157.83,108.17) v2(157.83,107.52) v2(157.83,105.57) v2(157.83,104.92) v2(158.42,109.59) v2(158.42,90.68) v2(158.62,108.82) v2(158.62,108.17) v2(158.62,107.52) v2(158.62,106.87) v2(158.62,106.22) v2(158.62,105.57) v2(158.62,104.92) v2(158.62,104.22) v2(159.14,92.1) v2(159.12,91.41) v2(159.31,90.68) v2(159.4,108.17) v2(159.4,107.52) v2(159.4,106.87) v2(159.4,106.22) v2(159.4,105.57) v2(159.4,104.92) v2(159.4,104.22) v2(160.21,90.67) v2(161.14,91.34) v3(144.07,117.26)
+VCC_GT: length 6.9
  IN3 w0.508: v2(142.08,109.47) 142.08,109.93 142.74,110.59 v2(146.24,110.59)
  BOTTOM w0.508: RC12.2 146.82,112.19 146.24,111.61 v2(146.24,110.59)
  vias: v2(114,103.66) v2(114,103.02) v2(114,102.39) v2(114,101.75) v2(114.05,99.18) v2(114.51,103.4) v2(114.51,102.77) v2(114.51,102.13) v2(114.64,99.21) v2(114.64,98.58) v2(115.14,103.66) v2(115.14,103.02) v2(115.27,98.7) v2(115.27,98.07) v2(115.78,103.66) v2(115.78,103.02) v2(115.91,98.7) v2(115.91,98.07) v2(116.41,103.66) v2(116.41,103.02) v2(116.54,98.7) v2(116.54,98.07) v2(116.67,106.07) v2(116.67,105.43) v2(117.18,98.7) v2(117.17,98.07) v2(117.3,106.7) v2(117.3,106.07) v2(117.81,107.08) v2(117.81,106.45) v2(117.81,105.81) v2(118.32,108.61) v2(118.32,107.97) v2(118.32,107.34) v2(118.32,106.7) v2(118.32,106.07) v2(118.7,101.88) v2(118.7,101.24) v2(118.7,100.61) v2(118.7,99.97) v2(118.7,99.34) v2(126.93,108.97) v2(127.61,93.3) v2(127.61,92.51) v2(128.27,109.59) v2(128.26,93.3) v2(128.26,92.51) v2(128.79,107.7) v2(128.91,93.3) v2(128.91,92.51) v2(128.98,109.59) v2(129.56,93.3) v2(129.56,92.51) v2(129.7,109.61) v2(130.21,93.3) v2(130.21,92.51) v2(130.3,108.16) v2(130.31,107.53) v2(130.86,101.17) v2(130.86,98.81) v2(130.86,93.3) v2(130.86,92.51) v2(131.51,101.17) v2(131.51,98.81) v2(131.51,93.3) v2(131.51,92.51) v2(131.85,109.49) v2(131.85,108.79) v2(131.85,108.14) v2(132.63,109.47) v2(132.63,108.82) v2(132.63,108.17) v2(132.63,107.52) v2(132.63,106.87) v2(132.63,106.22) v2(133.42,108.17) v2(133.42,107.52) v2(133.42,106.87) v2(133.42,106.22) v2(133.42,105.57) v2(133.42,104.92) v2(133.42,104.22) v2(133.79,91.31) v2(133.77,90.68) v2(134.21,109.47) v2(134.21,108.82) v2(134.21,108.17) v2(134.21,107.52) v2(134.21,105.57) v2(134.21,104.92) v2(134.66,91.31) v2(134.68,90.64) v2(135,109.47) v2(135,108.82) v2(135,108.17) v2(135,107.52) v2(135,106.87) v2(135,106.22) v2(135,105.57) v2(135,104.92) v2(135.51,91.26) v2(135.5,90.62) v2(135.78,108.17) v2(135.78,107.52) v2(135.78,106.87) v2(135.78,106.22) v2(135.78,105.57) v2(135.78,104.92) v2(135.78,104.22) v2(136.57,109.47) v2(136.57,108.82) v2(136.57,108.17) v2(136.57,107.52) v2(136.57,105.57) v2(136.57,104.92) v2(136.57,104.22) v2(137.36,109.47) v2(137.36,108.82) v2(137.36,108.17) v2(137.36,107.52) v2(137.36,106.87) v2(137.36,106.22) v2(137.36,105.57) v2(137.36,104.92) v2(137.36,90.66) v2(137.77,93.09) v2(138.14,108.17) v2(138.14,107.52) v2(138.14,106.87) v2(138.14,106.22) v2(138.14,105.57) v2(138.14,104.92) v2(138.14,104.22) v2(138.26,91.3) v2(138.79,93.06) v2(138.93,109.47) v2(138.93,108.82) v2(138.93,108.17) v2(138.93,107.52) v2(138.93,105.57) v2(138.93,104.92) v2(139.23,91.35) v2(139.22,90.66) v2(139.72,109.47) v2(139.72,108.82) v2(139.72,108.17) v2(139.72,107.52) v2(139.72,106.87) v2(139.72,106.22) v2(139.72,105.57) v2(139.72,104.92) v2(139.72,104.22) v2(140.09,91.32) v2(140.07,90.65) v2(140.51,108.17) v2(140.51,107.52) v2(140.51,106.87) v2(140.51,106.22) v2(140.51,105.57) v2(140.51,104.92) v2(140.51,104.22) v2(141.06,91.31) v2(141.05,90.61) v2(141.29,109.47) v2(141.29,108.82) v2(141.29,108.17) v2(141.29,107.52) v2(141.29,105.57) v2(141.29,104.92) v2(141.29,104.22) v2(142.08,108.82) v2(142.08,108.17) v2(142.08,107.52) v2(142.08,106.87) v2(142.08,106.22) v2(142.08,105.57) v3(117.47,99.77)
+VCC_SA:
  vias: v2(157.82,115.72) v2(157.82,115.09) v2(157.82,114.45) v2(158.45,115.72) v2(158.45,115.09) v2(158.45,114.45) v2(159.09,115.72) v2(159.09,115.09) v2(159.09,114.45) v2(159.72,115.72) v2(159.72,115.09) v2(159.72,114.45) v2(160.36,115.72) v2(160.36,115.09) v2(160.36,114.45) v2(160.63,96.76) v2(160.74,94.42) v2(160.99,115.72) v2(160.99,115.09) v2(160.99,114.45) v2(160.98,108.82) v2(160.98,108.17) v2(160.98,107.52) v2(160.98,106.87) v2(160.98,106.22) v2(160.98,105.57) v2(160.98,104.92) v2(160.98,104.22) v2(160.98,103.57) v2(160.98,102.92) v2(161.63,115.72) v2(161.63,115.09) v2(161.63,114.45) v2(161.77,109.47) v2(161.77,108.82) v2(161.77,108.17) v2(161.77,107.52) v2(161.77,106.87) v2(161.77,105.57) v2(161.77,104.92) v2(161.77,104.22) v2(161.77,102.92) v2(162.52,105.59) v2(162.57,108.85) v2(162.55,107.52) v2(162.55,106.87) v2(162.55,106.22) v3(159.61,116.74)
+VCCRTCEXT: length 4.4
  BOTTOM w0.203: UH1.BF47 UH1.BG47
  BOTTOM w0.254: UH1.BG47 191.54,17.75 190.33,16.53 190.33,14.76 CH25.1
GND: length 3265.8
  TOP w0.127: C408.2 v3(178.52,26.55) ; CR4.2 38.8,20.72 v3(39.32,21.24) ; v3(57.83,34.31) v2(58.41,34.31)
  TOP w0.203: JUSBC1.8 8.94,53.44 v2(9.38,53) ; JUSBC1.10 8.59,49.24 8.99,48.84 v2(9.24,48.84) ; 46.34,45.69 UU4.51 46.34,47.48 45.91,47.91 45.91,48.04 v2(45.9,48.04) ; v2(9.26,51.87) 9.26,51.77 8.91,51.42 8.42,51.42 8.4,51.44 JUSBC1.9
  TOP w0.254: PUG1.6 116.78,94.9 v2(116.67,95.02) ; UK1.35 150.21,10.62 149.1,11.73 v2(149.1,11.86) ; v2(215.2,81.05) 214.65,81.05 CG50.2 ; v2(269.71,42.91) 269.71,43.12 269.32,43.51 C402.2 ; UT1.9 121.52,13.49 v2(121.52,13.49) ; v2(232.48,11.71) 233,12.23 PRB25.2 ; v2(274.3,14.39) 274.3,14.9 274.52,15.12 PQ2.4 ; UT1.2 120.27,18.16 v2(119.96,17.85) ; UT1.16 v2(125.02,13.59) 125.02,13.4 124.59,12.98 CTT323.2 ; v2(288.08,28.88) 288.5,28.46 RA20.2 ; v2(146.18,9.82) 146.18,9.55 146.44,9.29 UK1.24 ; RT809.2 33.91,56.31 33.91,56.95 v2(34.04,57.07) 34.28,57.07 34.63,56.73 RT808.2 ; UT1.23 v2(126.63,18.16) ; U9.7 179.21,47.93 v2(179.92,48.65) ; RK29.1 132.81,15.38 133.55,15.38 133.65,15.49 v2(133.95,15.49) 134.13,15.49 134.46,15.82 UK1.113 ; UT1.32 121.52,19.7 121.35,19.87 v2(121.02,19.87) ; U11.5 177,30.2 v2(176.41,30.79) ; CC36.2 162.84,88.28 v2(162.84,88.73) ; DU3.8 v2(13.9,48.44) ; U9.5 179.67,46.47 v2(180.66,47.46) ; UK1.11 141.24,5.73 141.33,5.64 CK4.2 ; CU58.1 10.42,52.71 10.13,53 v2(9.96,53) ; RT810.2 32.6,56.37 v2(32.6,56.78) ; v2(138.13,22.5) 138.04,22.6 UK1.94 ; v2(174.87,133.78) 174.79,133.86 173.88,133.86 PCZ3.1 ; v2(17.03,48.46) 17.01,48.44 DU3.3 ; v2(212.76,100.34) 213.87,99.23 RG48.1 ; v2(129.75,18.92) 129.75,18.67 129.27,18.18 CTT2.2 ; RT860.2 27.1,53.58 26.72,53.96 v2(26.72,54.18) 26.72,54.48 27,54.76 CT271.2 ; v2(12.86,52.5) 13.2,52.16 DU1.3 DU1.8 16.07,52.16 v2(16.08,52.15) ; v2(149.37,5.05) 149.53,5.22 149.53,5.6 CK1.2 ; QS1.1 15.83,81.05 v2(15.32,80.54) ; R124.2 110.38,20.75 U4019.4 ; v2(179.32,48.69) 178.71,48.08 U9.8 ; U9.6 179.58,46.97 179.75,47.14 179.75,47.83 v2(180.56,48.64)
  TOP w0.305: v2(134.45,35.32) 134.71,35.32 134.98,35.6 134.98,36.15 134.7,36.43 CD78.2 ; v2(300.97,16.81) 300.97,17.02 300.77,17.22 300.77,17.45 300.33,17.88 CA93.2 ; v2(131.81,31.76) 131.68,31.76 131.27,31.35 131.27,30.27 131.78,29.77 CD74.2 ; CA18.1 303.61,20.72 303.74,20.86 v2(304.61,20.86) ; CD21.2 134.22,42.47 134.68,42.01 CD27.2 ; v2(29.53,55.89) 29.62,55.89 29.97,56.24 RT816.2 ; CD31.2 117.18,43.05 v2(117.48,43.36) ; CD83.2 130.26,29.87 130.64,30.25 130.64,31.38 130.23,31.79 v2(130.13,31.79) ; v2(139.37,30.77) 139.37,30.27 138.41,29.31 CD88.2 ; CD90.2 143.4,36.96 143.4,35.23 v2(142.74,34.58) ; CD73.2 135.72,29.87 136.61,30.76 136.61,33.22 136.99,33.6 v2(137.13,33.6) ; v2(132.21,35.45) 131.53,36.13 CD89.2 ; CA1.2 293.25,16.86 v2(293.12,16.99) 292.56,16.43 CA94.1 292.56,15.69 RA15.2 ; PCG82.2 PCG76.2 139.06,104.09 v2(138.93,104.22) ; v2(137.14,31.84) 137.14,30.6 136.61,30.07 CD85.2 ; CD77.2 142.8,37.21 143.34,37.74 143.34,39.3 142.77,39.87 v2(142.64,39.87) ; v2(302.06,18.29) 301.58,18.29 CA4.2 ; v2(133.51,31.79) 133.33,31.79 132.95,31.4 132.95,30.3 133.18,30.07 CD86.2 ; RT1112.2 25.24,51.8 24.88,52.16 24.06,52.16 v2(24,52.09) ; v2(290.43,17.07) 290.43,17.5 CA22.2 ; CD71.1 129.08,36.18 129.08,34.6 v2(129.42,34.25) ; v2(144.61,34.94) 144.81,34.94 145.12,35.24 CD76.2
  TOP w0.356: CT274.2 36.71,53.61 v2(36.79,53.69) ; PCV35.2 204.55,86.91 v2(204.08,86.44) ; v2(110.02,88.33) 110.43,87.92 CC407.2 CC402.2 ; RT1111.2 25.55,53.68 RT815.2 ; 26.48,47.52 25.94,47.52 v2(25.72,47.74) ; v2(207.8,78.55) 208.36,77.99 PCV34.2 ; CH26.2 CH84.2 ; v2(207.94,19.41) 207.9,19.45 CH29.2 CH86.2 ; v2(196.88,98.64) 196.84,98.6 CG52.2 196.83,98.08 CG54.2 ; CH82.1 192.61,19.05 v2(193.41,19.85) ; RA24.1 309.88,30.31 v2(310.49,30.91) ; v2(207.67,79.46) 207.58,79.55 PCV41.2 ; CG25.2 194.76,95.76 v2(195.16,96.16) ; v2(211.89,19.37) 211.74,19.21 CH31.2 CH85.2 211.74,17.5 CH30.2 ; CH9.1 191.6,18.06 RH210.1 ; RT1114.2 27.27,49.32 v2(27.28,49.31) ; v2(203.08,87.44) 202.78,87.13 PCV37.2
  TOP w0.381: C368.2 v2(21.25,4.52) ; CD98.2 172.55,52.19 172.22,52.52 172.22,52.55 v2(172.19,52.58) ; v2(217.78,93.62) 217.78,93.99 217.33,94.44 CG202.2 ; v2(209.32,76.94) 209.01,76.63 PCV65.2 ; CG81.2 185.9,124.55 v2(185.95,124.6) ; CG153.2 234.69,91.54 v2(234.84,91.69) ; RK26.2 147.35,5.06 v2(147.34,5.05) ; v2(36.66,46.26) 36.57,46.16 QT2.2 ; CD24.2 139.53,49.13 139.69,48.97 v2(139.69,48.62) ; CG61.2 189.17,120.56 v2(189.17,121.02) ; RG93.1 240.94,81.23 v2(240.94,80.67) ; v2(303.07,26.65) 302.69,26.65 CA36.1 ; CG114.2 248.37,67.74 v2(248.24,67.87) ; EC11.2 v2(18.37,5.92) ; v2(216.86,15.38) 216.86,15.02 Q73.3 ; CD29.2 143.51,49.78 CD91.2 142.07,49.27 142.07,48.06 142.55,47.57 v2(142.64,47.57) ; v2(272.85,17.4) 273,17.55 PR20.2 ; CC408.2 254.37,36.36 254.39,36.35 254.39,35.77 v2(254.35,35.74) ; CD21.2 133.69,43.31 134.47,44.09 v2(134.76,44.09) ; v2(305.35,4.93) 305.08,4.93 304.73,5.28 304.73,5.95 CW1.2 ; v2(153.22,11.34) 153.43,11.34 154.03,11.94 RK28.1 ; v2(185.95,129.4) 185.52,129.4 CG57.2 ; CC38.2 163.33,106.86 v2(163.35,106.88) ; v2(237.04,91.69) 237.05,91.68 CG108.2 ; v2(146.13,31.13) 146.13,30.38 145.88,30.12 RD24.2 ; v2(298.17,15.46) 298.28,15.57 CA88.1 ; v2(166.46,34.39) 166.71,34.39 167.09,34.77 167.09,35.29 RD22.2 ; v2(216.98,92.77) 216.43,92.21 CG128.2 CG129.2 ; CC152.2 151.08,87.41 v2(151.09,87.4) ; RWL1.2 311.55,20.98 v2(311.68,21.11) ; CG156.2 243.46,74.24 CG178.2 243.46,73.09 v2(243.78,72.76) ; CG109.2 v2(248.55,89.03) ; RU72.2 40.68,44.4 40.11,44.4 40.11,44.41 v2(40.07,44.41) ; v2(215,125) v2(215,124.2) ; v2(245.08,89.21) 245.48,89.61 CG157.2 ; v2(154.71,90.65) 154.23,90.18 CC20.2 ; CD14.1 148.04,42.59 v2(146.77,43.86) 146.26,43.36 RD10.1 ; RD29.1 140.43,31.46 139.87,32.02 v2(139.4,32.02) ; QV7.1 73.11,29.6 72.78,29.93 72.78,30.95 73.36,31.53 v2(73.36,31.72) ; CR1.2 CR4.2 38.08,20.31 v2(38.45,19.94) ; CD5.2 171.53,51.64 171.73,51.84 171.73,52.12 v2(171.76,52.14) ; v2(311.63,20.02) 311.44,20.22 RWL2.2 ; v2(243.73,89.72) 244.03,89.72 CG118.2 ; v2(120.99,39.92) 121.2,39.92 121.9,39.21 CD75.2 ; CG111.2 239.15,79.18 v2(239.04,79.07) ; CG115.2 245.04,81.24 v2(245.04,80.67) ; CG115.2 245.36,82.24 CG90.2 ; CG115.2 245.76,81.55 v2(246.64,80.67) ; RD28.1 142.96,29.61 CD69.1 ; CD72.1 CD69.1 ; CD69.1 144.23,29.87 CD70.1 144.07,30.38 143.51,30.93 143.51,32.05 143.87,32.41 v2(144.03,32.41) ; R5802.2 179.8,42.89 v2(180.43,42.26) ; UH3.3 216.93,10.15 216.41,10.15 v2(216.41,10.15) ; CG187.2 243.84,96.49 v2(243.84,96.49) ; C395.2 205.3,136.14 v2(205.3,135.86) ; v2(204.93,132.41) 204.65,132.13 C393.2 C394.2 ; CD79.2 156.54,39.19 v2(156.87,39.51) ; v2(186.55,135) v2(186.55,134.2) v2(185.95,134.2) 185.36,134.2 CG82.2 ; v2(168.03,40.82) 168.37,40.82 168.56,40.64 RD5.2 169.78,40.64 v2(169.8,40.61) 170.52,40.61 CD9.2 ; RT815.2 25.22,54.27 v2(25.03,54.08) ; PRB19.2 241.68,7.88 v2(241.68,7.89) ; CD99.2 v2(171.79,47.65) ; CA3.2 300.74,19.12 CA4.2 ; CG117.2 242.97,67.31 v2(242.97,67.88) ; CK2.2 140.01,5.59 v2(140.01,5) ; v2(215.04,10.13) 214.47,10.7 214.29,10.7 RH196.2 ; v2(249.17,75.34) 249.16,75.33 CG112.2 ; v2(168.28,39.45) 168.6,39.45 168.93,39.77 RD3.2 ; v2(225.4,134.2) v2(224.8,134.2) v2(224.8,135) ; v2(40.49,16.86) 40.15,16.86 40,16.71 CR16.2 ; CH83.1 CH10.1 190.34,20.9 CK14.1 ; Q79.3 v2(20.29,5.98) ; CD20.2 138.72,52.96 v2(139.36,52.32) ; v2(51.23,36.8) 50.8,37.23 CU66.2 ; C5247.1 178.92,50.2 v2(178.68,50.43) 178.28,50.03 C5246.1 ; v2(190.75,129.8) 190.81,129.74 CG166.2 ; v2(205.59,20.32) 205.78,20.51 RH273.2 ; CG162.2 212.18,121.4 v2(212.6,121.4) ; DS5.1 21.19,88.8 21.33,88.66 v2(21.73,88.66) ; v2(217.78,91.12) 218.01,91.35 CG19.2 ; CD92.2 134.14,49.61 134.14,47.94 134.43,47.65 v2(134.6,47.65) ; v2(185.95,123) 185.3,123 CG62.2 ; C5245.1 179.63,50.26 v2(179.15,50.75) ; RV47.2 v2(69.6,41.15) ; C5254.2 64.03,40.13 v2(64.03,39.48) ; v2(49.36,36.62) 49.7,36.97 CU73.2 ; v2(304.27,7.37) 303.39,7.37 QWL3.3 ; CG64.2 187.01,128.15 v2(186.57,128.6) ; CD95.2 147.15,49.3 v2(146.76,48.92) ; RG74.2 241.76,69.79 v2(242.24,70.27) ; CG158.2 212.1,134.2 v2(212.6,134.2) v2(213.2,134.2) ; CC27.2 159.1,85.45 v2(159.39,85.45) ; QC11.4 v2(183.14,15.55) ; v2(71.18,39.84) 70.84,39.84 CV49.2 ; CD19.2 145.5,48.91 144.49,47.9 v2(144.35,47.9) ; UV1.2 71.57,39.39 71.46,39.28 v2(71.19,39.28) ; RK20.1 148.79,5.41 v2(148.79,5.05) ; C5263.2 41.05,15.18 v2(40.49,15.74) ; v2(198.75,126.9) 198.75,126.9 199.22,126.9 RG90.1 ; v2(193.41,19.85) 193.5,19.76 193.5,18.57 CH73.1 ; RG401.1 225.28,63.87 v2(224.8,63.4) ; v2(266.78,38.07) 266.21,38.07 PRB01.1 ; CG148.2 245.04,67.03 v2(245.04,67.87) ; CG76.2 213.84,128.27 213.42,128.7 v2(213.2,128.7) v2(212.6,128.7) ; v2(158.13,40.86) 158.15,40.84 CD22.2 ; CG83.2 199.12,131.37 v2(198.75,131) ; v2(244.37,6.95) 244.32,7 PRB29.2 ; CG136.2 197.36,85.37 v2(196.56,85.37) ; v2(238.64,80.67) 238.69,80.72 CG116.2 ; v2(185.95,131) 185.95,131 CG63.2 ; C366.2 v2(17.01,2.44) ; CC26.2 157.73,85.94 159.17,85.94 v2(159.35,86.12) ; CD94.2 138.21,42.47 v2(139.69,43.95) ; CD2.1 CD102.1 CD1.1 170.01,53.49 169.71,53.79 v2(169.36,53.79) ; QG8.4 236.17,53.25 235.97,53.05 v2(235.97,52.62) ; v2(304.5,24.69) 304.22,24.97 302.5,24.97 CA38.1 ; v2(190.75,133.8) 190.78,133.83 CG171.2 ; v2(193.95,129.8) 193.9,129.74 CG170.2 ; v2(247.84,99.69) 247.81,99.65 CG94.2 ; CC18.2 143.79,87.45 v2(143.77,87.48) ; v2(235.04,101.29) 234.58,101.29 CG181.2 ; CU70.2 40.93,46.11 v2(40.52,46.52) 40.52,46.89 40.29,47.11 CU71.2 ; v2(28.8,56.52) 28.51,56.24 28.28,56.24 CV43.1 CV53.1 ; v2(295.54,28.74) 295.07,28.28 CA32.1 ; v2(32.6,56.78) 32.18,56.78 31.83,56.43 RT812.2 ; CK4.2 141.84,5.1 v2(141.94,5) ; v2(237.04,80.67) 236.99,80.73 CG113.2 ; CG100.2 247.68,72.84 v2(247.84,72.67) ; RG94.1 240.94,91.02 v2(240.94,91.69) ; CD30.2 131.41,46.25 v2(130.64,46.25) ; CWL7.2 CWL1.2 311.31,21.82 311.36,21.87 v2(311.68,21.87) ; RC393.2 181.67,12.76 QC11.1 ; v2(242.64,5.58) 242.16,5.58 PCB24.2 ; v2(225.4,131) v2(224.8,131) ; v2(297.34,30.53) 297.53,30.72 CA37.1 ; RK31.1 142.7,5.13 v2(142.59,5.01) ; QS1.4 18.91,79.75 19.26,79.4 19.26,77.11 v2(18.71,76.56) ; D1.1 9.56,122.73 v2(9.24,123.05) ; v2(243.84,75.87) 243.84,75.46 CG177.2 ; CC29.2 138.09,77.33 138.38,77.62 v2(138.89,77.62) ; v2(149.94,44.28) 149.33,43.67 149.33,43.36 149.81,42.87 CD28.2 ; v2(234.84,80.67) 234.79,80.71 234.79,81.52 CG151.2 ; CD6.2 v2(172.42,47.65) ; PQ2.1 272.29,17.22 v2(272.29,17.36) ; v2(246.64,67.87) 246.64,67.27 CG142.2 ; v2(166.3,105.33) 166.08,105.1 CC40.2 ; v2(171.23,36.01) CD100.2 CD64.2 ; RD6.2 148.51,39.9 149.21,39.2 v2(149.85,39.2) ; CA15.2 v2(300.07,15.76) ; RK23.2 136.82,26.18 CK9.2 v2(137.87,26.18) ; CV19.2 29.97,59.03 v2(30.31,58.69) ; D3.1 v2(206.84,128.93) ; CH30.2 211.82,16.03 v2(211.65,15.86) ; v2(193.95,133.8) 193.92,133.83 CG77.2 ; v2(146.52,88.78) 145.91,88.78 CC19.2 ; CD60.1 166.67,38.24 166.29,38.62 v2(166.29,39.35) ; CG10.2 211.33,98.94 v2(211.93,99.54) ; CG101.2 234.75,79.98 v2(234.84,80.07) ; RD23.2 168.96,35.11 v2(169.18,35.11) ; CK10.2 v2(148.19,5.07) ; v2(237.53,51.13) 237.88,51.13 RG12.2 ; RG402.1 234.25,54.05 v2(234.25,53.63) 234.25,53.17 QG8.1 ; CD96.2 136.23,44.04 135,45.26 v2(134.75,45.26) ; v2(213.19,120.75) 213.36,120.57 CG140.2 ; CG9.2 209.26,97.7 v2(209.41,97.84) ; CD26.2 142.32,42.98 v2(142.64,43.29) ; v2(250.59,100.42) 249.8,100.42 CG155.2 ; CG87.2 199.25,124.6 v2(198.75,124.6) ; 214.68,97.14 214.68,97.64 v2(214.48,97.84) ; CU69.2 53.69,43.53 54.5,43.53 v2(54.5,43.52) 54.62,43.64 55.35,43.64 CU74.2 ; v2(166.29,40.59) 166.53,40.59 166.9,40.22 CD103.1 CD61.1 ; PCM14.2 94.68,32.4 v2(94.7,32.41) ; v2(202.42,75.87) 202.04,76.26 PCV48.2 ; CD65.2 CD101.2 171.28,39.76 v2(171.29,39.77) ; v2(211.02,129.95) 211.66,129.95 RG89.1 ; CH84.2 188.79,19.93 v2(188.32,19.93) ; C365.2 v2(18.24,5.1) ; v2(212.6,131) 212.3,131 CG161.2 ; RG60.2 189.2,134.64 v2(188.35,133.8) ; v2(149.84,39.9) 149.5,39.9 148.61,40.79 CD12.1 ; PCV32.2 206.88,80.27 PCV33.2 207.7,80.27 v2(207.72,80.25) ; v2(125.69,31.41) 126.32,30.78 CD87.2 ; RK27.2 131.68,14.22 CK16.2 130.97,13.46 v2(130.85,13.57) ; CD84.2 140.12,38.05 v2(139.69,38.48) ; v2(64.21,41.3) 64.06,41.14 64.06,40.8 C5251.2 ; C5250.2 v2(17.01,1.8) ; CG169.2 199.35,123 v2(198.75,123) ; CG96.2 246.28,99.65 v2(246.24,99.69) ; CG152.2 243.48,98.72 CG97.2 243.84,99.68 v2(243.84,99.69) v2(243.84,100.49) ; v2(238.63,91.69) 239.12,91.2 CG182.2
  TOP w0.406: v2(210.22,80.19) 210.22,80.63 CG137.2
  TOP w0.457: v2(248.94,7.72) 248.94,7.1 PCB35.2 ; v2(154.34,83.52) 154.61,83.52 155.02,83.92 155.02,84.47 CC28.2 ; RH258.1 192.92,9.23 193.27,8.88 v2(193.63,8.88) ; CU68.2 54.31,45.83 v2(54.14,46) ; v2(164.32,97.48) 164.27,97.43 CC34.2 ; LK2.1 148.92,26.49 v2(148.62,26.19) 148.16,26.19 148.01,26.34 RK34.1 ; CH71.1 215.39,24.53 v2(214.82,25.11) ; RH198.1 191.22,11.44 v2(191.59,11.06) 191.98,11.45 RH197.1
  TOP w0.508: v2(161.88,126.64) 163.17,126.64 PRZ61.2 ; CK5.1 154.03,12.65 RK28.1 ; v2(192.88,21.67) 192.16,21.67 RH50.1 ; v2(274.3,14.39) 274.88,13.81 PQ1.3 ; RH22.2 212.77,21.38 v2(212.73,21.42) ; CH63.2 208.5,23.29 v2(208.84,22.95) ; RH8.2 212.88,36.95 v2(212.64,36.71) ; CH27.2 v2(178.74,15.64) ; CH79.1 215.19,9.98 v2(215.04,10.13) ; v2(286.21,42.26) PR5.2 ; v2(214.87,29.18) 214.54,29.18 RH14.1 ; v2(236.11,16.35) 235.94,16.51 PCB05.2 ; v2(138.28,87.48) 138.28,87.48 138.28,86.76 CC31.2 ; v2(104.74,40.73) 104.74,40.5 CD93.2 ; PCB30.2 v2(244.94,8.88) ; C5256.2 v2(84.86,6.55) ; CK12.2 128.86,22.25 128.83,22.22 CK11.1 127.41,22.22 v2(127.3,22.33) 126.87,22.76 QK1.3 ; v2(49.36,36.62) 49.32,36.59 CU67.2 ; v2(130.57,43.24) 131.65,42.15 CD25.2 ; v2(118.45,95.65) 118.88,96.09 PCG6.2 ; v2(196.94,11.06) 196.78,11.23 RH156.1 ; v2(294.59,14.97) 295,14.56 CA2.2 ; CH108.2 189.01,16.03 v2(188.5,16.03) ; CH35.2 206.43,23.06 206.41,23.08 v2(206.41,23.32) ; PRB30.2 v2(236.89,4.84) ; v2(242.55,10.53) 243.02,10.53 243.13,10.64 PCB29.2 ; v2(132.8,90.66) 132.75,90.71 CC37.2 ; v2(180.76,106.86) 180.7,106.8 CC397.2 ; v2(193.19,32.81) 192.46,32.81 191.95,33.32 CH32.2 ; CC30.2 151.78,85.99 v2(151.96,86.17) ; PD3.2 v2(287.31,38.76) ; v2(50.69,16.01) 50.79,16.11 CL29.2 ; v2(306.45,5.92) 306.48,5.95 CWL5.2 CWL3.2 ; DM16.1 9.25,59.97 v2(9.3,59.92) ; PC6.2 284.43,42.21 v2(284.48,42.26) ; CU59.2 12.05,51.87 CU60.1 v2(12.7,51.84) ; RU79.1 53.78,40.24 v2(54.04,40.5) ; CC144.2 132.42,8.26 v2(132.42,7.53) ; C367.2 v2(37.51,2.06) ; CK8.2 131.87,10.44 131.86,10.44 v2(131.6,10.18) ; v2(128.91,91.72) 129.05,91.72 129.58,91.19 RD11.1 ; C5259.2 88.27,6.94 v2(87.58,6.25) ; CH103.2 163.63,101.47 v2(163.7,101.4) ; CC153.2 149.3,86.15 v2(149.28,86.13) ; CD3.2 CD4.2 174.35,49.88 v2(175.21,49.02) ; RH20.1 v2(212.64,34.62) ; v2(160.74,123.21) 160.56,123.39 PCA7.2 ; CU57.1 v2(12.24,52.71) ; RM11.1 55.38,18.49 v2(55.71,18.83) ; v2(161.32,92.63) 160.99,92.96 PCA27.2 ; v2(14.84,84.07) 16.58,82.33 CS108.2 ; v2(207.09,32.92) 206.86,32.69 CH22.2 ; RA37.2 288.14,15.34 v2(286.9,15.34) 286.9,14.94 QA3.3 ; PC2.2 PC1.2 279.52,28.73 v2(278.07,27.28) ; CC32.2 147.21,83.91 v2(146.8,83.49) ; CL4.2 46.27,26.44 45.67,25.84 v2(45.67,25.37) ; v2(16.96,118.12) CV52.1 15.1,118.12 CV45.2 14.01,118.15 v2(13.87,118.29) ; CLRP3.1 217,20.37 219.06,18.31 v2(219.28,18.31) ; v2(166.27,95.12) 166.2,95.2 CC405.2 ; v2(117.53,14.05) 117.58,13.99 CTT1.2 ; CH14.2 204.05,33.58 204.05,34.39 v2(204,34.44) ; v2(232.91,15.14) 233.21,14.85 PCB03.1 ; CH72.1 v2(218.9,23.39) ; PC1003.2 234.57,24.07 v2(235.03,23.61) ; v2(161.77,103.57) 162.26,103.57 CC39.2 ; v2(125.96,40.77) 125.96,40.77 126.61,41.43 CD16.2 ; CD18.2 153.87,52.65 v2(154.63,52.65) ; v2(202.46,34.7) 202.43,34.72 CH13.2 ; v2(131.52,16.03) 131.68,16.18 CK13.2 ; CK15.2 148,26.43 RK34.1 ; v2(126.85,127.45) 126.88,127.43 128.06,127.43 PCZ68.2 ; v2(216.16,96.94) 215.73,96.51 RG49.1 ; CD81.1 141.32,28.08 v2(141.86,28.08) ; PCP7.2 85.38,34.82 v2(85.38,34.22) ; v2(65.95,41.65) 65.49,41.18 R5804.2 ; C390.2 198.33,8.95 v2(198.58,9.21) ; PC2503.2 108.91,18.99 v2(108.79,18.88) ; v2(255.31,43.06) 255.22,43.15 CC393.2 CC392.2 ; CH1.2 219.32,9.54 v2(220.04,9.54) ; CH36.2 213.15,17.45 v2(213.37,17.23) 213.37,17.27 214,17.9 RH23.2 ; PC325.2 71.7,8.13 71.79,8.22 v2(73.82,8.22) ; RK30.1 v2(131.5,18.97) ; DA8.1 v2(297.18,37.86) ; v2(155.06,27.98) 155.43,27.98 156.38,27.03 157.12,26.29 PCB31.2 ; PCA23.2 161.74,101.23 v2(162.12,100.85) ; RV50.2 v2(78.71,40.54) ; v2(117.54,18.08) 117.65,18.19 CTT3.2 CTT4.2 ; DT1.1 94.88,14.2 v2(94.35,14.2) ; v2(210.81,33.75) 210.37,34.2 RH173.2 ; CT270.2 37.55,53.54 37.39,53.69 v2(36.79,53.69) ; v2(86.02,12.24) 86.02,12.58 86.17,12.74 C388.2 ; v2(188.32,19.93) 188.07,20.18 CLRP2.1 ; v2(312.16,5.74) 311.56,6.34 CWL8.2 ; PD1.1 v2(281.89,41.93) ; C410.2 C5249.2 34.42,3.22 C409.2 35.13,3.21 v2(35.15,3.22) ; C5278.1 215.08,27.32 215.54,27.79 v2(215.54,27.98) ; v2(103.18,15.97) 103.38,15.77 PR2507.2 ; PCB23.2 v2(238.53,4.83) ; v2(117.53,15.7) 118.06,15.7 RTT12.2 ; CD13.1 124.24,51.2 v2(124.52,51.49) ; v2(10.06,44.6) 10.88,44.6 DU13.1 ; U7.1 v2(210.67,136.34) ; CH12.2 v2(202.42,36.45) ; v2(28.74,66.79) 28.42,67.1 CV31.2 ; v2(131.45,52.3) 132.09,52.3 CD23.2 ; CC35.2 164.32,94.99 v2(164.32,95.12) ; v2(182.11,11.35) 181.67,11.79 RC393.2 ; CH81.2 211.06,30.15 v2(211.54,30.15) ; v2(128.56,27.98) 128.48,28.07 CD10.1 ; v2(207.27,21.01) 207.27,21 206.72,21 CH64.2 ; v2(284.81,26.31) 285.19,25.93 DA1.2 ; CC24.2 163.91,90.31 164.32,90.72 v2(164.32,91.18) ; v2(195.67,8.88) 195.77,8.98 RH256.2 ; v2(141.77,84.75) 142.68,84.75 CC25.2 ; v2(19.98,65.67) 19.98,65.22 20.37,64.82 RV22.1 ; v2(165,87.23) 164.8,87.44 CC154.2 ; v2(214,17.01) 214.27,17.29 RH24.2 ; CC17.2 163.43,84.28 v2(163.58,84.13) ; PC5.2 285.16,41.16 v2(285.16,42.28) ; CD17.2 165.61,51.24 165.25,51.6 164.93,51.6 v2(164.93,51.6) ; CH62.2 201.41,27.28 201.36,27.22 201.34,27.22 v2(201.34,27.23) ; DM5.2 84.97,10.49 v2(84.67,10.79) ; CH102.2 165.26,99.06 v2(164.32,99.06) ; PRB34.2 v2(237.66,4.83) ; v2(164.32,92.76) 164.22,92.86 CC33.2 ; v2(85.47,6.35) 85.47,6.65 85.79,6.97 C5257.2 ; CWL2.2 310.99,23.62 CWL4.2 311.29,24.79 v2(311.29,25.11) ; C389.1 184.59,11.48 v2(184.03,11.48) ; v2(194.78,19.46) 194.37,19.05 CH70.2 ; v2(87,6.53) 87.35,6.88 C5258.2 ; v2(102.47,24.95) v3(102.47,24.01) 104.34,22.15 Q32.3 ; RH210.1 191.51,17.47 v2(190.63,17.47) 190.42,17.68 RH212.1 189.64,17.68 189.16,17.19 CLRP1.1 ; CD7.2 CD8.2 173.84,42.09 v2(174.17,42.42) ; C5277.2 176.14,31.82 v2(176.62,31.34) 176.64,31.32 178.01,31.32 v2(178.04,31.3) ; PU2501.2 v2(107.97,16.91) ; CL1.1 v2(45.9,32.54) ; CH15.2 192,34.29 192.47,33.82 v2(193.19,33.82) ; RK4.1 154.52,26.55 PCB32.2 154.56,26.93 153.52,27.98 v2(152.95,27.98) ; CV1.1 v2(73.08,37.11) ; CD80.2 116.52,30.27 v2(117.36,31.11) ; v2(102.39,18.59) 103.41,17.57 PC2501.1 ; CK14.1 190.05,21.07 v2(189.57,21.56) ; CD62.2 CD63.2 173.84,36.17 173.42,35.75 v2(173.41,35.75) ; v2(184.89,15.4) RH199.1 ; v2(111.02,20.72) R124.2 ; CD11.1 CD14.1 ; RL55.2 v2(40.85,35.01) ; CE5.2 v2(274.87,42.5) ; v2(201,9.2) C391.2 ; CH33.2 198.46,27.18 v2(198.46,27.77) ; DA9.1 v2(297.2,41.96) ; PCH2.2 182.82,112.3 v2(183.47,111.66)
  GND1 w0.203: JCR2.14 8.27,44.31 ; JCR2.14 5.42,44.31 ; JCR2.14 6.85,44.31 ; JCR2.14 5.42,43.44 ; JCR2.14 8.27,43.44 ; H22.1 4.83,9 ; H22.1 3,7.41 ; H22.1 1.17,9 ; H22.1 3,10.59 ; H22.1 1.17,7.41 ; H22.1 4.83,7.41 ; H22.1 1.17,10.59 ; H22.1 4.83,10.59 ; JUSB3.10 7.68,96.7 ; JUSB3.10 7.68,97.58 ; JUSB3.10 4.32,97.58 ; JUSB3.10 6,97.58 ; JUSB3.10 4.32,96.7 ; H12.1 121.6,121.71 ; H12.1 119.8,121.03 ; H12.1 123.4,117.43 ; H12.1 124.08,119.23 ; H12.1 119.8,117.43 ; H12.1 121.6,116.75 ; H12.1 119.12,119.23 ; H12.1 123.4,121.03 ; H19.1 180.53,66.13 ; H19.1 180.53,61.17 ; H19.1 182.33,65.45 ; H19.1 178.73,61.85 ; H19.1 183.01,63.65 ; H19.1 178.73,65.45 ; H19.1 182.33,61.85 ; H19.1 178.05,63.65 ; JHDMI1.22 12.45,119.83 ; JHDMI1.22 11.17,119.83 ; JHDMI1.22 11.17,117.97 ; JHDMI1.22 13.73,119.83 ; JHDMI1.22 13.73,118.9 ; JHDMI1.22 13.73,117.97 ; JHDMI1.22 11.17,118.9 ; H20.1 250.24,50.69 ; H20.1 249.56,48.89 ; H20.1 247.76,53.17 ; H20.1 245.96,48.89 ; H20.1 247.76,48.21 ; H20.1 245.28,50.69 ; H20.1 245.96,52.49 ; H20.1 249.56,52.49 ; JCR2.8 34.87,34.7 ; JCR2.8 34.67,34.03 ; JCR2.8 33.33,35.37 ; JCR2.8 34.67,35.37 ; JCR2.8 34,33.82 ; JCR2.8 33.33,34.03 ; JCR2.8 34,35.58 ; 290.32,33.98 PJP1.1 ; PJP1.1 290.95,32.52 ; PJP1.1 290.32,32.71 ; PJP1.1 291.78,33.35 ; PJP1.1 291.59,32.71 ; PJP1.1 290.12,33.35 ; PJP1.1 290.95,34.17 ; PJP1.1 291.59,33.98 ; 290.95,30.52 PJP1.2 ; PJP1.2 291.78,31.35 ; PJP1.2 290.32,31.98 ; PJP1.2 290.32,30.71 ; PJP1.2 290.12,31.35 ; PJP1.2 291.59,30.71 ; PJP1.2 290.95,32.17 ; PJP1.2 291.59,31.98 ; JHDMI1.8 12.88,110.65 ; JHDMI1.8 11.84,110.19 ; JHDMI1.8 11.84,111.11 ; JHDMI1.8 12.76,110.19 ; JHDMI1.8 12.76,111.11 ; JHDMI1.8 11.72,110.65 ; 12.45,103.47 JHDMI1.20 ; JHDMI1.20 13.73,104.4 ; JHDMI1.20 13.73,105.33 ; JHDMI1.20 11.17,105.33 ; JHDMI1.20 11.17,104.4 ; JHDMI1.20 11.17,103.47 ; JHDMI1.20 12.45,105.33 ; JHDMI1.20 13.73,103.47 ; H23.1 25.17,116.45 ; H23.1 24,113.69 ; H23.1 22.83,116.45 ; H23.1 25.59,115.28 ; H23.1 25.17,114.11 ; H23.1 22.41,115.28 ; H23.1 24,116.87 ; H23.1 22.83,114.11 ; 12,2.41 H17.1 ; H17.1 12,5.59 ; H17.1 13.17,2.83 ; H17.1 13.59,4 ; H17.1 10.83,5.17 ; H17.1 13.17,5.17 ; H17.1 10.83,2.83 ; H17.1 10.41,4 ; JUSB3.13 13.8,96.13 ; JUSB3.13 13.8,94.37 ; JUSB3.13 15.17,94.37 ; JUSB3.13 15.17,95.25 ; JUSB3.13 15.17,96.13 ; 294.53,6.73 H9.1 ; H9.1 296.87,9.07 ; H9.1 297.29,7.9 ; H9.1 296.87,6.73 ; H9.1 295.7,9.49 ; H9.1 295.7,6.31 ; H9.1 294.53,9.07 ; H9.1 294.11,7.9 ; 1.72,121.73 JHDMI1.23 ; JHDMI1.23 3,121.73 ; JHDMI1.23 3,119.87 ; JHDMI1.23 4.28,121.73 ; JHDMI1.23 4.28,120.8 ; JHDMI1.23 4.28,119.87 ; JHDMI1.23 1.72,119.87 ; JHDMI1.23 1.72,120.8 ; JUSBC1.6 8.76,56.33 ; JUSBC1.6 7.93,57.5 ; JUSBC1.6 8.76,56.91 ; JUSBC1.6 8.76,57.5 ; JUSBC1.6 7.1,56.91 ; JUSBC1.6 7.1,57.5 ; 115.38,81.63 H15.1 ; H15.1 118.99,81.63 ; H15.1 115.38,78.03 ; H15.1 118.99,78.03 ; H15.1 117.18,77.35 ; H15.1 114.71,79.83 ; H15.1 119.66,79.83 ; H15.1 117.18,82.31 ; H4.1 93,54.49 ; H4.1 94.59,52.9 ; H4.1 94.17,51.73 ; H4.1 94.17,54.07 ; H4.1 91.83,54.07 ; H4.1 93,51.31 ; H4.1 91.83,51.73 ; H4.1 91.41,52.9 ; JUSB3.4 14.7,86.13 ; JUSB3.4 14.1,84.75 ; JUSB3.4 15.48,85.35 ; JUSB3.4 14.7,84.57 ; JUSB3.4 15.3,85.95 ; JUSB3.4 15.3,84.75 ; JUSB3.4 13.92,85.35 ; JUSB3.4 14.1,85.95 ; H13.1 177.4,117.88 ; H13.1 177.4,114.27 ; H13.1 173.8,114.27 ; H13.1 178.08,116.08 ; H13.1 173.8,117.88 ; H13.1 175.6,118.55 ; H13.1 175.6,113.6 ; H13.1 173.12,116.08 ; 10.17,115.15 JHDMI1.17 ; JHDMI1.17 11.33,115.15 ; JHDMI1.17 10.29,115.61 ; JHDMI1.17 11.21,114.69 ; JHDMI1.17 11.21,115.61 ; JHDMI1.17 10.29,114.69 ; 47.88,7.07 H7.1 ; H7.1 49.05,7.49 ; H7.1 50.64,5.9 ; H7.1 49.05,4.31 ; H7.1 47.88,4.73 ; H7.1 47.46,5.9 ; H7.1 50.22,7.07 ; H7.1 50.22,4.73 ; 10.17,109.15 JHDMI1.5 ; JHDMI1.5 11.21,109.61 ; JHDMI1.5 10.29,109.61 ; JHDMI1.5 11.33,109.15 ; JHDMI1.5 11.21,108.69 ; JHDMI1.5 10.29,108.69 ; JUSBC1.B12 6.92,56.42 ; JUSBC1.B12 6.39,54.86 ; JUSBC1.B12 5.86,55.64 ; JUSBC1.B12 5.86,56.42 ; JUSBC1.B12 6.39,56.42 ; JUSBC1.B12 6.92,54.86 ; H34.1 26.5,110.28 ; H34.1 25.3,109.85 ; H34.1 24.87,108.65 ; H34.1 28.13,108.65 ; H34.1 27.7,107.45 ; H34.1 25.3,107.45 ; H34.1 26.5,107.02 ; H34.1 27.7,109.85 ; 1.5,57.84 JUSBC1.4 ; JUSBC1.4 2.73,57.84 ; JUSBC1.4 2.73,59.19 ; JUSBC1.4 3.96,58.51 ; JUSBC1.4 1.5,59.19 ; JUSBC1.4 1.5,58.51 ; JUSBC1.4 3.96,59.19 ; JUSBC1.5 6.8,59.19 ; JUSBC1.5 5.57,57.84 ; JUSBC1.5 6.8,57.84 ; JUSBC1.5 4.34,58.51 ; JUSBC1.5 4.34,59.19 ; JUSBC1.5 6.8,58.51 ; JUSBC1.5 5.57,59.19 ; H16.1 4.67,124.73 ; H16.1 3.5,127.49 ; H16.1 4.67,127.07 ; H16.1 2.33,127.07 ; H16.1 1.91,125.9 ; H16.1 5.09,125.9 ; H16.1 3.5,124.31 ; H16.1 2.33,124.73 ; JUSB3.11 7.68,80.12 ; JUSB3.11 7.68,81 ; JUSB3.11 6,80.12 ; JUSB3.11 4.32,81 ; 174.21,73.63 H18.1 ; H18.1 177.82,77.23 ; H18.1 173.54,75.43 ; H18.1 174.21,77.23 ; H18.1 176.02,77.91 ; H18.1 176.02,72.95 ; H18.1 178.49,75.43 ; H18.1 177.82,73.63 ; JHDMI1.21 5.53,103.43 ; JHDMI1.21 5.53,101.57 ; JHDMI1.21 4.25,103.43 ; JHDMI1.21 2.97,101.57 ; JHDMI1.21 4.25,101.57 ; JHDMI1.21 2.97,102.5 ; JHDMI1.21 5.53,102.5 ; 13.8,81.57 JUSB3.12 ; JUSB3.12 13.8,83.33 ; JUSB3.12 15.17,81.57 ; JUSB3.12 15.17,83.33 ; JUSB3.12 15.17,82.45 ; PJP1.4 289.78,31.35 ; PJP1.4 288.32,31.98 ; PJP1.4 288.95,30.52 ; PJP1.4 289.59,31.98 ; PJP1.4 289.59,30.71 ; PJP1.4 288.32,30.71 ; PJP1.4 288.95,32.17 ; PJP1.4 288.12,31.35 ; 1.5,45.69 JUSBC1.3 ; JUSBC1.3 2.73,47.04 ; JUSBC1.3 3.96,45.69 ; JUSBC1.3 2.73,45.69 ; JUSBC1.3 1.5,46.36 ; JUSBC1.3 1.5,47.04 ; JUSBC1.3 3.96,46.36 ; JUSBC1.1 8.76,47.96 ; JUSBC1.1 8.76,47.38 ; JUSBC1.1 7.1,47.96 ; JUSBC1.1 7.1,47.38 ; JUSBC1.1 7.93,47.38 ; JUSBC1.1 8.76,48.55 ; JCR2.5 34.87,28.09 ; JCR2.5 34.67,27.42 ; JCR2.5 33.33,28.76 ; JCR2.5 34,28.97 ; JCR2.5 34.67,28.76 ; JUSBC1.B1 6.39,50.02 ; JUSBC1.B1 6.92,50.02 ; JUSBC1.B1 5.86,49.24 ; JUSBC1.B1 5.86,48.46 ; JUSBC1.B1 6.39,48.46 ; JUSBC1.B1 6.92,48.46 ; JUSBC1.2 6.8,45.69 ; JUSBC1.2 5.57,47.04 ; JUSBC1.2 6.8,47.04 ; JUSBC1.2 4.34,45.69 ; JUSBC1.2 5.57,45.69 ; JUSBC1.2 4.34,46.36 ; JUSBC1.2 6.8,46.36 ; 177.83,135.07 H1.1 ; H1.1 180.17,135.07 ; H1.1 179,132.31 ; H1.1 177.41,133.9 ; H1.1 177.83,132.73 ; H1.1 179,135.49 ; H1.1 180.59,133.9 ; H1.1 180.17,132.73 ; H2.1 230.67,6.73 ; H2.1 231.09,7.9 ; H2.1 230.67,9.07 ; H2.1 228.33,6.73 ; H2.1 229.5,9.49 ; H2.1 228.33,9.07 ; H2.1 229.5,6.31 ; H2.1 227.91,7.9 ; H8.1 267.5,54.49 ; H8.1 268.67,51.73 ; H8.1 268.67,54.07 ; H8.1 267.5,51.31 ; H8.1 266.33,51.73 ; H8.1 266.33,54.07 ; H8.1 265.91,52.9 ; H8.1 269.09,52.9 ; H11.1 17.53,58.89 ; H11.1 15.94,60.48 ; H11.1 14.77,57.72 ; H11.1 14.77,60.06 ; H11.1 15.94,57.3 ; H11.1 17.11,57.72 ; H11.1 14.35,58.89 ; H11.1 17.11,60.06 ; 288.12,33.35 PJP1.3 ; PJP1.3 289.59,32.71 ; PJP1.3 289.78,33.35 ; PJP1.3 288.95,32.52 ; PJP1.3 288.95,34.17 ; PJP1.3 289.59,33.98 ; PJP1.3 288.32,32.71 ; PJP1.3 288.32,33.98 ; 26.5,11.33 JCR2.13 ; JCR2.13 27.92,11.33 ; JCR2.13 25.07,12.2 ; JCR2.13 25.07,11.33 ; JCR2.13 27.92,12.2 ; 13.2,88.07 JUSB3.7 ; JUSB3.7 13.2,89.63 ; JUSB3.7 13.8,89.45 ; JUSB3.7 13.8,88.25 ; JUSB3.7 13.98,88.85 ; H14.1 233.67,110.19 ; H14.1 231.87,109.51 ; H14.1 231.87,114.47 ; H14.1 229.39,111.99 ; H14.1 233.67,113.79 ; H14.1 230.07,110.19 ; H14.1 230.07,113.79 ; H14.1 234.35,111.99 ; 10.17,112.15 JHDMI1.11 ; JHDMI1.11 10.29,111.69 ; JHDMI1.11 11.33,112.15 ; JHDMI1.11 10.29,112.61 ; JHDMI1.11 11.21,112.61 ; JHDMI1.11 11.21,111.69 ; JCR2.12 26.5,44.31 ; JCR2.12 27.92,43.44 ; JCR2.12 27.92,44.31 ; JHDMI1.2 12.76,107.19 ; JHDMI1.2 12.3,107.07 ; JHDMI1.2 11.72,107.65 ; JHDMI1.2 11.84,108.11 ; JHDMI1.2 11.84,107.19 ; JHDMI1.2 12.76,108.11 ; JHDMI1.2 12.88,107.65 ; 5.42,12.2 JCR2.15 ; JCR2.15 8.27,12.2 ; JCR2.15 8.27,11.33 ; JCR2.15 6.85,11.33 ; JCR2.15 5.42,11.33
  VCC w0.203: JHDMI1.5 11.33,109.15 ; JHDMI1.5 10.17,109.15 ; JHDMI1.5 10.29,109.61 ; JHDMI1.5 11.21,109.61 ; JHDMI1.5 11.21,108.69 ; JHDMI1.5 10.29,108.69 ; 2.97,101.57 JHDMI1.21 ; JHDMI1.21 5.53,101.57 ; JHDMI1.21 4.25,103.43 ; JHDMI1.21 4.25,101.57 ; JHDMI1.21 5.53,102.5 ; JHDMI1.21 5.53,103.43 ; JHDMI1.21 2.97,102.5 ; 25.3,107.45 H34.1 ; H34.1 26.5,110.28 ; H34.1 27.7,109.85 ; H34.1 25.3,109.85 ; H34.1 26.5,107.02 ; H34.1 28.13,108.65 ; H34.1 27.7,107.45 ; H34.1 24.87,108.65 ; 6,80.12 JUSB3.11 ; JUSB3.11 7.68,81 ; JUSB3.11 4.32,81 ; JUSB3.11 7.68,80.12 ; 114.71,79.83 H15.1 ; H15.1 117.18,77.35 ; H15.1 117.18,82.31 ; H15.1 118.99,78.03 ; H15.1 115.38,78.03 ; H15.1 119.66,79.83 ; H15.1 115.38,81.63 ; H15.1 118.99,81.63 ; 230.07,113.79 H14.1 ; H14.1 229.39,111.99 ; H14.1 231.87,109.51 ; H14.1 233.67,110.19 ; H14.1 233.67,113.79 ; H14.1 231.87,114.47 ; H14.1 234.35,111.99 ; H14.1 230.07,110.19 ; 11.84,110.19 JHDMI1.8 ; JHDMI1.8 11.84,111.11 ; JHDMI1.8 12.88,110.65 ; JHDMI1.8 12.76,110.19 ; JHDMI1.8 12.76,111.11 ; JHDMI1.8 11.72,110.65 ; H16.1 5.09,125.9 ; H16.1 3.5,127.49 ; H16.1 2.33,127.07 ; H16.1 1.91,125.9 ; H16.1 4.67,124.73 ; H16.1 2.33,124.73 ; H16.1 3.5,124.31 ; H16.1 4.67,127.07 ; 1.5,58.51 JUSBC1.4 ; JUSBC1.4 2.73,59.19 ; JUSBC1.4 3.96,59.19 ; JUSBC1.4 1.5,59.19 ; JUSBC1.4 1.5,57.84 ; JUSBC1.4 2.73,57.84 ; JUSBC1.4 3.96,58.51 ; JUSB3.12 15.17,82.45 ; JUSB3.12 13.8,81.57 ; JUSB3.12 15.17,81.57 ; JUSB3.12 15.17,83.33 ; JUSB3.12 13.8,83.33 ; JHDMI1.20 13.73,105.33 ; JHDMI1.20 12.45,103.47 ; JHDMI1.20 11.17,105.33 ; JHDMI1.20 11.17,103.47 ; JHDMI1.20 13.73,103.47 ; JHDMI1.20 11.17,104.4 ; JHDMI1.20 13.73,104.4 ; JHDMI1.20 12.45,105.33 ; 290.32,30.71 PJP1.2 ; PJP1.2 290.12,31.35 ; PJP1.2 291.78,31.35 ; PJP1.2 290.95,32.17 ; PJP1.2 290.32,31.98 ; PJP1.2 291.59,30.71 ; PJP1.2 291.59,31.98 ; PJP1.2 290.95,30.52 ; JHDMI1.2 12.76,108.11 ; JHDMI1.2 12.88,107.65 ; JHDMI1.2 11.84,108.11 ; JHDMI1.2 12.76,107.19 ; JHDMI1.2 12.3,107.07 ; JHDMI1.2 11.84,107.19 ; JHDMI1.2 11.72,107.65 ; H9.1 295.7,9.49 ; H9.1 296.87,9.07 ; H9.1 296.87,6.73 ; H9.1 297.29,7.9 ; H9.1 294.11,7.9 ; H9.1 294.53,6.73 ; H9.1 294.53,9.07 ; H9.1 295.7,6.31 ; 13.2,88.07 JUSB3.7 ; JUSB3.7 13.2,89.63 ; JUSB3.7 13.8,88.25 ; JUSB3.7 13.98,88.85 ; JUSB3.7 13.8,89.45 ; JUSBC1.5 5.57,59.19 ; JUSBC1.5 4.34,59.19 ; JUSBC1.5 4.34,58.51 ; JUSBC1.5 6.8,59.19 ; JUSBC1.5 6.8,58.51 ; JUSBC1.5 5.57,57.84 ; JHDMI1.22 13.73,119.83 ; JHDMI1.22 13.73,117.97 ; JHDMI1.22 11.17,117.97 ; JHDMI1.22 13.73,118.9 ; JHDMI1.22 11.17,118.9 ; JHDMI1.22 11.17,119.83 ; JHDMI1.22 12.45,119.83 ; JUSB3.13 15.17,94.37 ; JUSB3.13 13.8,94.37 ; JUSB3.13 15.17,96.13 ; JUSB3.13 15.17,95.25 ; JUSB3.13 13.8,96.13 ; JHDMI1.11 11.21,111.69 ; JHDMI1.11 10.17,112.15 ; JHDMI1.11 11.21,112.61 ; JHDMI1.11 11.33,112.15 ; JHDMI1.11 10.29,111.69 ; JHDMI1.11 10.29,112.61 ; H23.1 25.59,115.28 ; H23.1 22.83,116.45 ; H23.1 22.41,115.28 ; H23.1 25.17,114.11 ; H23.1 24,113.69 ; H23.1 24,116.87 ; H23.1 22.83,114.11 ; H23.1 25.17,116.45 ; JHDMI1.23 3,121.73 ; JHDMI1.23 4.28,120.8 ; JHDMI1.23 4.28,121.73 ; JHDMI1.23 1.72,119.87 ; JHDMI1.23 1.72,121.73 ; JHDMI1.23 4.28,119.87 ; JHDMI1.23 3,119.87 ; JHDMI1.23 1.72,120.8 ; H4.1 94.17,54.07 ; H4.1 91.83,54.07 ; H4.1 93,54.49 ; H4.1 91.83,51.73 ; H4.1 93,51.31 ; H4.1 94.17,51.73 ; H4.1 94.59,52.9 ; H4.1 91.41,52.9 ; H11.1 17.11,60.06 ; H11.1 14.35,58.89 ; H11.1 15.94,60.48 ; H11.1 17.53,58.89 ; H11.1 15.94,57.3 ; H11.1 14.77,57.72 ; H11.1 14.77,60.06 ; H11.1 17.11,57.72 ; 288.12,31.35 PJP1.4 ; PJP1.4 288.95,32.17 ; PJP1.4 289.59,31.98 ; PJP1.4 288.32,31.98 ; PJP1.4 288.95,30.52 ; PJP1.4 288.32,30.71 ; PJP1.4 289.78,31.35 ; PJP1.4 289.59,30.71 ; 14.1,85.95 JUSB3.4 ; JUSB3.4 13.92,85.35 ; JUSB3.4 15.3,84.75 ; JUSB3.4 15.48,85.35 ; JUSB3.4 14.7,86.13 ; JUSB3.4 15.3,85.95 ; JUSB3.4 14.1,84.75 ; JUSB3.4 14.7,84.57 ; JUSB3.10 7.68,97.58 ; JUSB3.10 4.32,96.7 ; JUSB3.10 7.68,96.7 ; JUSB3.10 6,97.58 ; JUSB3.10 4.32,97.58 ; 173.54,75.43 H18.1 ; H18.1 174.21,77.23 ; H18.1 176.02,77.91 ; H18.1 178.49,75.43 ; H18.1 176.02,72.95 ; H18.1 177.82,77.23 ; H18.1 177.82,73.63 ; H18.1 174.21,73.63 ; JHDMI1.17 11.21,115.61 ; JHDMI1.17 10.17,115.15 ; JHDMI1.17 10.29,114.69 ; JHDMI1.17 10.29,115.61 ; JHDMI1.17 11.33,115.15 ; JHDMI1.17 11.21,114.69 ; 288.32,33.98 PJP1.3 ; PJP1.3 288.95,32.52 ; PJP1.3 288.12,33.35 ; PJP1.3 289.59,32.71 ; PJP1.3 288.95,34.17 ; PJP1.3 289.78,33.35 ; PJP1.3 289.59,33.98 ; PJP1.3 288.32,32.71 ; PJP1.1 291.59,32.71 ; PJP1.1 290.95,34.17 ; PJP1.1 290.32,33.98 ; PJP1.1 291.78,33.35 ; PJP1.1 290.95,32.52 ; PJP1.1 290.32,32.71 ; PJP1.1 291.59,33.98 ; PJP1.1 290.12,33.35
  GND2 w0.203: H9.1 295.7,9.49 ; H9.1 296.87,6.73 ; H9.1 294.53,6.73 ; H9.1 294.11,7.9 ; H9.1 296.87,9.07 ; H9.1 295.7,6.31 ; H9.1 297.29,7.9 ; H9.1 294.53,9.07 ; H19.1 182.33,65.45 ; H19.1 178.73,61.85 ; H19.1 180.53,66.13 ; H19.1 183.01,63.65 ; H19.1 180.53,61.17 ; H19.1 178.73,65.45 ; H19.1 178.05,63.65 ; H19.1 182.33,61.85 ; JUSB3.13 15.17,94.37 ; JUSB3.13 13.8,94.37 ; JUSB3.13 15.17,96.13 ; JUSB3.13 13.8,96.13 ; JUSB3.13 15.17,95.25 ; PJP1.3 289.59,33.98 ; PJP1.3 289.59,32.71 ; PJP1.3 288.95,34.17 ; PJP1.3 289.78,33.35 ; PJP1.3 288.32,32.71 ; PJP1.3 288.95,32.52 ; PJP1.3 288.32,33.98 ; PJP1.3 288.12,33.35 ; JCR2.8 34.67,35.37 ; JCR2.8 34.87,34.7 ; JCR2.8 34,33.82 ; JCR2.8 33.33,35.37 ; JCR2.8 34.67,34.03 ; JCR2.8 34,35.58 ; JCR2.8 33.33,34.03 ; JHDMI1.8 12.88,110.65 ; JHDMI1.8 11.84,111.11 ; JHDMI1.8 11.84,110.19 ; JHDMI1.8 12.76,110.19 ; JHDMI1.8 12.76,111.11 ; JHDMI1.8 11.72,110.65 ; JUSBC1.4 2.73,59.19 ; JUSBC1.4 3.96,58.51 ; JUSBC1.4 1.5,57.84 ; JUSBC1.4 1.5,58.51 ; JUSBC1.4 3.96,59.19 ; JUSBC1.4 2.73,57.84 ; JUSBC1.4 1.5,59.19 ; 12.45,103.47 JHDMI1.20 ; JHDMI1.20 12.45,105.33 ; JHDMI1.20 11.17,103.47 ; JHDMI1.20 13.73,104.4 ; JHDMI1.20 11.17,105.33 ; JHDMI1.20 13.73,105.33 ; JHDMI1.20 11.17,104.4 ; JHDMI1.20 13.73,103.47 ; JUSB3.7 13.8,89.45 ; JUSB3.7 13.2,88.07 ; JUSB3.7 13.8,88.25 ; JUSB3.7 13.98,88.85 ; JUSB3.7 13.2,89.63 ; 91.83,51.73 H4.1 ; H4.1 94.59,52.9 ; H4.1 93,54.49 ; H4.1 93,51.31 ; H4.1 94.17,51.73 ; H4.1 91.41,52.9 ; H4.1 94.17,54.07 ; H4.1 91.83,54.07 ; 229.5,6.31 H2.1 ; H2.1 229.5,9.49 ; H2.1 227.91,7.9 ; H2.1 231.09,7.9 ; H2.1 228.33,9.07 ; H2.1 228.33,6.73 ; H2.1 230.67,6.73 ; H2.1 230.67,9.07 ; 2.33,124.73 H16.1 ; H16.1 1.91,125.9 ; H16.1 3.5,127.49 ; H16.1 5.09,125.9 ; H16.1 3.5,124.31 ; H16.1 2.33,127.07 ; H16.1 4.67,124.73 ; H16.1 4.67,127.07 ; H11.1 15.94,60.48 ; H11.1 14.77,60.06 ; H11.1 14.35,58.89 ; H11.1 15.94,57.3 ; H11.1 17.11,60.06 ; H11.1 17.11,57.72 ; H11.1 14.77,57.72 ; H11.1 17.53,58.89 ; 14.1,85.95 JUSB3.4 ; JUSB3.4 14.7,84.57 ; JUSB3.4 13.92,85.35 ; JUSB3.4 15.3,85.95 ; JUSB3.4 15.3,84.75 ; JUSB3.4 14.1,84.75 ; JUSB3.4 15.48,85.35 ; JUSB3.4 14.7,86.13 ; JUSBC1.B1 6.39,50.02 ; JUSBC1.B1 5.86,49.24 ; JUSBC1.B1 6.92,48.46 ; JUSBC1.B1 6.39,48.46 ; JUSBC1.B1 6.92,50.02 ; JUSBC1.B1 5.86,48.46 ; JUSBC1.B12 6.39,56.42 ; JUSBC1.B12 5.86,56.42 ; JUSBC1.B12 6.92,56.42 ; JUSBC1.B12 6.92,54.86 ; JUSBC1.B12 6.39,54.86 ; JUSBC1.B12 5.86,55.64 ; 114.71,79.83 H15.1 ; H15.1 118.99,78.03 ; H15.1 118.99,81.63 ; H15.1 117.18,82.31 ; H15.1 115.38,81.63 ; H15.1 115.38,78.03 ; H15.1 117.18,77.35 ; H15.1 119.66,79.83 ; 176.02,72.95 H18.1 ; H18.1 176.02,77.91 ; H18.1 174.21,77.23 ; H18.1 178.49,75.43 ; H18.1 177.82,77.23 ; H18.1 174.21,73.63 ; H18.1 177.82,73.63 ; H18.1 173.54,75.43 ; JHDMI1.11 11.33,112.15 ; JHDMI1.11 10.29,112.61 ; JHDMI1.11 10.17,112.15 ; JHDMI1.11 10.29,111.69 ; JHDMI1.11 11.21,112.61 ; JHDMI1.11 11.21,111.69 ; JHDMI1.2 12.76,107.19 ; JHDMI1.2 12.88,107.65 ; JHDMI1.2 12.76,108.11 ; JHDMI1.2 12.3,107.07 ; JHDMI1.2 11.84,107.19 ; JHDMI1.2 11.84,108.11 ; JHDMI1.2 11.72,107.65 ; 288.95,30.52 PJP1.4 ; PJP1.4 288.12,31.35 ; PJP1.4 289.59,31.98 ; PJP1.4 288.32,30.71 ; PJP1.4 288.95,32.17 ; PJP1.4 289.59,30.71 ; PJP1.4 288.32,31.98 ; PJP1.4 289.78,31.35 ; H17.1 13.17,5.17 ; H17.1 10.41,4 ; H17.1 12,2.41 ; H17.1 13.17,2.83 ; H17.1 10.83,5.17 ; H17.1 10.83,2.83 ; H17.1 12,5.59 ; H17.1 13.59,4 ; 7.93,47.38 JUSBC1.1 ; JUSBC1.1 8.76,47.38 ; JUSBC1.1 7.1,47.38 ; JUSBC1.1 8.76,47.96 ; JUSBC1.1 8.76,48.55 ; JUSBC1.1 7.1,47.96 ; 13.8,81.57 JUSB3.12 ; JUSB3.12 15.17,83.33 ; JUSB3.12 15.17,82.45 ; JUSB3.12 15.17,81.57 ; JUSB3.12 13.8,83.33 ; 290.12,31.35 PJP1.2 ; PJP1.2 290.32,31.98 ; PJP1.2 290.95,32.17 ; PJP1.2 290.95,30.52 ; PJP1.2 291.59,31.98 ; PJP1.2 290.32,30.71 ; PJP1.2 291.59,30.71 ; PJP1.2 291.78,31.35 ; H22.1 4.83,9 ; H22.1 3,7.41 ; H22.1 3,10.59 ; H22.1 4.83,10.59 ; H22.1 1.17,10.59 ; H22.1 1.17,7.41 ; H22.1 1.17,9 ; H22.1 4.83,7.41 ; 290.12,33.35 PJP1.1 ; PJP1.1 291.59,32.71 ; PJP1.1 291.59,33.98 ; PJP1.1 291.78,33.35 ; PJP1.1 290.32,32.71 ; PJP1.1 290.32,33.98 ; PJP1.1 290.95,34.17 ; PJP1.1 290.95,32.52 ; H7.1 50.22,7.07 ; H7.1 47.46,5.9 ; H7.1 50.22,4.73 ; H7.1 49.05,4.31 ; H7.1 49.05,7.49 ; H7.1 50.64,5.9 ; H7.1 47.88,7.07 ; H7.1 47.88,4.73 ; JCR2.13 27.92,11.33 ; JCR2.13 25.07,12.2 ; JCR2.13 26.5,11.33 ; JCR2.13 27.92,12.2 ; JCR2.13 25.07,11.33 ; 245.96,52.49 H20.1 ; H20.1 249.56,52.49 ; H20.1 245.28,50.69 ; H20.1 250.24,50.69 ; H20.1 247.76,48.21 ; H20.1 245.96,48.89 ; H20.1 249.56,48.89 ; H20.1 247.76,53.17 ; 119.8,121.03 H12.1 ; H12.1 121.6,121.71 ; H12.1 124.08,119.23 ; H12.1 123.4,121.03 ; H12.1 119.12,119.23 ; H12.1 123.4,117.43 ; H12.1 119.8,117.43 ; H12.1 121.6,116.75 ; JUSBC1.5 5.57,59.19 ; JUSBC1.5 6.8,59.19 ; JUSBC1.5 4.34,58.51 ; JUSBC1.5 6.8,58.51 ; JUSBC1.5 6.8,57.84 ; JUSBC1.5 5.57,57.84 ; JUSBC1.5 4.34,59.19 ; H8.1 268.67,51.73 ; H8.1 268.67,54.07 ; H8.1 265.91,52.9 ; H8.1 266.33,54.07 ; H8.1 266.33,51.73 ; H8.1 269.09,52.9 ; H8.1 267.5,51.31 ; H8.1 267.5,54.49 ; H34.1 27.7,109.85 ; H34.1 24.87,108.65 ; H34.1 28.13,108.65 ; H34.1 26.5,107.02 ; H34.1 26.5,110.28 ; H34.1 25.3,107.45 ; H34.1 25.3,109.85 ; H34.1 27.7,107.45 ; 4.32,97.58 JUSB3.10 ; JUSB3.10 4.32,96.7 ; JUSB3.10 7.68,96.7 ; JUSB3.10 7.68,97.58 ; JUSB3.10 6,97.58 ; 4.32,81 JUSB3.11 ; JUSB3.11 7.68,80.12 ; JUSB3.11 7.68,81 ; JUSB3.11 6,80.12 ; JCR2.12 26.5,44.31 ; JCR2.12 27.92,44.31 ; JCR2.12 27.92,43.44 ; JHDMI1.23 3,121.73 ; JHDMI1.23 1.72,119.87 ; JHDMI1.23 1.72,121.73 ; JHDMI1.23 1.72,120.8 ; JHDMI1.23 4.28,119.87 ; JHDMI1.23 4.28,121.73 ; JHDMI1.23 4.28,120.8 ; JHDMI1.23 3,119.87 ; H14.1 233.67,110.19 ; H14.1 230.07,110.19 ; H14.1 231.87,114.47 ; H14.1 229.39,111.99 ; H14.1 234.35,111.99 ; H14.1 233.67,113.79 ; H14.1 230.07,113.79 ; H14.1 231.87,109.51 ; JCR2.5 34.87,28.09 ; JCR2.5 34.67,28.76 ; JCR2.5 33.33,28.76 ; JCR2.5 34.67,27.42 ; JCR2.5 34,28.97 ; 177.83,135.07 H1.1 ; H1.1 180.59,133.9 ; H1.1 180.17,135.07 ; H1.1 177.83,132.73 ; H1.1 180.17,132.73 ; H1.1 177.41,133.9 ; H1.1 179,135.49 ; H1.1 179,132.31 ; JCR2.15 8.27,12.2 ; JCR2.15 5.42,12.2 ; JCR2.15 8.27,11.33 ; JCR2.15 6.85,11.33 ; JCR2.15 5.42,11.33 ; JUSBC1.3 3.96,45.69 ; JUSBC1.3 1.5,45.69 ; JUSBC1.3 2.73,45.69 ; JUSBC1.3 2.73,47.04 ; JUSBC1.3 3.96,46.36 ; JUSBC1.3 1.5,47.04 ; JUSBC1.3 1.5,46.36 ; 5.42,44.31 JCR2.14 ; JCR2.14 5.42,43.44 ; JCR2.14 6.85,44.31 ; JCR2.14 8.27,43.44 ; JCR2.14 8.27,44.31 ; 11.17,117.97 JHDMI1.22 ; JHDMI1.22 13.73,118.9 ; JHDMI1.22 13.73,117.97 ; JHDMI1.22 11.17,118.9 ; JHDMI1.22 13.73,119.83 ; JHDMI1.22 11.17,119.83 ; JHDMI1.22 12.45,119.83 ; JUSBC1.6 8.76,56.33 ; JUSBC1.6 8.76,56.91 ; JUSBC1.6 7.93,57.5 ; JUSBC1.6 8.76,57.5 ; JUSBC1.6 7.1,57.5 ; JUSBC1.6 7.1,56.91 ; 4.34,46.36 JUSBC1.2 ; JUSBC1.2 6.8,47.04 ; JUSBC1.2 4.34,45.69 ; JUSBC1.2 6.8,46.36 ; JUSBC1.2 5.57,47.04 ; JUSBC1.2 5.57,45.69 ; JUSBC1.2 6.8,45.69 ; 22.83,114.11 H23.1 ; H23.1 22.83,116.45 ; H23.1 22.41,115.28 ; H23.1 24,113.69 ; H23.1 25.59,115.28 ; H23.1 25.17,114.11 ; H23.1 25.17,116.45 ; H23.1 24,116.87 ; JHDMI1.21 5.53,103.43 ; JHDMI1.21 5.53,101.57 ; JHDMI1.21 2.97,101.57 ; JHDMI1.21 5.53,102.5 ; JHDMI1.21 2.97,102.5 ; JHDMI1.21 4.25,103.43 ; JHDMI1.21 4.25,101.57 ; 173.8,114.27 H13.1 ; H13.1 178.08,116.08 ; H13.1 173.8,117.88 ; H13.1 177.4,117.88 ; H13.1 177.4,114.27 ; H13.1 175.6,113.6 ; H13.1 173.12,116.08 ; H13.1 175.6,118.55 ; 10.29,115.61 JHDMI1.17 ; JHDMI1.17 10.29,114.69 ; JHDMI1.17 11.21,114.69 ; JHDMI1.17 11.21,115.61 ; JHDMI1.17 10.17,115.15 ; JHDMI1.17 11.33,115.15 ; 10.17,109.15 JHDMI1.5 ; JHDMI1.5 11.21,108.69 ; JHDMI1.5 11.21,109.61 ; JHDMI1.5 10.29,109.61 ; JHDMI1.5 11.33,109.15 ; JHDMI1.5 10.29,108.69
  BOTTOM w0.089: v2(212.12,31.21) 212.33,31 212.52,31 212.74,31.16 213.01,31.24 213.33,31.24 213.48,31.39
  BOTTOM w0.102: 214.26,33.27 213.96,32.97 213.96,32.97 213.94,32.95 213.69,32.95 213.66,32.98 213.11,32.98 212.97,33.12
  BOTTOM w0.127: v2(123.6,6.78) v3(122.82,6.78) ; UH1.T4 212.97,33.12 ; v3(236.35,31.16) 236.75,31.56 v2(237.24,31.56) ; v2(217.76,75.34) 217.33,75.77 UG1.D2 ; UC1.F31 164.66,104.69 164.34,104.37 164.34,103.69 UC1.F29 ; v3(181.66,116.07) v2(181.17,115.58) ; v2(232.91,15.14) v3(232.91,15.73) ; v2(213.58,102.74) v2(213.58,101.94) v2(214.41,101.94) ; UH1.D8 210.91,39.09 210.7,39.31 210.7,40.07 210.79,40.16 UH1.A8 ; v3(228.13,71.72) v2(228.87,71.72) ; v2(266.18,45.76) v3(266.18,46.42) ; v2(297.34,30.53) v3(296.4,30.53)
  BOTTOM w0.15: v2(217.78,91.12) 217.78,91.74 217.58,91.94 217.18,91.94 216.98,92.14 v2(216.98,92.77) ; UG1.C25 217.78,96.09 v2(217.78,96.94) ; v2(217.78,84.44) 218.43,84.44 218.58,84.29 v2(218.58,83.62)
  BOTTOM w0.152: v2(199.29,41.16) 198.63,40.49 UH1.A33 ; UH1.M49 190.88,35 192.05,35 192.44,34.61 UH1.P46 ; v2(214.87,29.18) 214.79,29.1 UH1.AD1 UH1.AD2 ; UH1.AT1 214.38,23 214.68,23 v2(214.81,22.87) ; v2(220.18,82.77) 219.76,83.19 UG1.B10 ; UH1.A37 196.43,40.51 v2(196.73,40.81) ; UH1.J46 192.33,36.38 UH1.J47 191.55,36.38 UH1.J48 191.03,36.22 v2(190.81,36.45) ; UH1.AG1 214.79,27.42 215.44,27.42 215.54,27.52 v2(215.54,27.98) ; UH1.A28 200.82,40.49 v2(201.89,41.56) ; v2(214.82,25.11) 214.43,25.11 UH1.AM1 ; v2(197.06,16.29) 196.43,16.92 UH1.BG37 ; UH1.AC46 192.44,30.17 191.95,30.66 190.81,30.66 UH1.AA49 ; v2(202.37,17.28) 202.37,17.66 UH1.BG25 ; v2(200.82,17.29) UH1.BG28 ; UH1.BG17 v2(206.72,17.44) ; UH1.AG49 190.88,27.62 v2(190.88,27.8) 190.88,28.9 UH1.AD49 ; v2(215.73,90.69) UG1.G19 ; v2(198.63,17) UH1.BG33 ; UH1.BG22 v2(204.18,17.28)
  BOTTOM w0.178: UG1.E22 v2(215.73,93.19) UG1.G22
  BOTTOM w0.2: v2(220.18,93.62) v2(219.38,93.62)
  BOTTOM w0.203: UC1.N6 159.71,85.77 v2(159.39,85.45) 159.65,85.19 159.72,85.12 UC1.N5 UC1.N4 159.85,84.43 159.85,83.85 UC1.N3 UC1.N2 UC1.N1 ; UC1.N6 UC1.M6 ; UC1.N6 159.81,86.38 UC1.N7 159.82,86.48 159.82,87.02 UC1.N8 160.24,87.56 160.24,88 v2(160.21,88.03) 160.07,88.03 UC1.N9 159.75,87.75 159.75,88.36 UC1.N10 ; UC1.Y10 UC1.Y11 154.47,89.03 v2(154.74,88.75) 154.66,88.75 UC1.Y10 ; UC1.Y10 UC1.Y9 UC1.Y8 ; UC1.AF4 UC1.AF3 149.72,83.7 149.68,83.68 v2(149.34,83.49) 149.35,83.42 149.73,83.16 UC1.AF2 UC1.AF1 v2(149.76,81.97) ; UC1.AL9 146.44,88.12 v2(146.51,88.12) v2(146.51,87.48) 146.1,87.08 UC1.AL8 UC1.AL7 ; UC1.BH3 132.19,83.78 132.19,83.2 UC1.BH2 131.9,82.91 UC1.BH1 131.9,82.08 v2(131.81,82) ; UC1.BH3 132.21,83.88 132.21,84.41 UC1.BH4 UC1.BH5 132.03,85.12 v2(131.71,85.44) ; UC1.BH3 131.75,83.48 v2(131.72,83.48) ; UC1.BH11 v2(132.8,88.75) UC1.BH10 132.5,88.21 132.5,87.89 UC1.BH9 UC1.BH8 ; UC1.A24 167.53,99.05 v2(167.53,99.04) ; UC1.AD9 151.91,88.1 v2(152,88.1) ; UC1.AD9 151.57,87.7 151.57,87.11 UC1.AD8 ; UC1.AD9 UC1.AD10 ; UC1.BR7 127.96,86.63 128.56,86.63 UC1.BP7 128.91,86.93 v2(128.91,87.01) 129.1,86.82 129.1,86.82 129.24,86.68 UC1.BN7 ; UC1.Y8 154.66,87.45 v2(154.74,87.45) ; UC1.Y8 UC1.Y7 154.2,86.34 154.2,86.21 154.13,86.15 153.75,86.15 153.63,86.02 153.5,86.02 153.24,85.77 UC1.AB6 UC1.AC6 UC1.AC5 UC1.AC4 152.12,84.47 151.95,84.29 v2(151.82,84.17) 152.18,83.82 UC1.AC3 UC1.AC2 UC1.AC1 152.17,82.41 152.17,78.24 152.16,78.24 v2(152.16,77.31) ; UC1.BL6 UC1.BK6 131.38,85.77 v2(131.71,85.44) ; UC1.BL6 UC1.BM7 129.89,86.63 129.56,86.96 129.56,87.01 ; UC1.BL6 129.77,85.77 UC1.BM6 129.68,85.14 UC1.BM5 ; v2(139.25,82.84) 139.58,82.52 UC1.AW1 139.72,82.54 139.72,83.14 UC1.AW2 139.73,83.2 139.73,83.78 UC1.AW3 UC1.AW4 v2(139.24,84.72) UC1.AW5 139.88,85.12 UC1.AU6 ; UC1.BM5 129.7,85.04 UC1.BN4 129.14,84.48 128.81,84.48 128.78,84.45 128.44,84.45 128.28,84.29 127.8,84.29 127.55,84.53 UC1.BT4 ; UC1.BM5 129.78,85.04 129.86,84.89 129.86,84.8 v2(130.05,84.6) 129.89,84.44 129.89,84.34 UC1.BM3 UC1.BM2 129.7,83.53 129.32,83.33 UC1.BN2 ; v2(93.89,28.02) 93.62,27.75 PUM1.1 ; v2(143.77,88.75) 143.77,89.39 v2(143.77,89.39) 143.67,89.39 UC1.AP11 143.58,88.75 v2(143.77,88.75) ; v2(143.77,88.75) 143.77,88.75 v2(143.77,88.12) ; UC1.A9 UC1.B9 ; UC1.T14 UC1.T13 UC1.T12 ; UC1.T3 UC1.T4 UC1.T5 ; UC1.T3 157.17,83.82 v2(156.86,83.51) ; UC1.T3 157.3,83.71 157.31,83.7 157.31,83.32 157.3,83.3 UC1.T2 UC1.T1 157.26,82.52 v2(156.91,82.17) ; UC1.BH8 UC1.BH7 ; UC1.BH8 v2(132.79,87.4) ; v2(160.23,88.71) 159.89,88.38 UC1.N10 ; v2(193.41,19.85) UH1.BB43 ; v2(193.41,19.85) UH1.BC45 ; v2(193.41,19.85) UH1.BD43 193.51,19.01 193.45,18.86 UH1.BE44 ; UC1.Y13 154.38,90.33 v2(154.71,90.65) ; UC1.BB1 137.2,82.53 137.2,83.15 UC1.BB2 137.2,83.19 137.2,83.79 UC1.BB3 137.18,84.05 137.15,84.09 137.02,84.09 136.8,84.31 136.8,84.62 136.86,84.69 136.86,84.9 136.8,84.96 136.8,85.4 136.8,85.4 v2(136.76,85.44) ; UC1.BR21 UC1.BT21 v2(126.69,96.84) ; v2(149.22,89.35) 149.11,89.35 UC1.AG11 ; v2(154.71,90.65) 154.75,90.61 154.75,90.15 155.2,89.71 UC1.W12 ; v2(154.71,90.65) 154.61,90.65 UC1.Y14 ; v2(135.06,85.44) 134.99,85.44 UC1.BE5 UC1.BE4 UC1.BE3 ; v2(135.06,85.44) UC1.BD6 UC1.BC6 v2(136.76,85.44) ; v2(135.06,85.44) UC1.BE6 ; UC1.AD6 151.1,85.43 v2(151.01,85.43) 150.93,85.43 UC1.AE6 ; v2(149.28,86.13) UC1.AG6 ; UC1.AG6 148.79,85.89 UC1.AG7 UC1.AG8 ; UC1.AG6 UC1.AH6 UC1.AJ6 UC1.AJ5 UC1.AJ4 ; UC1.P6 159,85.77 v2(159.35,86.12) ; UC1.BH7 v2(132.79,86.75) ; UC1.BH7 UC1.BH6 ; UC1.N10 UC1.N11 ; UC1.AD7 UC1.AD8 ; UC1.AD8 151.48,87.07 v2(151.09,87.4) ; UH1.AH12 208.78,26.96 v2(208.78,26.61) 208.78,25.98 UH1.AL12 ; UC1.BT5 126.68,85.33 126.52,85.49 v2(126.52,85.51) ; v2(194.78,19.46) 194.65,19.59 194.65,20 194.66,20.01 194.66,20.14 UH1.BB41 ; UC1.T12 UC1.T11 UC1.T10 ; UC1.T12 157.19,89.68 v2(157.48,89.39) 157.65,89.39 UC1.R12 158.2,89.94 158.59,89.94 UC1.P12 159.07,89.9 159.55,89.9 UC1.N12 ; UC1.T12 156.86,89.85 156.28,89.85 UC1.V12 ; UC1.AJ4 UC1.AJ3 147.12,83.82 v2(146.8,83.49) 146.89,83.49 147.21,83.17 UC1.AJ2 147.28,83.13 147.28,82.56 UC1.AJ1 146.9,82.85 v2(146.81,82.85) ; UC1.AJ4 UC1.AK4 146.22,84.33 145.75,84.33 UC1.AL4 ; v2(136.76,85.44) 136.86,85.44 UC1.BB6 ; UC1.AP9 143.55,87.48 v2(143.77,87.48) ; UC1.BE6 UC1.BF6 UC1.BG6 UC1.BH6 ; UC1.BE6 135.08,86.18 UC1.BD7 UC1.BD8 v2(135.54,87.48) UC1.BD9 v2(135.54,88.12) UC1.BD10 v2(135.54,88.75) UC1.BD11 ; UC1.BB6 137.36,85.59 137.36,85.3 UC1.BB5 137.24,85.06 137.24,84.53 UC1.BB4 ; UC1.BB6 137.82,86.41 UC1.BA7 UC1.BA8 ; UC1.BB6 UC1.BA6 ; v2(131.71,85.44) 131.83,85.44 UC1.BH6 ; UC1.W3 UC1.W4 UC1.W5 154.97,85.12 UC1.V6 155.69,85.7 156.4,85.7 UC1.U6 156.46,85.86 UC1.T7 UC1.T8 UC1.T9 ; UC1.W3 154.82,83.78 154.82,83.2 UC1.W2 UC1.W1 154.78,82.03 154.5,81.75 v2(154.34,81.59) ; UC1.W3 v2(154.34,83.52) ; UC1.BA8 UC1.BA9 ; UC1.BA8 v2(138.28,87.48) ; UH1.G3 213.82,38.2 UH1.F3 ; v2(143.77,87.48) 143.36,87.08 UC1.AP8 143.74,86.64 143.74,85.91 UC1.AN6 143.84,85.72 UC1.AN5 ; v2(143.77,87.48) v2(143.77,88.12) ; UC1.AU11 141,88.77 141.01,88.73 v2(141.03,88.72) ; UC1.AU11 UC1.AU12 ; UC1.AU11 UC1.AU10 UC1.AU9 UC1.AU8 140.75,87.08 v2(141,86.82) 140.61,86.43 UC1.AU7 140.99,86 141.22,85.77 UC1.AT6 ; UC1.N12 UC1.N11 ; UC1.N12 159.91,89.68 v2(160.23,89.36) ; UC1.N11 159.89,89.03 v2(160.23,89.36) ; UC1.M14 UC1.M13 UC1.M12 160.54,89.68 v2(160.23,89.36) ; v2(144.87,81.9) 144.73,82.04 UC1.AM1 UC1.AM2 UC1.AM3 144.76,83.85 144.76,84.43 UC1.AM4 UC1.AM5 ; UC1.AD10 151.91,88.75 v2(152,88.75) 152,89.02 v2(151.99,89.39) 151.9,89.39 UC1.AD11 ; UC1.AD10 UC1.AD11 ; v2(168.49,88.41) UC1.A10 ; v2(168.49,93.13) UC1.A16 ; v2(141.94,90.65) 142.26,90.98 UC1.AR14 142.42,90.95 142.42,90.36 UC1.AR13 ; v2(134.19,81.38) 134.19,81.54 134.67,82.01 UC1.BE1 UC1.BE2 UC1.BE3 ; v2(129.55,87.01) 129.56,87.01 ; 129.56,87.01 129.56,87.06 UC1.BM8 129.65,87.63 129.65,87.94 UC1.BM9 129.89,88.26 130.17,88.54 130.17,88.69 UC1.BM11 v2(129.56,89.36) 129.56,89.43 UC1.BM12 ; UC1.A4 UC1.A3 167.34,83.77 UC1.B3 ; UC1.AD11 UC1.AD11 ; v2(143.77,88.12) 143.57,88.12 143.34,88.35 UC1.AP10 ; v2(138.28,89.39) UC1.BA11 v2(138.28,88.75) UC1.BA10 UC1.BA9 ; UC1.F31 164.21,105.4 163.89,105.4 UC1.H32 ; UC1.BE3 v2(134.17,83.5) ; v2(168.49,96.28) UC1.A20 ; v2(168.38,95.19) 168.38,95.18 UC1.A18 ; UH1.P46 192.69,33.82 v2(193.19,33.82) ; UC1.BA9 v2(138.28,88.12) ; v2(141.85,80.86) 141.47,81.24 141.47,81.61 142.21,82.35 UC1.AR1 UC1.AR2 UC1.AR3 UC1.AR4 v2(141.77,84.75) 142.03,84.97 UC1.AR5 ; PUM1.14 90.63,27.35 v2(91.03,26.95) ; UH1.AW46 192.55,21.93 192.72,22.1 192.72,22.66 192.64,22.74 UH1.AT45 192.64,23.54 v2(192.65,23.55) 192.44,23.76 UH1.AP46 ; v2(168.49,91.56) UC1.A14 ; v2(168.49,89.98) UC1.A12 ; v2(149.26,88.75) 149.17,88.75 UC1.AG10 ; UH1.BF49 UH1.BF48 UH1.BG48 190.65,17.46 v2(190.63,17.47) ; UC1.BC14 UC1.BC13 UC1.BC12 ; v2(168.49,97.86) UC1.A22 ; v2(214.88,33.74) 214.41,33.27 214.27,33.27 214.26,33.27 ; PUM1.3 v2(94.1,26.95) ; UH1.F43 194.27,38.46 UH1.E42 194.65,38.8 195.19,38.8 UH1.E40 ; 213.48,31.39 213.61,31.52 v2(214.14,31.52) ; UH1.D12 208.8,38.99 UH1.C12
  BOTTOM w0.229: UH1.BC26 201.46,19.54 v2(201.43,19.51) ; UH1.AT24 203.2,23.39 204.32,23.39 UH1.AT21 ; UH1.D17 UH1.E17 206.25,38.46 v2(205.84,38.14) UH1.E19 ; UH1.G6 UH1.H8 210.99,36.98 v2(210.7,36.31) UH1.J9 ; UH1.D16 207.01,38.66 UH1.E15 v2(208.03,38.66) ; v2(211.54,30.15) 212.09,30.7 UH1.AA5
  BOTTOM w0.25: v2(216.08,103.54) 216.42,103.88 216.43,103.88 216.88,104.33 v2(216.88,104.34) ; v2(220.94,101.77) 220.93,101.76 220.93,101.71 220.23,101.01 v2(220.23,100.94) ; v2(196.01,99.52) 195.99,99.5 195.24,99.5 v2(195.18,99.44)
  BOTTOM w0.254: UC1.D14 166.27,91.18 UC1.C13 v2(166.92,90.4) ; UC1.BN34 128.96,105.96 v2(128.91,105.9) UC1.BP34 UC1.BR34 ; UC1.H35 163.42,106.88 v2(163.35,106.88) ; UH1.J4 212.56,36.63 v2(212.64,36.71) ; UC1.BJ34 v2(131.85,106.22) UC1.BJ33 UC1.BL33 ; JWLAN1.61 301.9,7.6 v2(301.39,7.09) ; v2(140.51,109.47) UC1.AV38 v2(140.51,108.82) UC1.AV37 ; UC1.D12 UC1.C11 v2(166.92,88.82) ; UC1.C27 v2(166.27,101.42) UC1.D26 165.95,100.89 166.49,100.23 UC1.C25 ; UC1.C27 v2(166.27,102.21) UC1.D28 ; UC1.C27 v2(166.92,101.42) ; v2(135.55,89.34) 135.21,89.68 UC1.BD12 134.96,89.8 134.28,89.8 UC1.BF12 ; v2(135.55,89.34) 135.89,89.68 UC1.BC12 136.07,89.68 136.19,89.8 136.79,89.8 UC1.BB12 137.03,89.8 137.7,89.8 UC1.BA12 ; v2(135.55,89.34) 135.41,89.2 135.36,89.2 135.19,89.03 UC1.BD11 ; UH1.M16 207.03,35.04 207.66,35.67 v2(207.81,35.67) ; UH1.M16 UH1.N16 UH1.R16 ; UH1.M16 206.76,35.04 v2(206.31,35.02) UH1.M18 v2(205.04,35.45) 204.6,35 UH1.M21 ; UC1.E9 v2(165,87.23) ; v2(165,87.23) UC1.F8 UC1.G8 UC1.J7 ; v2(165,87.23) UC1.F9 164.37,87.98 ; UC1.BG12 133.08,89.68 v2(132.79,89.39) 132.63,89.39 132.34,89.68 UC1.BH12 ; UC1.AP12 142.97,89.34 142.92,89.34 v2(142.86,89.28) ; UG5.A1 v2(197.15,133.8) ; v2(164.32,99.06) UC1.G23 ; v2(164.32,99.06) UC1.G24 v2(163.62,99.84) UC1.H25 UC1.J25 ; v2(164.32,99.06) UC1.F23 v2(164.97,98.27) ; v2(213.61,38.86) 213.69,38.69 UH1.F3 ; UH1.BA12 v2(209.41,20.77) ; UH1.R29 200.37,33.51 200.06,33.82 v2(199.93,33.82) ; UC1.G28 UC1.F27 v2(164.97,101.42) ; UC1.C29 v2(166.27,103.78) UC1.D30 ; v2(212.42,90.03) 212.32,89.94 UG1.M18 ; UC1.C31 v2(166.3,105.33) UC1.D33 165.77,105.96 UC1.E34 165.26,106.52 v2(164.9,106.88) ; v2(212.5,39.92) UH1.C4 ; JEDP1.5 63.05,31.46 v2(63.13,31.54) ; UG1.G7 214.88,80.73 v2(215.2,81.05) ; UC1.AU7 140.38,86.43 v2(140.07,86.73) ; v2(307.93,38.75) JIO1.15 ; UH1.BF3 UH1.BG4 213.22,17.28 v2(213.37,17.23) 213.4,17.29 213.53,17.55 UH1.BG3 UH1.BG2 ; UH1.R12 208.94,33.81 v2(209.18,34.05) UH1.N12 v2(208.81,35.06) v2(209.03,36.02) UH1.K11 UH1.J10 UH1.J9 ; UH1.R12 v2(208.92,32.88) UH1.U12 208.98,32.36 v2(209.68,31.66) ; UH1.R12 209.3,33.45 209.38,33.37 209.84,33.37 209.84,33.38 210.43,33.38 v2(210.81,33.75) 211.14,33.43 UH1.T7 v2(211.77,32.85) UH1.T5 UH1.T4 ; v2(130.86,91.72) UC1.BK14 130.83,90.9 ; v2(130.86,91.72) UC1.BK15 ; v2(130.86,91.72) UC1.BL14 ; v2(194.11,37.58) 194.4,37.87 UH1.F41 ; v2(194.11,37.58) 193.91,37.78 UH1.F43 ; v2(194.11,37.58) 194.04,37.58 193.76,37.3 UH1.G44 ; UC1.BM21 v2(130.21,96.45) ; UC1.BM21 UC1.BM22 ; UC1.BM21 v2(129.56,96.45) UC1.BN21 v2(128.91,96.45) UC1.BP21 ; v2(130.21,96.45) UC1.BL21 UC1.BL22 ; v2(130.21,96.45) UC1.BL20 UC1.BL19 ; JWLAN1.43 304.07,12.1 v2(304.37,11.8) ; UH1.C25 202.5,39.24 UH1.E26 201.29,38.66 v2(201.1,38.85) ; UC1.BJ15 v2(131.51,91.74) UC1.BJ14 ; UC1.BC33 v2(136.57,106.22) UC1.BC34 v2(136.57,106.87) ; UH1.AL33 v2(197.87,25.26) 198.15,24.97 UH1.AN34 UH1.AR34 UH1.AT34 198.24,23.06 198.74,23.06 199.12,23.06 UH1.AT32 ; 130.83,90.9 UC1.BK13 ; 130.83,90.9 UC1.BL13 UC1.BM13 ; UC1.K8 162.54,86.97 162.54,86.61 UC1.K7 163.27,86.43 UC1.J7 ; v2(246.83,12.91) 247.15,13.23 JHDD1.9 ; UC1.Y37 v2(154.68,108.82) UC1.Y38 v2(154.68,109.47) ; UC1.AY12 139.07,89.35 139.32,89.35 UC1.AW12 139.8,89.68 v2(140.09,89.98) ; UH1.E24 v2(203.45,38.36) UH1.E22 ; UC1.AL33 v2(146.02,106.22) UC1.AL34 v2(146.02,106.87) ; UC1.BP14 v2(128.91,91.72) UC1.BN14 UC1.BM14 ; UH1.U21 204.51,32.66 UH1.V22 204.37,31.88 v2(204.44,31.81) UH1.V20 UH1.T18 UH1.T17 206.63,32.46 UH1.U17 UH1.U15 207.39,32.61 v2(207.09,32.92) ; UH1.T4 UH1.R3 ; UH1.T4 UH1.R4 UH1.P4 v2(212.64,34.62) 212.56,34.75 UH1.M5 ; UC1.BD37 v2(135.78,108.82) UC1.BD38 v2(135.78,109.47) ; UG1.AP2 192.49,76.43 v2(192.49,75.9) ; UC1.AM37 v2(145.23,108.82) UC1.AM38 v2(145.23,109.47) ; v2(202.52,23.63) 202.16,23.27 UH1.AT26 ; UH1.E8 210.49,38.25 v2(210.13,38.25) 209.51,38.25 209.5,38.26 208.69,38.26 UH1.E13 208.5,38.69 UH1.D12 ; UC1.BJ25 v2(131.51,100.38) UC1.BK25 ; UG1.AN10 192.58,83.19 192.49,83.11 192.49,83.11 v2(192.48,83.09) ; JEDP1.27 v2(74.05,31.64) ; UC1.AL14 145.9,90.98 v2(145.56,90.64) ; UC1.G4 v2(163.58,84.13) UC1.J4 ; UC1.G4 UC1.F4 ; UC1.G4 UC1.G5 ; UG1.AM25 UG1.AN25 ; v2(227.06,60.94) 226.51,60.94 PCV18.2 ; UH1.AT18 205.9,23.33 v2(206.41,23.32) 206.55,23.17 UH1.AT16 UH1.AR16 UH1.AN16 ; v2(196.59,35.16) 196.82,34.94 UH1.N37 ; v2(126.4,83.62) 126.59,83.81 UC1.BT3 ; 211.84,29.14 212.56,28.52 UH1.AE4 ; 211.84,29.14 v2(211.46,29.24) ; 211.84,29.14 211.91,29.14 212.56,29.68 UH1.AC4 ; UC1.D16 166.27,92.76 UC1.C15 v2(166.92,91.97) ; UH1.BC10 v2(210.17,19.42) UH1.BC8 UH1.BB9 ; v2(78.78,31.49) 78.78,31.29 78.55,31.06 JEDP1.36 ; UH1.E35 v2(197.09,38.73) ; UG1.T7 v2(207.72,80.25) ; UC1.A6 168.58,86.06 v2(168.71,86.19) ; v2(214.88,33.74) 215.88,34.75 v2(215.88,34.98) 216.06,35.16 216.57,35.16 216.97,35.56 220.9,35.56 221.3,35.15 v2(221.3,34.45) v2(221.3,33.18) 221.3,31.95 220.69,31.34 218.8,31.34 v2(218.47,31.67) 218.23,31.91 214.94,31.91 214.55,31.52 v2(214.14,31.52) ; UC1.B9 v2(166.94,87.23) ; v2(166.94,87.23) UC1.C8 UC1.D6 ; v2(166.94,87.23) UC1.C9 166.32,87.98 ; UG1.T2 207.42,76.45 v2(207.42,75.82) ; v2(130.98,102.79) UC1.BL29 v2(130.23,102.74) ; v2(130.98,102.79) UC1.BK29 131.35,103.57 UC1.BJ30 ; v2(130.98,102.79) 131.54,102.79 UC1.BJ29 ; v2(196.17,27.8) UH1.AE38 ; v2(192.29,25.87) 192.44,26.02 UH1.AK46 ; UC1.AF14 UC1.AG13 v2(148.33,90) UC1.AH12 ; v2(192.32,28) 192.44,28.12 UH1.AE46 UH1.AC46 ; v2(130.23,102.74) UC1.BM28 UC1.BM27 ; v2(130.23,102.74) UC1.BM29 UC1.BN29 UC1.BP29 UC1.BR29 UC1.BT29 126.64,103.14 v2(126.55,103.05) ; UC1.BM26 v2(130.21,100.38) UC1.BM25 ; UC1.K11 v2(162.84,88.73) ; v2(162.84,88.73) UC1.H11 ; v2(162.84,88.73) UC1.J10 ; v2(216.88,104.34) 217.33,103.89 217.33,103.89 217.34,103.88 217.34,103.5 217.33,103.49 v2(217.33,102.99) ; UH1.E10 209.83,38.81 v2(210.23,38.81) UH1.D8 ; UC1.BL38 v2(130.4,109.6) UC1.BM38 ; v2(235.43,27.1) 235.47,27.14 PU1001.18 ; UC1.T10 v2(157.49,88.75) UC1.T11 ; UC1.T10 v2(156.53,88.05) UC1.T9 ; UC1.T10 v2(157.49,88.12) ; UC1.AF12 v2(150.17,89.89) UC1.AF13 ; v2(209.32,76.94) 209.43,76.94 UG1.N2 ; UC1.AD12 151.71,89.68 v2(151.99,89.39) 152.28,89.68 UC1.AC12 152.61,89.83 153.21,89.83 UC1.AA12 153.58,89.9 153.85,89.9 UC1.Y13 ; UC1.K9 v2(162.03,88.06) UC1.K10 ; v2(157.83,106.87) UC1.T34 v2(157.83,106.22) UC1.T33 ; UC1.F17 v2(164.97,93.55) ; v2(137.5,132.48) 137.49,132.49 PUZ4.6 ; v2(304.12,9.8) 304.12,10.06 303.57,10.6 JWLAN1.49 ; v2(126.48,108.06) 126.7,107.83 UC1.BT36 UC1.BR36 ; UC1.W12 v2(155.67,89.37) UC1.V12 ; UH1.BC13 v2(207.94,19.41) UH1.BC15 ; v2(160.42,130.33) 160.35,130.39 PUA1.6 ; UC1.W33 v2(155.47,106.22) UC1.W34 v2(155.47,106.87) ; v2(72.77,31.74) 72.55,31.52 JEDP1.24 ; v2(217.42,125) UG4.F5 ; UG4.F5 v2(216.6,125.8) UG4.G5 v2(217.42,125.8) UG4.F5 ; UH1.Y12 209.02,30.99 v2(209.02,30.29) ; UH1.R34 UH1.N34 UH1.N35 ; UC1.J4 v2(162.74,84.13) ; UC1.J4 UC1.K5 ; v2(126.55,105.44) UC1.BT32 ; UC1.P37 v2(159.4,108.82) UC1.P38 ; UC1.F25 v2(164.97,99.84) ; v2(207.27,21.01) UH1.BA14 ; UC1.AD7 151.77,86.43 151.96,86.24 v2(151.96,86.17) 151.96,86.15 152.27,85.84 UC1.AC6 ; UC1.BJ22 v2(131.53,98.02) UC1.BK22 ; UH1.AR12 208.8,23.51 208.8,22.99 v2(208.84,22.95) UH1.AV11 UH1.AW10 ; UC1.F36 164.59,107.84 v2(164.9,107.53) 165.24,107.19 UC1.E35 ; UC1.BL35 130.43,106.96 130.01,106.96 UC1.BM35 ; UC1.BL35 v2(131.06,107.52) ; UC1.BL35 v2(131.06,106.87) ; UC1.F4 UC1.F5 UC1.G6 UC1.J7 ; UC1.F4 UC1.E4 UC1.D3 166.5,83.82 v2(166.64,84.02) ; UC1.F4 UC1.F3 UC1.F2 ; UG1.AH16 197,87.91 v2(196.77,87.91) ; v2(147.53,110.61) 147.53,110.87 147.73,111.07 147.73,111.91 148.01,112.19 RC13.2 ; DU2.8 16.07,52.13 v2(16.08,52.15) ; v2(146.52,88.78) 146.51,88.77 ; 146.51,88.77 v2(146.51,88.12) ; 146.51,88.77 146.44,88.77 UC1.AL10 ; UC1.K4 v2(162.74,84.13) ; v2(162.74,84.13) UC1.K3 162.39,83.76 162.39,83.23 UC1.K2 v2(162.74,82.82) UC1.K1 ; UC1.L34 v2(161.77,106.22) UC1.L33 ; v2(131.06,107.52) UC1.BJ36 ; v2(131.06,107.52) UC1.BJ35 ; v2(190.63,17.47) 190.48,17.7 190.51,17.84 190.55,18.05 UH1.BF49 ; v2(166.92,98.27) UC1.C23 UC1.D24 ; v2(216.98,80.27) 216.58,80.67 UG1.E7 ; UC1.J22 UC1.H22 163.38,97.79 163.94,97.79 UC1.G22 v2(164.32,97.48) UC1.F21 v2(164.97,96.7) ; UC1.K38 v2(162.55,109.47) ; v2(214.42,79.35) UG1.G5 v2(215.26,78.51) ; v2(194.9,21.96) 195.06,22.12 UH1.AV39 UH1.AW40 ; UC1.AJ38 v2(146.81,109.47) ; DU2.3 13.23,52.13 v2(12.86,52.5) ; UH1.BC24 203.11,19.5 203.52,19.47 v2(203.68,19.46) ; UC1.BN19 v2(129.56,95.66) UC1.BN20 ; UC1.BJ18 131.79,94.47 v2(131.51,94.14) 131.24,94.47 UC1.BK18 131.14,94.47 v2(130.86,94.14) 130.59,94.47 UC1.BL18 130.49,94.47 v2(130.21,94.14) 129.94,94.47 UC1.BM18 129.84,94.47 v2(129.56,94.14) 129.29,94.47 UC1.BN18 129.19,94.47 v2(128.91,94.14) 128.64,94.47 UC1.BP18 128.54,94.47 v2(128.26,94.14) 127.99,94.47 UC1.BR18 127.89,94.47 v2(127.61,94.14) 127.33,94.47 UC1.BT18 ; UG1.AB2 202.33,75.97 v2(202.42,75.87) ; UH1.AN38 v2(196.06,24.15) UH1.AR38 ; v2(126.78,89.97) 126.99,89.75 UC1.BT12 UC1.BR12 UC1.BP12 UC1.BN12 ; v2(193.19,32.81) 193.19,32.63 UH1.V46 192.3,32.01 192.3,32.49 191.97,32.82 190.84,32.82 UH1.T49 ; v2(127.61,99.6) UC1.BR24 UC1.BP24 v2(128.91,99.6) ; v2(127.61,99.6) UC1.BR25 UC1.BP25 v2(128.91,99.6) ; v2(127.61,99.6) UC1.BT24 ; v2(157.04,109.47) UC1.U38 v2(157.04,108.82) UC1.U37 ; UH1.BG2 213.96,17.04 v2(214,17.01) ; UH1.BG2 UH1.BF2 UH1.BF1 ; v2(204.98,23.27) 204.58,23.27 UH1.AT21 ; UC1.BA37 v2(138.14,108.82) UC1.BA38 v2(138.14,109.47) ; CG197.1 234.94,39.84 v2(235.19,39.6) QG17.4 ; v2(211.87,38.89) UH1.C5 ; v2(166.92,96.7) UC1.C21 166.27,97.48 UC1.D22 ; v2(129.56,98.81) UC1.BM24 v2(130.21,98.81) ; v2(129.56,98.81) UC1.BM23 ; v2(129.56,98.81) UC1.BN24 v2(128.91,99.6) ; UH1.N38 196.04,34.56 v2(196.04,35.14) 195.42,35.75 UH1.K39 195.24,36.26 UH1.J40 ; v2(129.55,105.86) 129.85,105.5 UC1.BM33 ; UC1.F11 164.64,89.19 v2(164.36,88.82) 164.01,88.44 UC1.G10 164.37,87.98 ; v2(196.08,25.26) UH1.AL38 UH1.AL37 ; UH1.M24 202.85,34.7 v2(202.46,34.7) ; UC1.AB33 v2(153.11,106.22) UC1.AB34 v2(153.11,106.87) ; v2(126.6,100.56) 126.82,100.78 UC1.BT26 UC1.BR26 UC1.BP26 ; JIO1.12 308.24,40.25 v2(308.02,40.02) ; UC1.A28 v2(168.35,102.82) 168.56,103.02 168.56,103.72 UC1.A30 ; JWLAN1.18 311.31,20.35 v2(311.63,20.02) ; v2(160.19,106.87) UC1.N34 v2(160.19,106.22) UC1.N33 ; 164.37,87.98 UC1.G9 ; UC1.J33 v2(163.38,105.57) UC1.J32 v2(163.38,104.88) UC1.H32 ; UC1.A26 v2(167.58,101.41) ; UG1.AE2 199.73,76.44 199.73,75.88 v2(199.86,75.75) ; JHDD1.12 245.65,15.21 245.43,14.99 v2(244.68,14.99) ; PCV7.2 221.56,46.45 218.95,46.45 217.54,47.86 210.74,47.86 210.26,48.34 201.61,48.34 200.92,49.03 195.99,49.03 194.32,50.69 194.32,55.87 v2(194.91,56.46) ; v2(205.59,20.32) 205.59,19.85 UH1.BC19 ; UC1.AU33 v2(141.29,106.22) UC1.AU34 v2(141.29,106.87) ; UC1.H12 UC1.G12 UC1.F13 v2(164.32,91.18) UC1.G14 v2(164.32,91.97) UC1.F15 v2(164.97,91.97) ; UH1.AW4 212.69,21.83 212.75,21.44 v2(212.73,21.42) 212.77,21.29 212.57,20.96 UH1.BA5 211.84,20.9 UH1.BA6 ; UC1.BR14 v2(127.61,91.72) UC1.BT14 ; v2(194.78,19.46) 195.07,19.5 UH1.BC40 ; UC1.AE33 v2(150.74,106.22) UC1.AE34 v2(150.74,106.87) ; UC1.BJ12 131.88,89.4 131.88,89.37 v2(131.88,89.34) ; v2(194.88,32.08) 195.26,31.7 195.52,31.7 UH1.Y38 196.17,31.04 UH1.AC38 ; v2(61,31.43) 61.05,31.38 JEDP1.1 ; JEDP1.2 61.55,31.38 v2(61.61,31.43) ; v2(201.89,81.06) 202.13,80.83 202.31,80.64 UG1.AB7 ; v2(145.12,132.48) 145.11,132.49 PUZ3.6 ; v2(215.46,75.12) 215.26,75.33 215.26,76.14 ; UC1.BF33 v2(134.21,106.22) UC1.BF34 v2(134.21,106.87) ; UH1.P29 v2(199.93,34.53) UH1.M32 v2(198.78,35.48) ; US2.14 22.05,80.44 22.41,80.08 v2(22.99,80.08) ; UH1.AM49 v2(190.12,25.23) ; PUZ5.6 130.12,132.49 v2(130.13,132.48) ; UG6.K14 v2(242.64,68.47) ; UC1.J36 v2(163.34,108.17) ; UC1.BJ31 v2(131.06,104.92) 131.21,105.04 UC1.BJ32 ; v2(204,34.44) 204,34.44 204,33.59 203.1,32.69 UH1.U24 ; UC1.AY33 v2(138.93,106.22) UC1.AY34 v2(138.93,106.87) ; v2(209.23,24.28) 209.23,24.29 209.23,24.29 208.94,24.58 UH1.AN12 ; JWLAN1.7 304.69,23.1 v2(304.91,23.31) ; v2(196.1,26.35) UH1.AH38 ; UC1.BR9 128.26,88.5 v2(128.26,88.57) ; UC1.L30 v2(161.77,103.57) UC1.L29 ; UC1.BR38 v2(127.51,109.57) ; v2(307.1,35.77) 307.41,35.47 307.95,35.47 308.22,35.75 JIO1.21 ; UC1.BG37 v2(133.42,108.82) UC1.BG38 v2(133.42,109.47) ; UH1.D33 198.69,38.47 UH1.E33 198.94,38.45 v2(199.24,38.44) UH1.E31 199.96,38.68 UH1.D30 UH1.C30 ; v2(192.88,21.67) 193.37,20.9 UH1.BA44 ; UH1.M34 198.08,35.04 UH1.N35 ; UC1.BP33 UC1.BN31 v2(128.92,104.32) UC1.BN30 ; UG1.AK7 195.59,80.69 v2(196.02,80.26) 196.43,80.67 UG1.AJ7 ; v2(304.12,9.22) 304,9.1 JWLAN1.55 ; 166.32,87.98 UC1.D10 ; 166.32,87.98 UC1.D9 ; v2(195.76,33.93) 196.06,33.63 UH1.R38 196.06,32.89 v2(196.08,32.87) UH1.U38 ; UC1.AY14 138.27,90.51 138.27,90.14 138.26,90.14 138.26,89.41 v2(138.28,89.39) ; UC1.J18 162.73,94.64 163.24,94.64 UC1.H18 163.38,94.64 163.94,94.64 UC1.G18 v2(164.32,95.12) UC1.F19 v2(164.32,95.91) UC1.G20 ; v2(212.12,26.1) 212.12,26.1 212.12,26.1 212.54,26.33 UH1.AK4 ; UC1.AL12 UC1.AM12 145.02,89.8 144.34,89.8 UC1.AN12 144.05,89.68 v2(143.77,89.39) ; v2(152.74,132.48) 152.73,132.49 PUZ2.6 ; JWLAN1.37 304.41,13.6 v2(304.91,14.09) ; UG1.AN19 UG1.AM19 ; v2(126.53,107.01) UC1.BT35 ; UG4.A3 215.4,121.39 v2(215.8,121) ; UC1.BG13 v2(132.8,90.66) ; v2(132.8,90.66) UC1.BH14 ; v2(132.8,90.66) UC1.BG14 ; UC1.AJ13 v2(147.41,90) ; UC1.G16 v2(164.32,92.76) ; UC1.C5 v2(166.96,85.66) ; UG1.AH2 197.33,76.56 v2(196.95,76.94) ; v2(166.27,95.12) UC1.C19 165.97,96.28 UC1.D20 ; UH1.T32 199,32.87 198.86,32.92 198.5,32.74 UH1.U33 198.21,32.15 198.22,32.09 v2(198.29,31.65) 198.29,31.3 UH1.Y33 ; UH1.J26 v2(202.42,36.45) ; v2(166.92,93.55) UC1.C17 166.27,94.33 166.24,94.37 UC1.D18 ; v2(196.99,19.38) 197.37,19.38 UH1.BC35 ; v2(199.98,24.01) 200.39,23.6 200.49,23.5 UH1.AT29 ; UC1.C2 166.68,83.98 v2(166.64,84.02) ; v2(166.64,84.02) 166.84,83.86 UC1.B3 ; v2(214.48,97.84) UG1.G28 v2(215.31,98.67) 215.73,98.24 UG1.F28 ; JIO1.24 v2(307.89,34.25) ; UH1.N35 197.25,34.21 v2(197.25,33.85) ; UC1.AC37 v2(152.32,108.82) UC1.AC38 v2(152.32,109.47) ; v2(163.7,101.4) UC1.G26 ; UG7.N12 238.64,101.69 v2(238.24,102.09) ; UH1.R26 201.92,33.52 202.45,34.05 v2(202.45,34.1) ; JEDP1.30 75.55,31.12 v2(75.02,31.65) ; JIO1.18 308.07,37.25 v2(307.96,37.36) ; v2(199.28,19.32) 199.68,19.45 UH1.BC31 ; UH1.AP4 v2(212.08,24.21) ; JEDP1.33 v2(77.05,31.68) ; RC16.2 159.31,112.32 159.03,112.04 159.03,111 159.41,110.63 v2(159.51,110.63) ; JHDD1.6 248.65,15.37 247.75,14.47 v2(247.75,12.94) ; UH1.AE12 v2(208.83,29.03) ; v2(208.47,30.34) 208.47,30.04 UH1.AC12 ; UC1.AH33 v2(148.38,106.22) UC1.AH34 v2(148.38,106.87) UC1.AH35 v2(148.38,107.52) UC1.AH36 v2(147.59,108.17) UC1.AJ37 ; JIO1.9 v2(309.58,41.75) ; UG1.F7 v2(216.16,80.27) ; v2(212.75,76.96) UG1.K2
  BOTTOM w0.3: v2(211.91,103.54) 212.39,103.06 212.39,102.54 212.33,102.49 UG1.K33
  BOTTOM w0.305: JSSD1.21 30.85,8.26 v2(30.93,8.18) ; v2(217.42,124.2) 217.59,124.2 218.04,123.75 218.04,122.89 217.34,122.19 UG4.B5 ; v2(245.04,92.29) 245.04,92.89 UG7.E1 v2(245.44,93.29) ; v2(36.17,10.34) 35.85,10.01 JSSD1.1 ; JSSD1.9 v2(33.85,8.2) ; UG4.H14 224.19,127 v2(223.8,126.6) 223.4,126.99 UG4.H13 v2(223,127.4) ; UH1.J29 199.97,36.52 v2(199.6,36.89) ; UH1.P26 201.92,34.35 202.27,34.7 v2(202.46,34.7) ; JSSD1.15 v2(32.35,8.2) ; v2(247.84,96.49) UG7.B5 ; UG7.B5 247.04,95.69 v2(247.04,95.69) UG7.C4 246.24,94.89 v2(246.24,94.89) UG7.C3 247.04,94.09 v2(247.04,94.09) ; UG7.B5 v2(247.84,95.69) ; UG7.N3 238.64,94.49 v2(239.04,94.09) ; v2(215,127.4) UG4.H2 v2(214.2,126.6) UG4.H1 213.29,127 v2(213.2,126.9) ; v2(248.24,103.89) UG7.A14 ; v2(248.24,103.89) v2(249.04,103.89) ; v2(248.24,103.89) v2(248.24,104.49) ; v2(248.24,92.29) UG7.A1 ; v2(248.24,92.29) v2(249.04,92.29) ; v2(248.24,92.29) v2(248.24,91.69) ; JSSD1.39 26.35,8.34 v2(26.2,8.19) ; v2(35.54,10.39) 35.35,10.2 JSSD1.3 ; UC1.BT8 127.21,87.08 v2(126.81,87.08) ; UG1.AK10 195.2,83.57 v2(195.18,83.57) ; UG1.AE7 199.83,80.18 v2(199.96,80.05) 199.74,79.83 199.74,79.03 UG1.AE5 ; v2(241.44,102.09) UG7.K13 v2(240.64,102.89) UG7.K14 ; v2(301.72,5.21) 301.72,5.72 302.09,6.1 JWLAN1.67 ; UG5.K14 187.15,127 v2(187.55,126.6) 187.95,127 UG5.K13 v2(188.35,127.4) ; v2(210.03,79.63) 209.83,79.42 UG1.N5 ; v2(27.89,8.22) 27.85,8.26 JSSD1.33 ; v2(244.64,100.49) UG7.F10 v2(243.84,99.69) UG7.G10 v2(243.84,100.49) ; UG4.L10 v2(220.6,129.8) 220.99,130.2 UG4.M10 v2(221.4,130.6) ; UG4.K14 v2(224.8,128.6) v2(225.4,128.6) ; v2(247.84,99.69) UG7.B10 v2(247.04,100.49) UG7.C11 ; v2(235.84,93.29) UG7.U1 235.44,92.88 v2(235.44,92.29) ; v2(195.22,76.93) UG1.AL2 ; UG1.K7 212.72,80.25 v2(212.72,79.34) ; v2(29.26,8.2) 29.27,8.2 29.35,8.27 JSSD1.27 ; v2(219.38,93.62) 218.98,93.21 UG1.B22 ; UG1.AN7 192.86,80.69 v2(192.65,80.48) ; v2(212.42,89.4) 212.42,89.35 212.01,88.94 UG1.M17 ; UG4.K13 223.39,128.6 v2(223,128.2) ; v2(241.44,94.09) UG7.K2 v2(240.64,93.29) 241.04,92.89 UG7.K1 241.04,92.39 v2(240.94,92.29) ; RC391.2 218.64,26.31 v2(218.9,26.57) ; v2(235.82,96.51) 236.24,96.09 UG7.T5 236.24,96.09 v2(236.64,96.49) ; JWLAN1.1 303.75,24.6 v2(303.97,24.38) ; v2(192.49,75.9) 192.68,75.72 193.16,75.72 UG1.AN1 ; v2(242.54,91.69) v2(242.54,92.29) 242.64,92.39 UG7.H1 242.64,92.89 v2(242.24,93.29) UG7.H2 ; UG1.AN4 192.87,78.19 v2(192.62,78.44) ; v2(202.8,78.56) 202.42,78.94 UG1.AB5 ; v2(246.64,92.29) UG7.C1 v2(247.04,93.29) ; UG4.G10 v2(221.4,125.8) 221,125.4 UG4.F10 v2(221.4,125) ; UG1.AH13 196.96,85.37 v2(196.56,85.37) ; v2(248.64,94.89) UG7.A3 v2(247.84,94.09) ; UG7.U3 v2(235.04,94.09) ; v2(237.44,100.49) 237.04,100.89 UG7.R11 237.04,100.89 v2(236.64,101.29) ; JSSD1.57 v2(21.85,8.2) ; v2(186.57,128.6) 186.57,128.6 UG5.H14 ; JPWR1.8 13.14,127.44 ; RH153.1 200.18,13.94 199.78,13.54 v2(199.47,13.54) ; v2(175.37,129.23) 175.1,129.5 PRZ24.2 ; v2(23.26,8.23) 23.35,8.32 JSSD1.51 ; UG1.AH5 196.88,79.39 196.88,80.24 UG1.AH7 v2(196.86,81.07) 196.81,81.07 UG1.AJ7 ; v2(189.95,130.6) 189.95,130.6 UG5.F10 v2(190.75,129.8) UG5.G10 ; UG7.L5 240.24,96.09 239.91,96.42 v2(239.84,96.49) UG7.M5 239.44,96.09 v2(239.04,96.49) ; UG1.T17 207.58,88.92 v2(208.05,88.45) ; v2(212.6,128.7) v2(213.2,128.7) 213.3,128.6 UG4.K1 UG4.K2 ; v2(301.48,14.37) 301.48,14.65 301.92,15.1 JWLAN1.31 ; v2(239.04,100.49) UG7.M10 v2(239.84,100.49) 240.24,100.09 UG7.L10 ; RH200.2 195.13,13.99 v2(194.89,13.75) 194.51,14.13 RH11.2 ; v2(238.63,91.69) v2(238.63,92.29) 238.64,92.3 238.64,92.88 UG7.N1 ; v2(304.3,16.96) 303.93,16.6 JWLAN1.25 ; UG5.H13 v2(188.35,128.2) ; v2(189.95,125) 190.35,125.4 UG5.M10 v2(189.95,125.8) 190.35,126.2 UG5.L10 ; UC1.D38 165.82,109.54 v2(165.38,109.99) 165.02,109.63 UC1.E38 ; UG7.E14 v2(244.64,102.89) ; UG7.H13 v2(242.24,102.09) ; v2(216.6,130.6) UG4.M5 v2(217.4,129.8) UG4.L5 ; UG1.K5 v2(212.73,78.54) ; v2(194.4,78.66) UG1.AL5 ; v2(189.15,122.6) 189.55,122.99 UG5.R11 189.55,123 v2(189.95,123.4) ; JSSD1.45 24.85,8.27 v2(24.9,8.22) ; v2(242.64,104.49) v2(242.64,103.89) UG7.H14
  BOTTOM w0.33: v2(194.75,130.6) UG5.F5 194.35,130.2 v2(193.95,129.8) UG5.G5 ; v2(198.75,126.9) v2(198.15,126.9) 198.05,127 UG5.K1 197.55,127 v2(197.15,126.6) 196.75,126.99 UG5.K2 v2(196.35,127.4) ; v2(193.95,125) 194.35,125.4 UG5.M5 v2(193.95,125.8) 194.35,126.2 UG5.L5 ; v2(198.75,128.58) v2(198.15,128.58) 197.57,128.58 UG5.H1 197.55,128.6 v2(197.15,128.2) UG5.H2
  BOTTOM w0.356: UG1.R21 v2(208.07,92.66) UG1.T20 ; UG1.P22 209.82,94.15 v2(210,94.31) 210.54,94.89 UG1.N23 ; UG1.Y21 v2(204.08,92.44) UG1.W20 ; v2(221.4,123.4) 221.8,123 UG4.C11 v2(222.2,122.6) ; UG6.L10 243.78,72.62 243.78,72.73 ; CL12.2 v2(59.59,23.56) ; UG1.AN16 UG1.AM16 193.98,88.26 v2(194.37,88.65) UG1.AL17 UG1.AL18 ; v2(216.98,96.12) UG1.E25 v2(216.06,95.87) ; UG7.G5 v2(243.84,96.49) UG7.F5 244.64,95.69 v2(244.64,95.69) ; CA31.1 295.08,23.26 v2(295.02,23.2) ; v2(196.84,95.34) 197.16,94.98 UG1.AH24 ; v2(293.05,21.23) 292.54,21.74 CA30.1 ; UG1.M15 v2(212.13,87.25) ; v2(196.86,92.65) 196.86,92.77 UG1.AH22 ; CG2818.2 v2(234.37,56.23) ; UG1.U23 v2(206.08,94.44) UG1.V23 ; v2(244.64,71.87) 244.24,72.27 UG6.M10 243.78,72.73 ; PCW14.2 PCW13.2 243.67,49.34 PCW12.2 243.66,49.04 243.43,48.8 242.65,48.8 v2(242.54,48.92) ; v2(191.98,100.27) 192.03,100.31 192.74,100.31 v2(192.78,100.27) ; v2(25.72,47.74) RT845.2 RT846.2 ; CL13.2 55.75,16.03 v2(56.27,16.03) ; UG1.G25 v2(214.52,95.28) ; v2(210.22,80.19) 210.22,80.25 UG1.N7 ; v2(241.44,70.27) UG6.H13 v2(240.64,69.47) 241.04,69.08 UG6.H14 ; UG1.AC22 200.68,93.84 v2(201.05,93.48) UG1.AB21 ; UG1.AB23 v2(202.06,94.52) UG1.AA22 ; v2(234.84,80.07) 234.84,80.08 v2(234.84,80.67) ; RT817.2 RT818.2 RT857.2 27.18,48.55 RT858.2 27.18,49.21 v2(27.28,49.31) ; UG1.N16 v2(210.98,87.54) ; v2(196.87,83.6) 197.09,83.38 UG1.AH10 ; v2(248.24,80.67) v2(248.24,80.07) ; v2(248.24,80.07) v2(249.04,80.07) ; v2(248.24,80.07) UG6.U1 ; v2(120.99,108.38) 120.55,108.38 CC406.2 ; v2(201.02,87.39) UG1.AC15 ; UG1.AL15 UG1.AL14 194.5,86.22 194.43,86.21 194.39,86.17 v2(194.36,86.17) 194.36,86.07 194.33,86.04 UG1.AM13 ; UG1.AM13 193.98,85.65 194.38,85.25 v2(194.38,85.2) 194.43,85.2 194.78,84.85 UG1.AL12 ; UG1.AM13 UG1.AN13 ; CR17.2 v2(40.21,21.84) ; UG1.AC17 200.84,89.22 v2(201.12,89.54) 200.84,89.75 UG1.AC18 ; UG1.W17 204.08,89.44 UG1.W18 ; UG1.T5 v2(207.8,78.55) ; UG1.AN22 UG1.AM22 v2(194.34,93.6) 194.35,93.61 UG1.AL23 194.63,94.19 194.63,94.69 UG1.AL24 194.78,94.89 UG1.AM25 ; UG1.AL21 UG1.AL20 v2(194.38,91.16) UG1.AM19 ; v2(54.65,24.36) 54.83,24.36 55.07,24.12 CL26.2 ; UG1.W22 v2(204.08,94.44) UG1.Y23 ; v2(197.72,83.6) 197.52,83.8 UG1.AH11 ; v2(59.52,21.71) CL9.2 ; v2(242.64,80.07) UG6.K1 v2(243.04,79.07) UG6.K2 ; UG1.AH19 v2(196.88,91.09) ; CH16.2 192.05,14.12 191.62,13.69 v2(189.67,13.69) ; CL11.2 v2(52.67,22.03) ; v2(195.16,96.16) UG1.AL26 ; 243.78,72.73 v2(243.78,72.76) ; v2(209.14,87.33) UG1.R16 ; CL16.2 v2(53.89,17)
  BOTTOM w0.381: UL2.2 56.31,13.8 v2(56,13.49) ; CG103.2 242.89,81.28 242.64,81.03 v2(242.64,80.67) ; v2(33.36,60.26) 33.62,60 RV18.2 ; v2(15.32,79.78) 15.32,79.78 RS41.1 ; v2(201.02,87.39) 201.57,87.94 UG1.AB16 ; v2(216.55,34.71) 217.02,34.71 CH4.2 ; v2(15.6,89.37) 15.94,89.03 DS6.3 ; RL11.1 v2(49.92,22.38) ; CV17.2 71.79,23.25 v2(71.79,22.43) 71.88,22.33 RV5.2 ; CG107.2 246.74,67.78 v2(246.64,67.87) ; UG1.U14 206.25,86.27 v2(206.04,86.27) 205.91,86.27 UG1.V14 ; v2(14.28,115.09) DV1.3 v2(16.83,115.09) ; RG133.1 228.7,63.85 229.17,64.32 v2(229.17,64.45) ; v2(195.55,121) 195.95,121.39 UG5.U3 ; CG145.2 185.17,134.2 v2(185.95,134.2) ; CG163.2 226.3,129.4 v2(225.4,129.4) v2(225.4,128.6) 225.98,128.6 226.09,128.7 CG89.2 RG52.2 ; v2(242.64,68.47) 242.97,68.15 v2(242.97,67.88) 243.18,67.66 CG123.2 RG66.2 ; PCH14.2 180.56,106.66 v2(180.76,106.86) ; PRW11.2 244,58.74 v2(244.06,58.79) ; CG69.2 185.16,131 v2(185.95,131) v2(186.55,131) 186.55,131 UG5.E14 v2(187.55,131.4) ; v2(245.04,68.47) v2(245.04,67.87) 245.12,67.79 CG93.2 ; CG165.2 226.3,123 v2(225.4,123) ; PC310.2 253.23,26.63 v2(253.6,27) ; RA23.1 297.77,21.36 297.64,21.23 v2(296.98,21.23) ; v2(184.02,130.82) 184.02,131.56 QG3.3 ; UG2.3 233.64,53.33 233.94,53.63 v2(234.25,53.63) ; v2(193.95,121.8) 194.35,122.19 UG5.T5 v2(193.95,122.6) ; UG1.R12 208.11,84.41 208.1,84.41 208.1,84.42 v2(208.08,84.44) UG1.T13 ; CG146.2 184.94,123 v2(185.95,123) ; CG186.2 238.64,90.68 238.64,91.67 v2(238.63,91.69) ; UG5.R4 v2(195.55,122.6) 195.95,122.99 UG5.R3 v2(196.35,122.6) ; UG1.W28 204.81,98.24 v2(204.39,97.82) ; PRM9.2 96.26,25.47 v2(96.39,25.6) ; CL19.2 v2(49.87,23.22) ; v2(188.75,72.52) 188.85,72.62 190.38,72.62 RG406.1 ; CG179.2 241.5,67.28 241.65,67.42 v2(241.65,67.85) ; CG71.2 210.27,114.64 v2(209.47,114.64) ; UG5.N3 v2(196.35,124.2) ; UG1.AG11 198.08,83.95 v2(197.72,83.6) ; v2(239.03,59.53) 239.34,59.84 UG29.3 ; v2(242.54,48.92) 242.51,48.95 PCW3.2 ; v2(199.41,100.34) 199.81,99.94 UG1.AE30 ; v2(220.25,102.71) 220.15,102.71 UG1.A33 ; UG1.P15 v2(209.14,87.33) ; v2(213.2,124.6) v2(212.6,124.6) 212.23,124.6 212.03,124.8 CG68.2 ; v2(246.64,80.67) 246.46,80.86 CG120.2 ; v2(240.94,91.69) 240.94,90.69 CG188.2 ; CG164.2 226.31,131 v2(225.4,131) v2(224.8,131) ; v2(184.02,129.3) 183.88,129.15 RG56.2 ; CG74.2 225.99,134.37 225.82,134.2 v2(225.4,134.2) ; CG167.2 v2(227.07,135.67) ; CH109.2 219.1,37.86 CH20.2 CH101.2 217.74,37.85 v2(217.58,37.69) ; v2(211.08,85.44) UG1.N14 ; UG1.AA15 v2(203.08,87.44) UG1.Y16 ; CG80.2 200.27,123.19 199.22,123.19 199.03,123 v2(198.75,123) ; v2(245.04,104.49) 245.04,105.62 CG119.2 ; CL27.2 v2(49.89,21.49) ; UG1.W13 v2(204.08,84.44) UG1.Y12 v2(203.19,83.55) ; PRV21.2 226.09,51.24 v2(226.28,51.05) ; CV18.2 72.14,25.01 v2(72.4,25.01) ; UG28.3 236.27,62.05 v2(236.59,62.37) ; v2(235.44,91.69) 235.44,90.72 CG95.2 ; CH107.2 64.13,21.67 v2(64.6,21.67) ; v2(216.63,114.51) 216.14,115.01 CG172.2 ; CG160.2 211.88,131 v2(212.6,131) ; PQW3.3 235.97,52.9 v2(235.97,52.62) ; v2(37.88,8.64) 37.78,8.55 JSSD1.68 ; v2(55.38,13.61) 55.75,13.97 CL14.2 CL15.2 ; UG1.M20 v2(211.15,91.55) UG1.N19 ; UG1.N21 v2(211.05,93.53) UG1.M22 ; CG191.2 188.81,116.99 v2(189.35,116.99) ; JTP1.5 88.2,12.88 88.06,12.74 v2(88.06,12.22) ; v2(236.97,46.75) 236.97,46.47 UG10.3 ; CG105.2 245.11,91.61 v2(245.04,91.69) ; v2(225.4,126.76) 225.44,126.72 225.66,126.72 225.91,126.47 CG60.2 ; UG11.3 184.14,76.16 v2(184.66,76.68) ; v2(53.07,23.7) 52.93,23.56 CL5.2 ; v2(235.44,68.47) 235.44,67.61 235.49,67.56 CG102.2 235.49,66.24 CG92.2 ; v2(241.3,24.2) 241.69,24.59 PR1005.2 241.69,25.66 PC1001.2 ; D506.1 v2(66.31,28.08) ; UG5.B10 v2(190.75,133.8) ; v2(14.5,111.14) 14.61,111.02 DV2.3 16.51,111.02 v2(16.72,111.22) ; v2(217.09,37.96) 217.09,38.17 CH17.2 ; v2(96.03,28.52) 95.98,28.47 PCM6.2 ; CG193.2 229.54,71.05 v2(228.87,71.72) ; UG1.T22 v2(208.08,94.44) UG1.R23 ; CG104.2 248.24,90.88 v2(248.24,91.69) ; CG36.2 231.26,89.62 v2(231.26,89.09) ; v2(229.23,93.54) 229.36,93.42 CG223.2 ; CS109.2 19.92,85.48 v2(19.69,85.25) ; v2(188.78,79.19) 188.24,79.19 RG381.1 ; QG7.4 231.01,40.16 v2(231.1,40.25) ; v2(238.64,67.87) 238.64,66.95 CG99.2 ; RG71.2 234.37,100.42 234.37,100.61 v2(235.04,101.29) ; UG1.AA13 v2(202.08,84.44) UG1.AB12 ; v2(221.81,54.92) 222.14,55.24 PCV17.2 ; CH21.2 217.31,40.31 216.72,39.71 v2(215.75,39.71) ; CG91.2 242.98,104.82 v2(242.64,104.49) 242.24,104.89 CG122.2 ; v2(237.24,31.56) 237.43,31.37 PC1012.2 ; UG1.AA17 v2(201.9,89.49) UG1.AA18 ; v2(53.68,14.73) 53.73,14.68 CL10.2 ; v2(238.08,54.29) 238.35,54.01 PCW5.2 ; v2(218.7,39.55) 218.7,39.88 CH105.2 ; v2(302.01,32.48) 302.51,32.48 RA22.1 ; CG58.2 211.67,123 v2(212.6,123) ; v2(249.04,80.67) 249.04,82.03 CG150.2 ; CH5.2 v2(216.68,32.42) ; v2(238.64,80.67) 238.52,80.79 CG185.2 238.52,82.21 CG159.2 ; v2(201.71,129.64) 201.26,130.1 CG139.2 ; CG168.2 199.57,126.9 v2(198.75,126.9) ; RG16.2 237.88,60.19 v2(238.42,60.19) ; v2(190.63,17.47) 189.85,16.69 189.85,15.43 189.67,15.25 CH25.2 ; v2(198.75,131) 199.08,131 199.74,130.34 CG72.2 ; QG56.3 v2(238.01,62.89) ; v2(190.21,70.55) 190.21,70.75 190.54,71.08 RG405.1 ; CG200.2 v2(237.95,61.12) ; QG4.3 242,61.91 v2(241.59,61.49) ; UG1.V19 205.58,90.89 205.97,90.5 v2(206.25,90.5) 206.58,90.84 UG1.U19 ; UG8.3 184.12,79.13 184.36,79.36 v2(184.36,79.84) 183.76,79.84 183.28,79.36 CG46.2 ; CG144.2 194.5,113.53 v2(194.5,113.28) ; UG1.AA20 v2(203.08,91.44) UG1.Y19 ; UG1.T18 208.08,89.44 207.8,89.16 UG1.T17 ; v2(245.04,80.67) 244.71,81.01 CG176.2 ; CG183.2 238.95,106.77 v2(239.06,106.77) ; CG192.2 231.08,101.82 v2(231.46,102.19) ; v2(224.8,124.6) v2(225.4,124.6) 225.42,124.58 CG56.2 ; CG106.2 242.54,91.11 v2(242.54,91.69) ; PRW3.2 v2(244.57,55.49) ; CL3.2 34.73,42.75 34.73,42.23 v2(34.36,41.86) ; RG122.1 219.92,68.45 219.92,69.59 RG135.1 ; UG1.G2 214.86,76.54 v2(215.26,76.94) 214.86,77.34 UG1.G3 ; UG1.W15 v2(204.08,86.44) UG1.Y14 ; R5216.1 v2(35.64,11.05) ; CG196.1 238.19,45.13 v2(238.19,45.69) ; v2(206.09,83.29) 206.09,83.45 UG1.U12 206.58,84.08 v2(206.08,84.59) 205.58,84.09 UG1.V12 ; RG11.2 v2(221.13,68.96) ; CG154.2 v2(248.58,107.07) ; UG1.AB14 201.1,85.46 v2(201.1,85.43) 200.61,84.94 UG1.AC13 ; CU72.2 61.83,23.51 v2(62.25,23.93) ; v2(212.6,134.2) 212.13,134.66 CG147.2 ; UG1.U21 v2(206.08,92.44) UG1.V21 ; UG1.M13 v2(211.98,84.54) ; PR1806.2 v2(268.06,21.36) ; CG65.2 184.98,129.4 v2(185.95,129.4) ; CG190.2 220.92,115.94 v2(221.33,116.35) ; CR12.2 38.56,20.62 39.05,20.13 v2(39.05,20.06) ; CG66.2 199.71,124.6 v2(198.75,124.6) v2(198.15,124.6) UG5.N1 ; v2(212.6,128.7) 211.56,128.7 CG67.2 ; PCM15.2 95.95,26.73 v2(96.39,26.73) ; UG1.P17 v2(208.99,89.42) UG1.P18 ; CL20.2 60.28,21.71 v2(59.52,21.71) ; UG1.R14 v2(208.08,86.44) UG1.T15 207.58,86.94 v2(207.01,87.51) 206.96,87.51 206.58,87.89 UG1.U16 206.19,88.33 v2(206.19,88.43) 206.07,88.43 UG1.V16 UG1.W17 ; PR1002.2 240.31,21.84 v2(240.31,21.09) ; PC328.2 252.82,31.61 252.85,31.57 PR313.2 253.75,31.57 v2(254.03,31.3) ; QG7.1 229.02,42.06 228.62,42.46 228.62,43.08 ; 218.58,80.29 UG1.B7 219.38,80.29 v2(219.38,80.27) ; v2(198.75,128.58) 199.06,128.27 CG78.2 199.81,128.27 CG173.2 ; v2(194.51,112.72) 194.33,112.72 193.64,113.4 CG143.2 ; v2(186.85,83.64) 186.94,83.73 RG43.2 ; CG340.2 237.77,64.39 v2(238.23,63.93) ; v2(248.24,68.47) v2(248.24,67.87) ; v2(249.04,67.87) 249.04,66.64 CG149.2 ; RG42.2 187.13,81.8 v2(186.76,81.8) ; PRW12.2 236.46,51.08 236.88,51.51 v2(236.88,51.67) ; CG121.2 240.47,81.18 240.94,80.71 v2(240.94,80.67) 241.27,81 RG75.2 ; v2(236.78,106.79) 236.22,106.23 CG184.2 ; D507.1 v2(70.23,25.07) ; UC3.5 178.73,128.69 v2(178.85,128.8) ; RG59.2 212.3,127.12 v2(212.53,126.9) v2(213.2,126.9) ; RV3.2 73.95,24.92 v2(74.4,24.46) 74.91,23.96 RV7.2 ; v2(235.04,94.09) 235.02,94.11 CG189.2 ; UG1.P20 v2(209.04,91.4) UG1.R19 ; v2(235.44,80.67) 235.46,80.69 235.46,81.1 235.31,81.25 CG110.2 ; CG269.2 245.38,39.02 v2(245.38,38.6) 244.91,38.6 244.55,38.96 CG337.2 ; UG1.AC20 v2(201.04,91.48) UG1.AB19 ; CG84.2 223.14,116.84 v2(223.08,116.79) ; UG1.P13 v2(210.08,84.44) UG1.N12 ; UG1.G16 v2(215.31,88.62) ; v2(15.32,80.54) RS42.1 ; v2(14.53,107.59) 14.66,107.72 DV3.3 16.51,107.72 v2(16.72,107.92) ; CG563.2 v2(241.41,63.09) ; CH65.1 v2(184.79,23.09) ; v2(237.04,67.87) 237.04,66.95 CG175.2
  BOTTOM w0.4: UG1.AL32 194.43,101.94 ; 194.43,101.94 v2(194.41,101.94) ; 194.43,101.94 UG1.AL33 194.43,102.74 v2(194.41,102.74) ; v2(235.44,80.67) v2(234.84,80.67) ; v2(202.76,101.14) 202.73,101.14 UG1.AB32 ; UG1.AB28 201.93,97.84 v2(201.91,97.84) ; v2(217.8,88.62) 217.8,88.57 UG1.C16 ; v2(218.58,80.27) 218.58,80.29 UG1.C7 ; v2(216.98,92.77) 216.98,92.79 UG1.E22 ; v2(198.75,123) v2(198.15,123) ; 214.43,101.94 UG1.G33 ; 214.43,101.94 UG1.G32 ; 214.43,101.94 v2(214.41,101.94) ; v2(212.76,97.84) 212.73,97.84 UG1.K28 ; v2(245.04,92.29) v2(245.04,91.69) ; v2(207.76,101.14) 207.73,101.14 UG1.T32 ; UG1.B34 v2(218.58,102.74) ; v2(215.31,86.12) UG1.G13 ; v2(249.04,67.87) v2(249.04,68.47) v2(248.24,68.47) ; UG1.AH32 v2(196.93,101.94) UG1.AH33 197.08,102.59 196.93,102.74 v2(196.91,102.74) ; UG1.AE32 200.23,101.94 ; 200.23,101.94 v2(200.26,101.94) ; 200.23,101.94 UG1.AE33 199.43,102.74 v2(199.41,102.74) ; v2(220.78,76.14) 220.94,75.98 220.94,75.72 220.55,75.34 v2(220.18,75.34) ; v2(186.55,135) v2(186.55,134.2) ; v2(249.04,92.29) v2(249.04,91.69) ; 218.58,82.79 UG1.B10 218.81,83.36 218.58,83.59 v2(218.58,83.62) 218.18,83.22 UG1.C10 218.58,82.79 ; 218.58,82.79 v2(218.58,82.77) ; v2(192.78,100.27) 192.78,100.24 UG1.AN30 v2(192.78,99.44) ; 218.58,95.29 v2(218.58,95.27) ; 218.58,95.29 UG1.B25 ; 218.58,95.29 UG1.C25 ; v2(213.2,131) v2(212.6,131) ; UG1.AH30 v2(197.76,99.52) ; UG1.G2 215.23,76.14 215.26,76.14 ; v2(200.26,98.67) UG1.AE28 200.23,97.84 v2(200.26,97.84) ; v2(234.84,68.47) v2(235.44,68.47) ; v2(196.88,98.64) UG1.AH28 ; v2(249.04,80.67) v2(249.04,80.07) ; UG1.K32 212.76,101.12 v2(212.76,101.1) ; v2(213.2,134.2) v2(212.6,134.2) ; v2(204.41,101.94) 204.43,101.94 UG1.W32 ; v2(220.18,83.62) v2(220.18,82.77) ; v2(235.44,104.49) v2(235.44,103.89) v2(234.84,103.89) ; UG1.E5 v2(216.98,78.54) ; v2(191.97,101.96) 192,101.96 UG1.AP33 v2(192.78,101.94) ; UG1.N28 209.43,97.84 v2(209.41,97.84) ; v2(195.18,99.44) UG1.AL30 ; v2(215.31,83.62) UG1.G10 ; UG1.N33 209.43,101.94 v2(209.41,101.94) ; UG1.G19 v2(214.48,90.29) ; v2(245.04,103.89) UG7.E14 ; v2(235.44,91.69) 235.44,92.28 v2(235.44,92.29) v2(234.84,92.29) v2(234.84,91.69) v2(235.44,91.69)
  BOTTOM w0.406: 200.21,103.54 v2(200.26,103.54) ; 200.21,103.54 v2(199.41,102.74) ; 200.21,103.54 200.04,103.71 200.03,103.71 199.72,104.02 199.72,104.02 199.51,104.24 v2(199.41,104.24) ; v2(237.44,93.29) UG7.R1 237.04,92.88 v2(237.04,92.29) v2(237.04,91.69) ; UG1.G30 214.86,99.94 v2(215.26,100.34) ; v2(192.78,103.54) 192.05,103.54 v2(191.95,103.63) ; v2(192.78,103.54) v2(192.78,104.24) ; v2(192.78,103.54) UG1.AN34 ; UG6.K13 242.64,69.87 v2(242.24,70.27) ; v2(215,124.2) 215,124.2 UG4.E3 v2(215,125) ; v2(197.15,130.6) 197.55,131 UG5.E1 v2(198.15,131) v2(198.75,131) ; v2(185.95,134.2) v2(186.55,134.2) UG5.A14 ; v2(238.64,68.47) 238.64,68.48 UG6.E14 238.64,69.08 v2(238.24,69.47) ; UG1.E10 v2(216.16,82.77) v2(215.73,83.19) v2(215.31,83.62) ; v2(235.84,100.49) 236.24,100.09 UG7.T10 ; v2(209.41,101.94) 209.81,101.54 UG1.N32 210.23,101.14 v2(210.26,101.14) ; v2(194.38,98.62) 194.78,98.22 UG1.AL28 ; UG4.A12 222.56,121.35 v2(222.56,120.54) ; UG4.C1 213.2,122.99 v2(213.2,123) v2(212.6,123) ; UG5.R12 v2(189.15,122.6) ; v2(238.64,104.49) v2(238.64,103.89) 238.64,103.29 UG7.N14 v2(238.24,102.89) ; v2(239.04,71.87) UG6.F10 239.44,72.27 v2(239.84,71.87) UG6.G10 ; UG6.D10 237.84,72.27 v2(237.44,71.87) 237.4,71.83 UG6.C11 v2(236.64,71.07) 236.68,71.04 236.68,71.04 UG6.C12 237.04,70.67 v2(237.44,70.27) ; UG6.A1 235.44,80.07 v2(235.44,80.07) v2(235.44,80.67) ; UG1.D33 v2(217.33,102.99) ; v2(236.64,102.89) UG7.R14 237.04,103.29 v2(237.04,103.89) v2(237.04,104.49) ; v2(237.44,94.89) UG7.R3 237.04,94.49 v2(236.64,94.89) UG7.R4 ; UG4.P10 v2(220.6,131.4) ; UG4.P10 v2(220.6,132.2) ; UG4.P10 221.4,132.2 v2(221.4,132.2) UG4.R11 ; UG1.K30 v2(211.93,99.54) 211.93,99.49 v2(212.33,99.09) ; v2(245.04,104.49) v2(245.04,103.89) ; v2(198.15,123) 197.55,123 UG5.R1 v2(197.15,123.4) ; UG6.U14 v2(248.24,68.47) ; UG6.F5 v2(239.84,76.67) UG6.G5 v2(239.84,75.87) 239.44,76.27 UG6.F5 ; UG6.F5 v2(239.04,75.87) ; v2(223,131.4) 222.6,131 UG4.N12 v2(222.2,131.4) ; v2(215,133.8) UG4.U3 v2(215.8,134.6) ; UG7.E3 v2(245.44,94.89) ; UG4.R4 v2(215.8,132.2) UG4.R3 ; UG4.R4 216.6,133 UG4.T5 ; UG4.R4 v2(216.6,132.2) ; v2(220.23,100.94) 220.18,100.89 219.6,100.89 v2(219.38,101.12) 218.98,100.71 UG1.B31 ; v2(246.24,102.89) UG7.C14 v2(246.64,103.89) v2(246.64,104.49) ; UG1.D31 v2(217.78,101.14) ; v2(194.34,100.28) 194.78,99.85 UG1.AL30 ; v2(188.35,131.4) UG5.E12 v2(189.15,130.6) ; UG6.E12 v2(238.24,70.27) ; UG5.A12 188.75,134.2 v2(188.35,133.8) ; v2(195.55,133.8) 195.95,134.2 UG5.A3 196.35,134.6 v2(196.35,134.6) ; v2(224.8,134.2) v2(224.8,135) ; v2(224.8,134.2) v2(225.4,134.2) ; v2(224.8,134.2) UG4.U14 ; UG4.E1 v2(213.2,124.6) ; v2(245.44,102.09) UG7.E12 ; v2(236.64,77.47) 237.04,77.08 UG6.C4 237.44,77.47 v2(237.44,77.47) 237.04,77.87 UG6.C3 ; v2(242.64,80.07) v2(242.64,80.67) ; v2(217.78,93.62) 218.18,93.22 UG1.C22 ; v2(246.64,92.29) v2(246.64,91.69) ; v2(223.8,132.2) UG4.R14 v2(224.8,132.6) v2(225.4,132.6) ; v2(246.24,69.47) 246.64,69.07 UG6.R14 v2(246.64,68.47) v2(246.64,67.87) ; UG6.R11 246.64,71.47 v2(246.24,71.87) 246.24,71.87 UG6.P10 ; v2(187.55,133) UG5.C14 v2(186.55,132.6) v2(185.95,132.6) ; v2(236.64,75.87) 236.24,76.27 UG6.B5 ; UG7.R12 237.04,101.69 v2(236.64,101.29) ; v2(187.55,124.2) 187.15,124.6 UG5.N14 186.55,124.6 v2(186.55,124.6) v2(185.95,124.6) ; UG7.P10 237.84,100.09 v2(237.44,100.49) ; UG4.U12 222.6,134.2 v2(223,133.8) ; UG6.U12 v2(247.84,70.27) ; UG4.B10 v2(221.4,121.8) ; v2(238.24,78.27) 238.64,77.88 UG6.E3 ; UG6.P10 v2(246.24,72.67) ; UG6.P10 245.44,72.67 v2(245.44,72.67) ; UG1.G33 214.86,102.34 v2(215.26,102.74) ; UG6.A14 235.44,68.48 v2(235.44,68.47) ; UG1.B4 218.98,78.18 v2(219.4,77.76) ; UG1.C13 v2(217.78,86.09) ; UG5.C12 188.75,132.6 v2(188.35,132.2) ; v2(223.8,122.6) 224.19,122.99 UG4.C14 224.2,123 v2(224.8,123) v2(225.4,123) ; v2(193.95,133.8) 194.35,133.4 UG5.B5 ; v2(212.6,132.6) v2(213.2,132.6) UG4.R1 v2(214.2,133) ; v2(186.55,121.4) 186.55,121.39 UG5.U14 ; UG5.P10 190.35,123.8 v2(189.95,123.4) ; v2(217.78,91.12) 218.18,90.72 UG1.C19 ; v2(223.8,124.2) 223.8,124.2 UG4.E14 224.2,124.6 v2(224.8,124.6) ; UG5.C11 v2(189.95,133) 190.35,133.4 UG5.B10 ; v2(224.8,131) 224.2,131 UG4.N14 v2(223.8,130.6) ; v2(223,133) 222.6,132.6 UG4.R12 ; v2(245.44,70.27) 245.44,70.27 UG6.N12 v2(244.64,70.27) ; v2(214.2,131.4) UG4.N1 v2(213.2,131) ; UG6.A3 235.44,77.87 v2(235.04,77.47) ; v2(213.2,134.2) UG4.U1 v2(214.2,134.6) ; UG6.R12 v2(247.04,70.27) ; v2(222.2,122.6) 222.59,122.99 UG4.C12 223,123.39 v2(223,123.4) ; UG7.U12 235.44,101.69 v2(235.04,101.29) ; UG5.U12 189.13,121.02 v2(189.17,121.02) ; UG6.R1 v2(246.64,80.07) ; v2(189.95,121.8) 190.35,122.19 UG5.T10 ; UG6.B10 236.24,72.27 v2(235.84,71.87) ; v2(195.55,130.6) 195.95,131 UG5.E3 195.95,131 v2(196.35,131.4) ; UG1.AB30 v2(201.91,99.52) ; v2(241.44,78.27) UG6.H2 240.64,79.07 v2(240.64,79.07) 241.04,79.47 UG6.H1 240.94,79.57 v2(240.94,80.07) v2(240.94,80.67) ; UG1.N30 v2(210.26,99.52) v2(209.83,99.09) ; UG6.T10 v2(247.84,72.67) ; v2(236.64,69.47) 237.04,69.08 UG6.C14 237.04,68.48 v2(237.04,68.47) ; v2(239.04,79.07) 239.04,79.07 UG6.E1 238.64,80.07 v2(238.64,80.07) ; v2(245.04,80.07) UG6.N1 v2(244.64,79.07) ; UG1.A2 v2(219.38,76.14) ; v2(219.38,76.14) UG1.B1 ; v2(219.38,76.14) v2(220.18,75.34) ; UG4.T5 v2(216.6,133.8) ; UG4.T5 v2(217.4,133.8) ; UG4.T10 v2(220.6,133.8) ; UG5.N12 v2(188.35,125) ; v2(235.04,71.07) 235.44,70.68 UG6.A12 ; UG7.A1 v2(248.64,93.29) ; v2(246.24,99.69) UG7.D10 v2(245.44,100.49) ; UG4.E12 v2(223,124.2) ; UG7.U14 235.44,103.89 v2(235.44,103.89) ; UG6.R4 v2(246.24,77.47) UG6.R3 v2(247.04,78.27) ; v2(197.15,132.2) 197.55,132.6 UG5.C1 v2(198.15,132.6) ; UG4.N3 v2(215,130.6) ; UG4.N3 v2(215.8,131.4) ; UG4.N3 v2(215,131.4) ; v2(187.55,122.6) 187.15,122.99 UG5.R14 186.55,122.99 v2(186.55,123) v2(185.95,123) ; UG1.B28 218.98,98.21 v2(219.38,98.62) ; v2(189.95,131.4) 189.95,131.4 UG5.D10 v2(190.75,132.2) ; v2(236.64,79.07) 237.04,79.47 UG6.C1 237.04,80.07 v2(237.04,80.07) v2(237.04,80.67) ; v2(217.78,98.62) 218.18,98.22 UG1.C28 ; UG6.T5 v2(247.84,75.87) ; v2(197.76,99.52) UG1.AH29 197.24,99 v2(196.88,98.64) ; UG1.T28 v2(206.91,98.67) ; UG4.D10 v2(221.4,123.4) ; UG6.L5 v2(243.84,75.87) UG6.M5 v2(244.64,76.67) ; v2(215.73,85.69) v2(215.31,86.12) ; UG7.C12 v2(247.04,102.09) ; v2(194.75,132.2) 194.75,132.2 UG5.C4 195.55,132.2 v2(195.55,132.2) 195.55,132.2 UG5.C3 ; UG6.N14 v2(245.04,68.47) ; UG7.A12 v2(247.84,102.09) ; UG6.N3 v2(245.44,77.47) ; v2(247.84,78.27) UG6.U3 ; 216.2,123 UG4.C4 216.19,122.99 v2(215.8,122.6) UG4.C3 215.8,123.39 v2(215.8,123.4) 216.2,123
  BOTTOM w0.432: UC2.3 121.25,88.78 120.89,89.15 v2(120.77,89.15)
  BOTTOM w0.457: v2(92.25,24.07) 92.6,23.73 PCM17.2 ; v2(38.75,51.13) 38.75,51.08 37.95,50.29 JFAN2.5 ; v2(75.48,11.06) 75.92,11.5 PC329.2 ; v2(311.93,27.62) 311.56,27.25 JIO1.38 ; v2(238.64,68.47) v2(238.64,67.87) ; v2(246.64,80.07) v2(246.64,80.67) ; v2(237.04,68.47) v2(237.04,67.87) ; v2(245.04,80.07) v2(245.04,80.67)
  BOTTOM w0.508: CL24.1 v2(50.2,20.34) ; v2(116.03,95.02) 115.3,95.76 PHZ5.2 ; RH176.2 180.77,51.71 v2(180.58,51.52) ; v2(174.83,57.85) 174.53,58.15 JDIMM1.262 ; v2(161.75,131.34) PRZ78.2 161.96,132.23 PCZ32.2 PRZ57.2 ; JSPK1.7 305.03,44.44 v2(305.03,45.21) ; v2(120.41,84.08) 120.55,84.23 CC41.1 ; CL28.2 62.03,14.01 61.25,14.8 v2(60.89,14.8) ; PC1804.2 261.24,17.78 v2(261.86,17.78) ; CG2.2 223.23,67.31 v2(222.79,66.87) 222.7,66.87 CG1.2 ; v2(230.88,65.06) 230.88,64.5 RG136.1 ; v2(219.31,14.57) 219.24,14.5 CH66.1 ; v2(242.86,46.48) 242.86,46.05 242.68,45.86 CG336.2 ; JKB1.34 208.75,8.14 v2(208.23,7.62) ; CR7.2 CR2.2 CR10.2 v2(36.28,17.3) ; JKBL1.6 211,7.55 v2(210.61,7.55) ; v2(17.03,48.46) 16.85,48.28 DU14.1 ; v2(189.67,13.69) CH25.2 ; PDM3.2 v2(84.29,27.72) ; v2(174.41,105.12) 174.41,105.1 PRF6.2 ; v2(261.58,21.28) 261.09,21.28 PC1803.2 ; PCZ31.1 v2(161.88,126.64) ; JFAN1.4 271.99,48.08 271.74,48.33 v2(270.93,48.33) ; PCW1.2 v2(239.86,56.97) 239.58,57.25 PRW6.2 ; v2(225.06,65.94) 225.28,65.72 RG134.1 225.48,64.98 RG138.1 ; JWLAN1.68 303.6,26.22 v2(304.02,26.64) ; v2(40.19,49.13) 40.76,49.13 40.99,48.9 JFAN2.4 ; UH2.4 192.35,49.01 v2(192.35,48.54) ; JDIMM2.261 100.65,20.45 v2(99.83,20.45) ; v2(147.86,136.17) 147.86,135.74 147.32,135.2 PCZ53.2 ; v2(187.28,18.77) 187.05,18.54 CH7.2 ; RC35.2 122.63,97.21 v2(122.57,97.15) 122.57,96.88 123,96.45 RC33.2 ; JKB1.33 173.52,8.68 v2(174.23,8.68) ; PCV28.2 228.83,51.41 229.25,50.99 v2(229.25,50.84) ; RR10.2 v2(36.89,13.06) ; v2(231.72,65.06) 231.72,64.55 RG123.1 ; QG16.3 233.41,38.67 v2(232.94,39.14) ; PCA6.2 161.37,135.74 v2(161.55,135.56) ; v2(230.04,65.06) 230.04,64.53 RG118.1 ; PCM16.2 89.67,25.05 v2(89.91,25.29) ; v2(219.28,18.31) RH25.2 RH168.2 ; PCM18.2 93.54,21.92 v2(93.56,21.9) ; UU5.4 57.64,28.41 58.32,27.74 v2(58.32,27.41) ; v2(186.57,128.6) v2(185.97,128.6) 184.87,128.6 CG88.2 ; v2(51.57,32.84) 51.89,33.16 DM13.2 ; RC32.2 123.38,99.59 v2(121.75,99.59) ; PR1007.2 v2(239.55,22.25) ; RH204.2 RH193.2 186.49,26.17 v2(186.31,26.35) ; PCM5.2 93.18,31.15 92.54,30.5 v2(92.54,30.12) ; v2(237.94,38.03) 237.91,38 QG17.1 ; CE6.2 46.97,41.02 46.99,41.04 ; CH80.2 v2(122,108.48) CC155.2 ; PCZ30.2 PRZ77.2 162.06,124.28 v2(161.88,124.1) ; CG11.2 v2(190.92,93.5) ; CH34.2 187.89,14.64 CH11.1 v2(186.38,15.53) ; DM12.2 51.89,26.81 v2(51.54,26.46) ; CH68.1 CH67.1 219.59,13.25 v2(220.02,13.68) ; QG55.3 v2(233.75,63.19) ; RC13.2 RC11.2 ; RG137.1 232.55,64.9 v2(232.4,65.06) ; CV274.2 v2(181.31,119.68) ; v2(252.17,20.34) 251.32,20.34 PC311.2 ; RC392.2 122.64,103.43 CC157.1 v2(122.05,104.29) ; v2(240.94,92.29) v2(240.94,91.69) ; v2(219.14,17.15) 218.99,17 CH69.1 ; PRW4.1 238.58,58.04 v2(238.09,57.54) ; v2(28.74,66.79) 28.32,67.21 CV32.2 ; v2(39.07,37.96) 38.65,37.96 38.13,38.48 DL1.1 ; YH1.4 v2(220.21,32.01) ; RG73.2 233.83,71.07 v2(235.04,71.07) ; CR9.2 v2(36.28,18.18) ; v2(218.37,8.98) 219.1,8.25 JKBL1.5 ; PC308.2 252,19.53 v2(252.15,19.69) ; JFAN1.5 271.22,43.5 v2(271.68,43.04) ; CC156.1 176.18,83.8 v2(176.14,83.84) ; JFAN1.6 v2(276.29,42.2) ; v2(284.81,26.31) 283.93,27.19 PD2.1 ; v2(280.54,26.4) 280.52,26.42 PR2.2 280.52,27.85 PR6.2 ; v2(243.79,64.29) 244.15,64.64 RG70.2 ; CR6.2 CR3.2 v2(46.92,18.82) ; RG57.2 v2(229.12,126.17) ; JFAN2.6 37.15,44.6 36.66,45.09 v2(36.66,46.26) ; v2(122.67,95.58) RC34.2 RC36.2 ; RC390.2 124.49,100.33 v2(124.82,100.66) ; v2(122.66,98) RC19.2 123.38,98 RC31.2 ; JSPK1.6 v2(297.49,44.61) ; RG135.1 219.46,69.77 219.31,69.62 v2(219.31,69.16) ; v2(245.03,29.02) 245.52,29.02 PC301.2 ; CH6.2 v2(187.3,21.26) ; PRZ65.2 162.01,130.58 v2(161.88,130.45) ; v2(260.57,22.49) PR1805.2 261.77,23.39 PC1805.2 ; JTP1.9 96.52,10.45 97.15,9.82 v2(97.15,9.4) ; PCZ39.2 154.89,135.2 155.53,135.84 v2(155.53,136.17) ; 224.87,43.39 224.43,42.95 QG57.3 ; PCZ60.2 139.73,135.2 140.24,135.71 v2(140.24,136.12) ; CH3.2 181.41,49.72 v2(181.19,49.93) ; v2(84.59,12.24) 82.8,10.45 JTP1.10 ; PCZ67.2 132.42,135.2 132.92,135.71 v2(132.92,136.24) ; PRZ63.2 162.01,129.82 v2(161.88,129.69) ; PCM7.1 v2(88.47,28.45) ; JSPK1.8 296.36,44.61 v2(296.65,44.61) ; v2(243.98,46.36) 244.48,45.85 CG335.2 ; PC329.2 75.89,11.74 PR308.2 ; PHZ4.2 v2(155.2,131.21) ; RG58.2 v2(229.12,126.96) ; CG570.2 v2(190.9,94.99) ; PCH7.2 v2(181.17,115.58) ; JDIMM1.261 101.43,60.32 v2(101.43,60.6) ; CH2.2 v2(180.68,53.36) ; YH1.2 v2(219.21,34.94) ; RV29.2 v2(18.52,117.66) ; CL25.1 v2(50.25,17.68) ; v2(238.64,80.07) v2(238.64,80.67) ; PCW6.2 v2(262.03,57.8)
  vias: v2(0.43,123.18) v2(0.44,120.64) v2(0.44,12.27) v2(0.44,9.73) v2(0.44,7.19) v2(0.44,4.65) v2(0.44,2.11) v2(0.89,57.63) v2(0.89,46.84) v2(0.89,44.3) v2(0.92,0.44) v2(1,119.83) v2(1.18,100.86) v2(1.18,98.32) v2(1.73,125.9) v2(1.73,96.19) v2(2.24,101.5) v2(2.3,43.33) v2(2.62,127.43) v2(2.62,124.37) v2(2.68,98.15) v2(2.88,12.83) v2(2.98,80.9) v2(3.36,99.55) v2(3.46,0.44) v2(4.07,96.19) v2(4.2,119.83) v2(4.18,101.03) v2(4.34,98.18) v2(4.38,127.43) v2(4.38,124.37) v2(4.39,42.81) v2(5.24,47.37) v2(5.27,125.9) v2(5.31,57.48) v2(5.31,55.85) v2(5.3,48.82) v2(5.42,103.47) v2(5.38,99.55) v2(5.61,5.05) v2(5.69,3.19) v2(6,0.44) v2(6.41,101.55) v2(6.36,98.18) v2(6.76,119.84) v2(7.06,6.31) v2(7.09,4.14) v2(7.11,1.89) v2(7.28,100.25) v2(7.51,8.25) v2(7.69,103.47) v2(7.7,10.58) v2(8.11,99.08) v2(8.21,101.62) v2(8.29,9.39) v2(8.37,7.23) v2(8.53,96.19) v2(8.5,81.56) v2(8.54,0.44) v2(8.87,127.22) v2(8.92,42.8) v2(9,98.04) v2(9.3,119.84) v2(9.29,100.32) v2(9.31,8.26) v2(9.5,10.6) v2(9.75,125.23) v2(9.96,126.97) v2(10.11,101.64) v2(10.13,99.15) v2(10.09,9.4) v2(10.18,117.35) v2(10.24,105.84) v2(10.19,103.57) v2(10.23,4) v2(10.44,125.19) v2(10.5,12.82) v2(10.69,118.92) v2(10.87,128.47) v2(11.04,81.56) v2(11,8.26) v2(11.07,96.18) v2(11.12,5.53) v2(11.12,2.47) v2(11.24,98.1) v2(11.19,10.6) v2(11.31,100.33) v2(11.46,42.8) v2(11.78,9.4) v2(12.3,101.66) v2(12.39,99.15) v2(12.67,8.28) v2(12.86,10.61) v2(12.88,5.53) v2(12.88,2.47) v2(13.04,12.82) v2(13.43,50.12) v2(13.45,9.42) v2(13.6,97.9) v2(13.77,4) v2(14.04,109.2) v2(14.08,44.78) v2(14.05,42.8) v2(14.17,58.89) v2(14.61,128.18) v2(15.06,60.42) v2(15.06,57.36) v2(15.58,12.82) v2(15.65,126) v2(16.16,0.44) v2(16.46,124.32) v2(16.57,44.8) v2(16.82,60.42) v2(16.82,57.36) v2(17.2,8.18) v2(17.41,122.33) v2(17.71,58.89) v2(17.87,8.21) v2(18.12,12.82) v2(18.31,120.44) v2(18.44,8.2) v2(18.7,0.44) v2(19.13,111.23) v2(19.11,44.8) v2(19.16,116.25) v2(19.16,115.62) v2(19.16,113.02) v2(19.37,118.21) v2(19.82,107.69) v2(19.77,83.34) v2(19.78,80.19) v2(20.3,109.34) v2(20.31,105.99) v2(20.66,12.82) v2(20.89,107.23) v2(20.91,74.86) v2(20.92,74.3) v2(20.9,50.59) v2(21.06,113.82) v2(21.24,0.44) v2(21.65,44.8) v2(21.75,86.76) v2(21.66,48.96) v2(21.8,54.81) v2(22.11,117.35) v2(22.09,54.33) v2(22.23,115.28) v2(22.3,110.61) v2(22.3,110.03) v2(22.6,90.81) v2(22.88,88.94) v2(23.12,116.81) v2(23.12,113.75) v2(23.2,12.82) v2(23.25,93.26) v2(23.28,70.29) v2(23.25,54.74) v2(23.48,84.74) v2(23.51,74.82) v2(23.51,74.25) v2(23.59,83.91) v2(23.59,83.35) v2(23.63,68.18) v2(23.67,90.3) v2(23.84,63.3) v2(23.84,61.95) v2(23.84,60.6) v2(23.84,59.26) v2(23.78,0.44) v2(23.86,54.78) v2(24,87.94) v2(23.96,71.39) v2(24.19,44.8) v2(24.37,96.08) v2(24.38,85.22) v2(24.35,78.23) v2(24.53,74.92) v2(24.52,73.01) v2(24.7,108.65) v2(24.8,82.28) v2(24.88,116.81) v2(24.88,113.75) v2(24.95,67.94) v2(25.07,69.9) v2(25.19,63.3) v2(25.19,61.95) v2(25.19,60.6) v2(25.19,59.26) v2(25.31,79.02) v2(25.37,105.43) v2(25.37,103.25) v2(25.37,100.25) v2(25.37,97.71) v2(25.6,110.21) v2(25.6,107.09) v2(25.77,115.28) v2(26,76.04) v2(26.07,112.81) v2(26.32,0.44) v2(26.54,63.3) v2(26.54,61.95) v2(26.54,60.6) v2(26.54,59.26) v2(26.75,73.63) v2(27.88,63.3) v2(27.88,61.95) v2(27.88,60.6) v2(27.88,59.26) v2(28.2,70.04) v2(28.33,42.8) v2(28.28,12.82) v2(28.38,44.77) v2(28.63,7.06) v2(28.86,0.44) v2(29.54,67.41) v2(29.6,44.41) v2(30.18,44.41) v2(30.44,51.68) v2(30.44,50.28) v2(30.76,44.41) v2(30.82,12.82) v2(30.87,42.8) v2(31.18,64.73) v2(31.4,0.44) v2(31.49,6.09) v2(31.55,53.1) v2(31.55,51.68) v2(31.55,50.28) v2(31.55,48.86) v2(32.22,58.45) v2(32.21,6.1) v2(32.67,51.68) v2(32.67,50.28) v2(32.95,62.25) v2(33.15,10.96) v2(33.33,18.21) v2(33.33,15.67) v2(33.3,12.82) v2(33.36,42.8) v2(33.85,48.32) v2(33.94,0.44) v2(35.18,59.71) v2(35.28,47.58) v2(36.5,34.95) v2(36.48,0.44) v2(36.68,31.92) v2(36.72,25.88) v2(36.76,28.9) v2(36.88,51.81) v2(37.32,57.6) v2(39.02,0.44) v2(39.5,8.24) v2(39.61,55.67) v2(39.65,49.41) v2(39.99,37.26) v2(40.49,17.97) v2(40.57,37.26) v2(40.95,42.42) v2(40.86,9.36) v2(41,0.43) v2(41.13,37.26) v2(41.61,17.97) v2(41.61,16.86) v2(41.61,15.74) v2(41.58,2.64) v2(42.37,53.71) v2(42.55,10.31) v2(42.62,45.3) v2(42.72,17.97) v2(42.72,16.86) v2(42.72,15.74) v2(42.78,46.41) v2(42.96,3.83) v2(43.35,46.49) v2(43.62,12.29) v2(44.52,49.03) v2(45.32,51.97) v2(45.5,3.83) v2(45.75,12.53) v2(46.52,44.72) v2(46.52,43.46) v2(46.52,42.19) v2(46.89,49.22) v2(47.3,48.8) v2(47.28,5.9) v2(47.99,45.98) v2(47.99,44.72) v2(47.99,43.46) v2(47.99,42.19) v2(47.99,40.93) v2(48.22,50.59) v2(48.17,7.43) v2(48.17,4.37) v2(49.47,44.72) v2(49.47,43.46) v2(49.47,42.19) v2(49.93,7.43) v2(49.93,4.37) v2(50.33,12.89) v2(50.37,49.1) v2(50.82,5.9) v2(50.88,12.89) v2(51.16,33.27) v2(51.41,27.23) v2(52.77,3.83) v2(52.94,48.29) v2(52.91,25.17) v2(53.75,25.93) v2(54.59,21.06) v2(54.59,19.94) v2(54.59,18.83) v2(55.61,48.26) v2(55.71,21.06) v2(55.71,19.94) v2(55.66,3.83) v2(56.36,23.03) v2(56.83,21.06) v2(56.83,19.94) v2(56.83,18.83) v2(57.48,23) v2(58.2,3.83) v2(58.29,47.8) v2(58.83,22.32) v2(59.02,34.31) v2(59.61,34.31) v2(60.13,6.88) v2(60.06,6.24) v2(60.19,34.31) v2(60.34,5.56) v2(60.49,47.57) v2(60.74,9.37) v2(60.69,6.22) v2(60.74,3.83) v2(60.77,8.12) v2(60.77,6.9) v2(60.97,5.58) v2(61.33,9.37) v2(61.3,6.22) v2(61.35,8.12) v2(61.35,6.9) v2(61.55,5.58) v2(61.91,6.19) v2(62.96,47.45) v2(63.28,3.83) v2(65.82,3.83) v2(65.89,47.52) v2(66.17,34.63) v2(66.17,34.06) v2(66.17,33.44) v2(66.73,34.67) v2(66.65,32.66) v2(68.36,3.83) v2(68.94,21.6) v2(69.17,47.86) v2(70.65,20.91) v2(70.9,3.83) v2(71.37,31.71) v2(71.8,33.09) v2(71.82,32.51) v2(71.93,48.36) v2(72.4,33.1) v2(72.42,32.52) v2(72.69,26.57) v2(73.44,3.83) v2(73.82,8.81) v2(74.21,26.55) v2(74.61,49.05) v2(75.08,8.34) v2(75.73,26.44) v2(75.98,3.83) v2(77.08,8.34) v2(77.18,49.91) v2(77.66,26.41) v2(78.16,31.48) v2(78.37,43.99) v2(78.39,7.84) v2(78.52,3.83) v2(78.6,34.64) v2(78.79,8.3) v2(78.94,43.99) v2(79.06,8.82) v2(79.13,7.86) v2(79.23,34.66) v2(79.24,6.53) v2(79.41,8.35) v2(79.52,50.88) v2(79.55,44) v2(79.54,26.53) v2(79.66,8.86) v2(79.7,7.83) v2(80.05,8.35) v2(80.04,7.34) v2(80.3,8.86) v2(80.3,7.84) v2(80.63,7.35) v2(80.68,8.35) v2(80.93,7.84) v2(81.06,3.83) v2(81.28,26.41) v2(81.6,51.89) v2(82.45,33.82) v2(82.46,34.44) v2(83.6,3.83) v2(83.81,53.14) v2(85.9,54.5) v2(85.95,41.94) v2(85.95,41.35) v2(85.95,40.77) v2(86.14,3.83) v2(86.83,23.17) v2(87.05,21.73) v2(87.35,32.54) v2(87.35,31.78) v2(87.57,44.25) v2(88.09,29.23) v2(88.16,56.22) v2(88.15,44.25) v2(88.18,20.59) v2(88.74,44.25) v2(88.68,3.83) v2(88.98,35.84) v2(88.98,35.2) v2(88.98,34.57) v2(89.32,44.25) v2(89.49,35.46) v2(89.49,34.82) v2(89.49,34.19) v2(89.62,39.14) v2(89.62,38.5) v2(89.62,37.87) v2(89.62,37.23) v2(89.62,36.6) v2(89.99,12.17) v2(90.12,38.25) v2(90.12,37.62) v2(90.12,36.85) v2(90.44,58.23) v2(91.23,52.9) v2(91.22,3.83) v2(91.65,27.57) v2(91.65,26.32) v2(92.12,54.43) v2(92.12,51.37) v2(92.35,60.19) v2(92.27,26.95) v2(93.12,9.5) v2(93.76,3.83) v2(93.88,54.43) v2(93.88,51.37) v2(94.16,62.33) v2(94.77,52.9) v2(96.23,65.13) v2(96.3,3.83) v2(97.5,67.33) v2(98.18,42.6) v2(98.72,41.99) v2(98.71,41.43) v2(98.71,40.8) v2(98.84,3.83) v2(98.87,70.01) v2(99.98,72.67) v2(100.76,10.5) v2(100.87,75.32) v2(101.38,3.83) v2(101.5,77.71) v2(101.91,93.09) v2(101.94,36.86) v2(101.94,35.64) v2(101.99,80.29) v2(102.2,91.03) v2(102.41,88.65) v2(102.69,10.47) v2(102.85,82.47) v2(102.78,31.03) v2(103.04,49.38) v2(103.04,48.12) v2(103.18,107.75) v2(103.49,105.54) v2(103.5,94.46) v2(103.89,102.72) v2(103.92,3.83) v2(104.19,100.55) v2(104.53,98.15) v2(104.53,36.77) v2(104.6,44.96) v2(104.65,34.15) v2(104.61,32.91) v2(104.66,43.64) v2(104.7,31.42) v2(104.8,96.24) v2(104.87,10.47) v2(105.02,108.45) v2(105.52,82.47) v2(105.58,87.34) v2(105.62,48.54) v2(105.62,46.38) v2(105.62,39.26) v2(105.67,45.16) v2(105.78,28.07) v2(105.77,11.22) v2(106.51,35.83) v2(106.51,34.56) v2(106.51,33.29) v2(106.46,3.83) v2(106.78,28.06) v2(107.09,31.41) v2(107.56,108.47) v2(107.9,52.09) v2(107.88,51.48) v2(107.9,48.16) v2(107.9,47.14) v2(107.9,45.87) v2(107.9,44.22) v2(107.89,11.22) v2(108.04,86.22) v2(108.15,83.75) v2(108.11,40.66) v2(108.11,39.96) v2(108.11,39.27) v2(108.16,95.15) v2(108.16,94.51) v2(108.16,93.88) v2(108.65,35.87) v2(108.59,34.65) v2(108.67,95.4) v2(108.67,94.77) v2(108.67,94.13) v2(108.67,93.5) v2(108.72,32.55) v2(108.78,31.2) v2(109,3.83) v2(109.17,95.15) v2(109.17,94.51) v2(109.17,93.88) v2(109.33,9.02) v2(109.38,46.66) v2(109.38,45.39) v2(109.38,44.19) v2(109.42,40.65) v2(109.42,39.33) v2(109.92,31.21) v2(110,95.3) v2(110,94.29) v2(110,93.29) v2(110.23,13.95) v2(110.34,108.99) v2(110.34,33.83) v2(110.79,13.95) v2(111.31,95.3) v2(111.31,94.29) v2(111.31,93.29) v2(111.35,13.95) v2(111.4,9.02) v2(111.54,3.83) v2(111.84,35.83) v2(111.84,35.19) v2(111.84,33.92) v2(112.12,9.97) v2(112.22,48.26) v2(112.22,47.01) v2(112.22,45.77) v2(112.16,43.74) v2(112.2,40.71) v2(112.2,39.93) v2(112.2,39.33) v2(112.32,109.83) v2(112.32,31.05) v2(112.63,95.3) v2(112.63,94.29) v2(112.63,93.29) v2(113.09,53.16) v2(113.09,51.99) v2(113.94,94.22) v2(113.94,93.29) v2(113.87,36.59) v2(113.87,35.32) v2(113.87,34.05) v2(113.87,32.78) v2(113.87,31.51) v2(114.08,3.83) v2(114.16,111.08) v2(114.2,9.97) v2(114.7,28.01) v2(114.91,9.01) v2(115.16,48.07) v2(115.16,46.86) v2(115.16,45.65) v2(115.16,44.81) v2(115.16,40.66) v2(115.16,39.28) v2(115.46,112.34) v2(115.91,34.81) v2(115.91,32.91) v2(115.91,32.27) v2(116.65,73.6) v2(116.62,3.83) v2(116.68,114.02) v2(116.98,9.16) v2(117.54,115.78) v2(117.48,47.37) v2(117.48,44.55) v2(117.48,40.23) v2(117.48,39.31) v2(117.68,73.31) v2(117.67,32.48) v2(117.83,35.17) v2(117.82,33.85) v2(117.94,87.44) v2(117.98,130.96) v2(117.98,128.42) v2(117.98,125.88) v2(117.98,123.34) v2(117.98,120.8) v2(117.98,117.18) v2(118.08,9.07) v2(118.26,87.92) v2(118.32,31.11) v2(118.51,94.65) v2(118.56,87.43) v2(118.75,88.29) v2(119.13,88.8) v2(119.11,87.64) v2(119.22,48.83) v2(119.22,47.65) v2(119.21,46.07) v2(119.21,44.6) v2(119.22,39.92) v2(119.22,39.27) v2(119.16,3.83) v2(119.33,88.24) v2(119.56,89.23) v2(119.75,31.76) v2(119.8,132.4) v2(119.78,34.51) v2(119.75,33.27) v2(120.21,9.01) v2(120.35,109.75) v2(120.86,110.26) v2(120.98,134.96) v2(121.09,48.83) v2(121.09,47.48) v2(121.09,43.99) v2(121.37,110.77) v2(121.39,33.54) v2(121.64,137.39) v2(121.7,18.49) v2(121.7,15.34) v2(121.7,3.83) v2(121.78,31.11) v2(121.84,9.07) v2(121.87,111.28) v2(122.84,81.63) v2(122.89,34.05) v2(123.12,32.02) v2(123.27,16.91) v2(123.53,35.7) v2(123.78,82.34) v2(123.9,88.17) v2(124.11,31.26) v2(124.18,137.39) v2(124.24,3.83) v2(124.29,126.9) v2(124.29,126.26) v2(124.29,125.63) v2(124.29,124.99) v2(124.25,85.12) v2(124.32,47.93) v2(124.3,46.61) v2(124.32,44.45) v2(124.52,52.76) v2(124.51,39.59) v2(124.7,31.23) v2(124.85,18.49) v2(124.85,15.34) v2(125.07,83.82) v2(125.3,34.43) v2(125.41,89) v2(125.48,6.79) v2(125.97,48.16) v2(125.96,46.76) v2(125.97,44.27) v2(125.96,39.98) v2(125.96,39.38) v2(126.09,79.58) v2(126.23,88.02) v2(126.32,36.72) v2(126.32,36.08) v2(126.72,137.39) v2(126.78,3.83) v2(126.95,55.4) v2(126.95,54.76) v2(127.41,80.85) v2(127.52,128.97) v2(127.52,128.03) v2(127.53,28.06) v2(127.72,34.3) v2(127.76,77.95) v2(128.25,33.08) v2(128.22,31.76) v2(128.36,43.97) v2(128.37,43.35) v2(128.84,128.97) v2(128.84,127.96) v2(128.84,126.95) v2(129.07,79.26) v2(129.26,137.39) v2(129.32,3.83) v2(129.62,48.66) v2(129.62,47.39) v2(129.88,134.39) v2(130.15,128.97) v2(130.15,127.96) v2(130.15,126.95) v2(130.55,80.66) v2(130.64,47.52) v2(131.47,128.97) v2(131.47,127.96) v2(131.47,126.95) v2(131.51,96.45) v2(131.51,95.66) v2(131.8,137.39) v2(131.81,34.3) v2(131.78,33.03) v2(131.86,3.83) v2(132.03,129.56) v2(132.03,128.93) v2(132.03,127.91) v2(132.03,126.9) v2(132.35,133.5) v2(132.35,128.42) v2(132.35,127.4) v2(132.35,126.32) v2(132.35,125.75) v2(132.35,125.18) v2(132.35,124.61) v2(132.35,124.04) v2(132.35,123.47) v2(132.35,122.9) v2(132.35,122.32) v2(132.35,121.75) v2(132.67,128.93) v2(132.67,127.91) v2(132.67,126.9) v2(132.92,133.5) v2(132.92,126.32) v2(132.92,125.75) v2(132.92,125.18) v2(132.92,124.61) v2(132.92,124.04) v2(132.92,123.47) v2(132.92,122.9) v2(132.92,122.32) v2(132.92,121.75) v2(132.99,128.42) v2(132.99,127.4) v2(133.23,99.9) v2(133.23,98.91) v2(133.23,95.02) v2(133.3,128.93) v2(133.3,127.91) v2(133.3,126.9) v2(133.33,68.3) v2(133.49,133.5) v2(133.49,126.32) v2(133.49,125.75) v2(133.49,125.18) v2(133.49,124.61) v2(133.49,124.04) v2(133.49,123.47) v2(133.49,122.9) v2(133.49,122.32) v2(133.49,121.75) v2(133.62,128.42) v2(133.62,127.4) v2(133.94,128.93) v2(133.94,127.91) v2(133.94,126.9) v2(134.07,133.5) v2(134.07,126.32) v2(134.07,125.75) v2(134.07,125.18) v2(134.07,124.61) v2(134.07,124.04) v2(134.07,123.47) v2(134.07,122.9) v2(134.07,122.32) v2(134.07,121.75) v2(134.21,104.22) v2(134.19,79.6) v2(134.19,78.41) v2(134.34,137.39) v2(134.32,129.37) v2(134.26,128.42) v2(134.26,127.4) v2(134.45,34.03) v2(134.4,3.83) v2(134.47,32.76) v2(134.68,46.42) v2(134.78,102.5) v2(134.89,128.97) v2(134.89,128.03) v2(135,104.22) v2(135.18,92.94) v2(136.2,128.97) v2(136.2,127.96) v2(136.2,126.95) v2(136.24,81.5) v2(136.23,79.68) v2(136.27,78.51) v2(136.43,92.17) v2(136.82,44.8) v2(136.88,137.39) v2(136.94,3.83) v2(136.96,92.96) v2(137.14,36.11) v2(137.13,34.35) v2(137.24,134.39) v2(137.36,104.22) v2(137.52,128.97) v2(137.52,127.96) v2(137.52,126.95) v2(137.73,48.02) v2(137.73,46.85) v2(138.83,128.97) v2(138.83,127.96) v2(138.83,126.95) v2(138.83,81.38) v2(138.84,80.22) v2(138.88,79.02) v2(139.42,137.39) v2(139.4,34.56) v2(139.4,33.29) v2(139.46,128.99) v2(139.53,126.45) v2(139.51,71.55) v2(139.48,3.83) v2(139.65,129.63) v2(139.72,123.72) v2(139.72,123.15) v2(139.72,122.58) v2(139.72,122.01) v2(139.69,46.03) v2(139.84,133.5) v2(139.86,93.01) v2(140.16,126.45) v2(140.16,125.88) v2(140.29,123.72) v2(140.29,123.15) v2(140.29,122.58) v2(140.29,122.01) v2(140.42,133.5) v2(140.68,98.17) v2(140.68,97.61) v2(140.68,97.05) v2(140.8,126.45) v2(140.8,125.88) v2(140.86,123.72) v2(140.86,123.15) v2(140.86,122.58) v2(140.86,122.01) v2(140.99,133.5) v2(141.24,98.17) v2(141.24,97.61) v2(141.24,97.05) v2(141.34,92.94) v2(141.43,123.72) v2(141.43,123.15) v2(141.43,122.58) v2(141.43,122.01) v2(141.56,133.5) v2(141.81,126.13) v2(141.84,79.1) v2(141.88,129.69) v2(141.88,129.12) v2(141.88,128.55) v2(141.88,127.98) v2(141.93,92.94) v2(141.93,92.3) v2(141.91,77.92) v2(141.91,76.71) v2(141.96,137.39) v2(142,123.72) v2(142,123.15) v2(142,122.58) v2(142,122.01) v2(141.98,74.77) v2(142.02,3.83) v2(142.08,104.92) v2(142.08,104.22) v2(142.16,32.58) v2(142.45,33.64) v2(142.51,128.97) v2(142.51,128.03) v2(142.64,46.03) v2(142.64,44.58) v2(142.87,109.47) v2(142.87,108.82) v2(142.87,108.17) v2(142.87,107.52) v2(142.87,106.87) v2(142.87,106.22) v2(142.87,105.57) v2(143.66,106.22) v2(143.66,104.22) v2(143.82,128.97) v2(143.82,127.96) v2(143.82,126.95) v2(144.35,46.12) v2(144.5,137.39) v2(144.56,3.83) v2(144.86,134.39) v2(145.14,128.97) v2(145.14,127.96) v2(145.14,126.95) v2(145.06,33.93) v2(146.02,104.22) v2(145.98,71.04) v2(145.98,69.11) v2(145.96,67.35) v2(146.45,128.97) v2(146.45,127.96) v2(146.45,126.95) v2(146.52,98.16) v2(146.52,97.6) v2(146.52,97.04) v2(146.56,34.69) v2(146.8,81.02) v2(146.8,79.18) v2(146.77,47.65) v2(146.77,46.38) v2(146.77,45.11) v2(147.04,137.39) v2(147.02,128.99) v2(147.02,127.98) v2(147.02,126.96) v2(147.15,129.63) v2(147.08,98.16) v2(147.08,97.6) v2(147.08,97.04) v2(147.1,36.74) v2(147.1,3.83) v2(147.16,31.05) v2(147.34,128.48) v2(147.34,127.47) v2(147.48,92.25) v2(147.48,91.56) v2(147.59,133.5) v2(147.59,124.36) v2(147.59,123.78) v2(147.59,123.21) v2(147.59,122.64) v2(147.59,122.07) v2(147.66,128.99) v2(147.66,127.98) v2(147.66,126.96) v2(147.78,121.5) v2(147.97,128.48) v2(147.97,127.47) v2(148.03,36.46) v2(148.04,33.92) v2(148.04,32.65) v2(148.04,31.38) v2(148.1,124.1) v2(148.1,123.53) v2(148.1,122.96) v2(148.1,122.39) v2(148.06,35.19) v2(148.16,133.5) v2(148.29,128.99) v2(148.29,127.98) v2(148.29,126.96) v2(148.35,121.5) v2(148.38,104.22) v2(148.42,53.01) v2(148.61,128.48) v2(148.61,127.47) v2(148.61,122.07) v2(148.73,133.5) v2(148.93,128.99) v2(148.93,127.98) v2(148.93,126.96) v2(148.93,121.5) v2(148.87,28.07) v2(149.24,128.48) v2(149.24,127.47) v2(149.18,122.07) v2(149.31,133.5) v2(149.43,31.13) v2(149.5,126.9) v2(149.5,121.5) v2(149.58,137.39) v2(149.56,129.56) v2(149.56,128.99) v2(149.56,127.98) v2(149.64,3.83) v2(149.75,122.07) v2(149.94,48.41) v2(149.94,47.14) v2(149.92,45.44) v2(150.13,128.97) v2(150.13,128.03) v2(150.74,104.22) v2(150.97,79.28) v2(151.08,35.07) v2(151.08,32.78) v2(151.44,128.97) v2(151.44,127.96) v2(151.44,126.95) v2(151.66,92.11) v2(151.91,47.6) v2(151.91,45.05) v2(151.87,32.13) v2(151.94,27.99) v2(151.97,36.51) v2(151.97,35.32) v2(152.12,137.39) v2(152.16,40.8) v2(152.16,39.37) v2(152.18,3.83) v2(152.48,134.39) v2(152.5,52.12) v2(152.5,51.56) v2(152.68,92.11) v2(152.75,46.42) v2(152.75,44.14) v2(152.76,128.97) v2(152.76,127.96) v2(152.76,126.95) v2(152.76,47.84) v2(152.75,45.31) v2(153.11,104.22) v2(153.39,76.05) v2(153.43,40.69) v2(153.43,40.01) v2(153.66,71.65) v2(153.7,69.82) v2(153.95,92.11) v2(154.07,128.97) v2(154.07,127.96) v2(154.07,126.95) v2(154.45,133.5) v2(154.64,128.99) v2(154.64,127.98) v2(154.64,126.96) v2(154.63,47.49) v2(154.63,46.32) v2(154.64,45.13) v2(154.59,34.03) v2(154.61,32.83) v2(154.66,137.39) v2(154.72,3.83) v2(155.02,133.5) v2(154.96,128.48) v2(154.96,127.47) v2(154.96,126.45) v2(154.96,125.88) v2(154.96,125.31) v2(154.96,124.74) v2(154.96,122.13) v2(154.96,121.56) v2(155.28,128.99) v2(155.28,127.98) v2(155.28,126.96) v2(155.28,33.41) v2(155.53,126.45) v2(155.53,125.88) v2(155.53,125.31) v2(155.53,124.74) v2(155.53,122.13) v2(155.53,121.56) v2(155.47,104.22) v2(155.53,92.11) v2(155.59,133.5) v2(155.59,128.48) v2(155.59,127.47) v2(155.91,128.99) v2(155.91,127.98) v2(155.91,126.96) v2(155.94,78.7) v2(156.1,122.13) v2(156.1,121.56) v2(156.11,31.39) v2(156.16,133.5) v2(156.23,128.48) v2(156.23,127.47) v2(156.21,73.89) v2(156.25,104.22) v2(156.33,72.09) v2(156.55,128.99) v2(156.55,127.98) v2(156.47,6.69) v2(156.75,92.11) v2(156.78,77.85) v2(156.81,52.11) v2(156.81,51.55) v2(156.79,46.17) v2(156.79,43.58) v2(156.78,32.45) v2(156.95,36.55) v2(157.2,137.39) v2(157.28,100.28) v2(157.34,31.29) v2(157.41,98.37) v2(157.41,97.81) v2(157.41,97.18) v2(157.41,96.54) v2(157.41,95.93) v2(157.41,95.3) v2(157.54,33.98) v2(157.66,92.78) v2(157.69,92.1) v2(157.73,40.46) v2(157.83,104.22) v2(158.05,76.6) v2(158.12,27.99) v2(158.09,9.23) v2(158.18,47.49) v2(158.25,46.25) v2(158.25,44.98) v2(158.44,32.54) v2(158.53,33.76) v2(158.68,80.74) v2(158.78,27.99) v2(159.09,100.1) v2(159.09,98.83) v2(159.09,97.56) v2(159.09,96.92) v2(159.09,95.65) v2(159.19,39.28) v2(159.47,31.25) v2(159.56,79.9) v2(159.64,39.61) v2(159.74,137.39) v2(159.83,40.14) v2(159.85,34.56) v2(159.85,33.29) v2(159.99,81.27) v2(160.1,132.23) v2(160.1,128.74) v2(160.1,128.17) v2(160.1,127.59) v2(160.1,126.96) v2(160.39,48.45) v2(160.4,47.28) v2(160.39,45.8) v2(160.63,9.23) v2(160.67,128.74) v2(160.67,128.17) v2(160.67,127.59) v2(160.67,126.96) v2(160.67,126.39) v2(160.67,125.82) v2(160.67,125.25) v2(160.78,71.47) v2(160.77,70.22) v2(160.78,31.16) v2(161.24,129.06) v2(161.24,128.42) v2(161.24,127.85) v2(161.24,127.28) v2(161.24,126.71) v2(161.24,126.13) v2(161.24,125.56) v2(161.24,124.99) v2(161.24,124.36) v2(161.28,80.06) v2(161.45,96.81) v2(162.28,137.39) v2(162.38,35.91) v2(162.38,32.83) v2(162.59,34.74) v2(162.62,31.79) v2(163.17,9.23) v2(163.58,40.69) v2(163.58,39.47) v2(163.66,81.32) v2(163.73,51.43) v2(163.68,48.56) v2(163.68,47.34) v2(163.68,45.44) v2(163.68,44.19) v2(163.88,34.33) v2(163.97,31.16) v2(164.82,137.39) v2(165.09,31.16) v2(165.33,7.33) v2(165.33,4.79) v2(165.87,48.28) v2(165.87,47.01) v2(165.87,45.62) v2(165.87,44.35) v2(166.11,131.75) v2(166.11,129.63) v2(166.11,127.51) v2(166.2,31.18) v2(166.29,39.94) v2(166.32,32.54) v2(166.95,21.12) v2(167.36,137.39) v2(167.52,21.12) v2(167.88,43.93) v2(167.88,3.83) v2(168.01,77.98) v2(168,45.77) v2(167.98,32.02) v2(168.23,131.75) v2(168.23,129.63) v2(168.23,127.51) v2(168.2,109.14) v2(168.15,33.9) v2(168.44,77.55) v2(168.48,108.61) v2(168.76,109.4) v2(168.83,77.16) v2(168.95,45.93) v2(168.99,108.86) v2(168.96,48.34) v2(168.98,47.17) v2(169.09,44.63) v2(169.23,101.38) v2(169.82,106.19) v2(169.8,105.6) v2(169.9,137.39) v2(170.35,131.75) v2(170.35,129.63) v2(170.35,127.51) v2(170.38,103.98) v2(170.42,3.83) v2(170.77,86.81) v2(171.61,85.75) v2(172.02,31.8) v2(172.44,137.39) v2(172.39,84.86) v2(172.42,32.19) v2(172.8,32.61) v2(172.88,106.45) v2(172.96,3.83) v2(173.23,84.02) v2(173.44,106.42) v2(174.09,111.45) v2(174.33,110.94) v2(174.91,110.64) v2(174.98,137.39) v2(175.12,111.16) v2(175.5,3.83) v2(175.97,100.6) v2(176.35,100.17) v2(176.4,100.96) v2(176.57,27.53) v2(176.84,100.54) v2(177,27.95) v2(177.23,133.9) v2(177.52,137.39) v2(178.04,3.83) v2(178.12,135.43) v2(178.12,132.37) v2(178.16,40.51) v2(178.83,107.71) v2(179.02,99.59) v2(179.27,108.07) v2(179.36,103.49) v2(179.44,99.99) v2(179.63,108.51) v2(179.88,135.43) v2(179.88,132.37) v2(179.94,103.5) v2(179.91,102.94) v2(179.96,101.93) v2(180.06,137.39) v2(180.58,3.83) v2(180.77,133.9) v2(181.19,100.08) v2(181.76,100.07) v2(182.6,137.39) v2(183.12,3.83) v2(184.05,100.63) v2(184.05,100.07) v2(184.05,99.51) v2(184.05,98.93) v2(184.61,105.92) v2(184.61,105.33) v2(184.61,102.96) v2(184.64,100.63) v2(185.14,137.39) v2(185.66,3.83) v2(187.68,137.39) v2(188.2,3.83) v2(188.35,100.69) v2(188.4,99.57) v2(188.79,101.04) v2(189.62,98.8) v2(189.67,37.3) v2(189.67,36.66) v2(189.79,45.18) v2(189.91,39.91) v2(190.22,137.39) v2(190.25,98.79) v2(190.32,40.35) v2(190.56,115.58) v2(190.73,40.76) v2(190.74,3.83) v2(191.16,41.16) v2(191.56,45.5) v2(191.98,101.12) v2(192.76,137.39) v2(193.28,3.83) v2(193.58,98.62) v2(193.58,61) v2(193.59,45.55) v2(193.81,57.89) v2(193.81,57.33) v2(194.14,61) v2(194.34,58.24) v2(194.34,57.64) v2(194.34,57.02) v2(194.41,104.24) v2(194.47,69.88) v2(194.47,69.32) v2(194.65,45.76) v2(194.91,58.47) v2(194.91,57.46) v2(195.3,137.39) v2(195.82,3.83) v2(196.04,79.37) v2(196.08,102.74) v2(196.08,101.94) v2(196.08,101.14) v2(196.06,78.6) v2(196.22,58.47) v2(196.22,57.46) v2(196.22,56.46) v2(196.68,43.01) v2(196.7,41.96) v2(196.91,104.97) v2(196.91,101.14) v2(196.91,100.34) v2(196.93,96.09) v2(196.9,78.54) v2(197.16,107.41) v2(197.22,44.61) v2(197.53,58.47) v2(197.53,57.46) v2(197.53,56.46) v2(197.84,137.39) v2(198.15,121.4) v2(198.15,120.8) v2(198.38,30.34) v2(198.36,3.83) v2(198.5,26.42) v2(198.64,112.35) v2(198.58,81.85) v2(198.74,105.26) v2(198.79,121.42) v2(198.75,120.81) v2(198.85,57.39) v2(198.85,56.46) v2(198.98,83.31) v2(198.98,82.72) v2(199.11,26.39) v2(199.21,113.98) v2(199.32,43.84) v2(199.32,42.5) v2(199.48,57.37) v2(199.48,56.82) v2(199.72,26.41) v2(199.79,30.26) v2(199.88,72.82) v2(199.88,72.24) v2(199.88,71.66) v2(199.88,71.07) v2(199.88,70.49) v2(200.11,62.33) v2(200.11,61.75) v2(200.11,61.16) v2(200.38,110.45) v2(200.56,31.04) v2(200.6,26.34) v2(200.74,62.33) v2(200.74,61.75) v2(200.74,61.16) v2(200.65,27.19) v2(200.88,42.59) v2(200.9,3.83) v2(200.99,113.75) v2(201,58.57) v2(201.08,100.34) v2(201.08,79.46) v2(201.12,57.94) v2(201.13,43.89) v2(201.25,46.81) v2(201.34,31.04) v2(201.34,26.39) v2(201.38,62.33) v2(201.38,61.75) v2(201.38,61.16) v2(201.45,60.47) v2(201.45,59.84) v2(201.45,59.2) v2(201.63,58.57) v2(201.68,57.94) v2(201.89,42.15) v2(202.01,62.33) v2(202.01,61.75) v2(202.01,61.16) v2(202.02,60.48) v2(202.02,59.84) v2(202.02,59.21) v2(202.11,31.04) v2(202.11,30.26) v2(202.1,27.23) v2(202.11,26.39) v2(202.27,80.11) v2(202.25,58.61) v2(202.27,57.94) v2(202.31,56.67) v2(202.39,82.91) v2(202.79,108.59) v2(202.8,63.84) v2(202.87,58.52) v2(202.87,57.51) v2(202.87,56.5) v2(202.89,31.04) v2(202.88,29.42) v2(202.89,28.71) v2(203.13,46.81) v2(203.44,3.83) v2(203.61,113.53) v2(203.66,31.04) v2(204.04,63.78) v2(204.19,58.52) v2(204.19,57.51) v2(204.19,56.5) v2(204.41,104.24) v2(204.44,31.04) v2(204.44,30.26) v2(204.44,26.39) v2(205.01,46.81) v2(205.21,30.26) v2(205.21,26.39) v2(205.46,137.39) v2(205.5,58.52) v2(205.5,57.51) v2(205.5,56.5) v2(205.57,73.35) v2(205.59,72.78) v2(205.59,72.18) v2(205.62,71.59) v2(205.62,71.02) v2(205.95,29.46) v2(205.98,3.83) v2(206.44,40.9) v2(206.54,30.32) v2(206.53,26.52) v2(206.81,57.44) v2(206.81,56.5) v2(206.89,46.81) v2(206.95,96.24) v2(207.43,57.26) v2(207.43,56.7) v2(207.54,96.24) v2(207.82,82.1) v2(208,137.39) v2(207.98,61.49) v2(208.28,58.7) v2(208.52,3.83) v2(208.58,99.52) v2(208.74,61.49) v2(208.73,42.31) v2(208.77,46.81) v2(208.89,58.7) v2(208.92,58.09) v2(209.23,42.92) v2(209.42,113.44) v2(209.41,104.14) v2(209.47,115.25) v2(209.5,61.49) v2(209.5,58.7) v2(209.5,58.06) v2(209.7,41.01) v2(210.14,58.7) v2(210.14,58.06) v2(210.23,104.17) v2(210.2,56.7) v2(210.26,103.54) v2(210.54,137.39) v2(210.52,31.81) v2(210.8,58.51) v2(210.8,57.51) v2(210.8,56.5) v2(211.06,42.97) v2(211.06,3.83) v2(211.21,71.71) v2(211.2,71.14) v2(211.69,64.82) v2(211.79,71.23) v2(211.91,106.14) v2(211.91,104.74) v2(212.12,58.51) v2(212.12,57.51) v2(212.12,56.5) v2(212.17,15.36) v2(212.26,112.95) v2(212.27,64.82) v2(212.6,120.76) v2(213.08,137.39) v2(213.2,121.4) v2(213.43,58.51) v2(213.43,57.51) v2(213.43,56.5) v2(213.44,15.34) v2(213.45,41.17) v2(213.56,107.77) v2(213.56,105.85) v2(213.6,3.83) v2(214.48,86.12) v2(214.59,112.54) v2(214.75,57.43) v2(214.75,56.5) v2(214.71,42.95) v2(214.73,16.03) v2(215.09,38.22) v2(215.12,31.47) v2(215.31,57.25) v2(215.31,56.69) v2(215.33,16.02) v2(215.44,42.98) v2(215.47,61.49) v2(215.62,137.39) v2(215.58,30.4) v2(215.93,58.26) v2(215.93,57.7) v2(215.92,16.02) v2(216.05,36.81) v2(216.06,61.49) v2(216.14,3.83) v2(216.2,113.5) v2(216.62,61.47) v2(216.57,58.26) v2(216.57,57.7) v2(216.98,99.44) v2(217.2,58.26) v2(217.2,57.7) v2(217.78,81.94) v2(218.16,137.39) v2(218.58,99.44) v2(218.68,3.83) v2(218.81,58.58) v2(219.38,74.54) v2(219.73,58.75) v2(220.18,99.44) v2(220.21,98.62) v2(220.18,96.95) v2(220.18,95.27) v2(220.7,137.39) v2(220.65,58.74) v2(220.78,92.77) v2(220.78,77.77) v2(221.22,3.83) v2(221.38,95.27) v2(221.38,93.62) v2(221.58,96.27) v2(221.61,80.27) v2(221.93,82.77) v2(223.24,137.39) v2(223.76,3.83) v2(224.61,45.38) v2(224.8,121.4) v2(224.8,120.8) v2(225.04,44.99) v2(225.4,121.4) v2(225.4,120.8) v2(225.47,44.57) v2(225.57,92.19) v2(225.78,137.39) v2(225.93,83.4) v2(226.14,57.03) v2(226.14,55.05) v2(226.32,86.62) v2(226.3,3.83) v2(227.07,83.14) v2(227.13,56.04) v2(227.42,92.6) v2(227.41,84.18) v2(227.52,86.62) v2(227.73,7.9) v2(228.12,57.03) v2(228.12,55.05) v2(228.32,137.39) v2(228.62,9.43) v2(228.62,6.37) v2(228.74,86.62) v2(228.84,3.83) v2(229.18,73.14) v2(230.38,9.43) v2(230.38,6.37) v2(230.81,92.08) v2(230.86,137.39) v2(231.27,7.9) v2(231.38,3.83) v2(231.71,46.38) v2(232.26,46.18) v2(232.25,45.63) v2(232.26,45.07) v2(233.05,6.06) v2(233.05,5.5) v2(233.4,137.39) v2(233.36,102.07) v2(233.92,3.83) v2(234.02,135.41) v2(235.15,132.46) v2(236.46,3.83) v2(237.02,130.84) v2(237.02,128.3) v2(237.02,125.76) v2(237.02,123.22) v2(237.02,120.68) v2(237.02,118.14) v2(237.2,11.53) v2(237.2,9.34) v2(237.74,115.11) v2(237.82,27.14) v2(238.29,10.43) v2(238.75,20.36) v2(238.75,19.77) v2(238.75,18.78) v2(238.76,18.17) v2(239,3.83) v2(239.08,112.9) v2(239.38,11.53) v2(239.38,9.34) v2(239.56,42.81) v2(240.12,42.8) v2(240.11,41.68) v2(240.15,26.82) v2(240.17,26.27) v2(240.45,54.33) v2(240.45,53.17) v2(240.72,27.02) v2(240.71,26.42) v2(240.86,111.06) v2(241.3,26.38) v2(241.44,27.49) v2(241.43,26.93) v2(241.45,53.75) v2(241.54,3.83) v2(242.02,27.49) v2(242.02,26.93) v2(242.42,42.32) v2(242.45,54.33) v2(242.45,53.17) v2(242.6,27.49) v2(242.6,26.93) v2(242.87,14.99) v2(243.09,109.62) v2(243.45,14.99) v2(244.02,42.59) v2(244.04,14.99) v2(244.08,3.83) v2(245.61,108.73) v2(245.67,42.2) v2(246.62,3.83) v2(246.7,59.6) v2(246.69,58.96) v2(246.69,58.33) v2(246.69,57.7) v2(246.69,57.03) v2(246.96,42.2) v2(246.97,8.34) v2(247.54,42.2) v2(247.55,8.34) v2(248.14,8.34) v2(248.47,108.46) v2(248.94,8.29) v2(249.16,3.83) v2(249.45,27.67) v2(249.52,8.29) v2(249.52,7.72) v2(249.64,33.62) v2(249.68,33.07) v2(250.11,8.29) v2(250.11,7.72) v2(250.16,33.84) v2(250.32,107.99) v2(250.26,33.07) v2(250.53,105.81) v2(250.66,33.6) v2(250.69,8.29) v2(250.69,7.72) v2(250.83,33.07) v2(251.26,33.58) v2(251.48,33.07) v2(251.51,3.92) v2(251.84,33.59) v2(252.04,33.07) v2(252.1,39.54) v2(252.67,105.47) v2(252.68,39.54) v2(253.4,68.9) v2(253.77,97.94) v2(254.03,95.11) v2(254.04,87.56) v2(254.04,85.3) v2(254.25,90.57) v2(254.19,82.73) v2(254.21,4.43) v2(254.31,39.52) v2(254.5,92.76) v2(254.55,80.03) v2(254.7,71.16) v2(254.7,66.65) v2(254.8,13.86) v2(255.06,77.44) v2(255.16,72.31) v2(255.38,100.49) v2(255.38,13.86) v2(255.67,105.34) v2(255.67,102.98) v2(255.85,74.58) v2(255.97,39.94) v2(255.97,13.86) v2(256.35,43.07) v2(256.56,39.94) v2(256.55,13.86) v2(256.75,4.43) v2(257.3,66.65) v2(258.31,62.87) v2(258.27,42.92) v2(258.4,41.3) v2(259.32,3.83) v2(260,46.81) v2(260,46.23) v2(260.01,41.93) v2(260.28,60.8) v2(260.36,65.08) v2(260.58,46.81) v2(260.58,46.23) v2(261.17,46.81) v2(261.17,46.23) v2(261.75,46.81) v2(261.75,46.23) v2(261.8,41.54) v2(261.86,3.83) v2(262.23,41.93) v2(262.33,46.81) v2(262.33,46.23) v2(262.95,61.57) v2(263.68,21.77) v2(264.26,21.77) v2(264.25,20.57) v2(264.4,3.83) v2(264.85,21.77) v2(265.26,19.28) v2(265.46,58.8) v2(265.73,52.9) v2(265.84,19.28) v2(266.32,44.51) v2(266.33,41.15) v2(266.62,54.43) v2(266.62,51.37) v2(266.6,42.88) v2(266.76,45.76) v2(266.9,44.51) v2(266.92,41.15) v2(266.94,3.83) v2(267.51,56.9) v2(268.38,54.43) v2(268.38,51.37) v2(269.27,52.9) v2(269.48,3.83) v2(269.76,13.44) v2(269.79,12.88) v2(270.34,13.44) v2(270.38,12.88) v2(270.92,13.44) v2(270.96,12.88) v2(271.4,53.94) v2(271.51,13.44) v2(271.54,12.88) v2(272.02,3.83) v2(272.19,13.44) v2(272.23,12.88) v2(272.78,13.44) v2(272.81,12.88) v2(272.97,51.84) v2(273.36,13.44) v2(273.4,12.88) v2(273.87,49.42) v2(273.98,12.88) v2(274.38,39.1) v2(274.56,3.83) v2(275,39.1) v2(275.64,37.95) v2(276.44,48.3) v2(277.1,3.83) v2(278.74,45.24) v2(278.74,44.65) v2(279.24,44.96) v2(279.33,48.99) v2(279.64,3.83) v2(281.15,5.03) v2(281.41,49.22) v2(284.41,48.41) v2(284.92,23.2) v2(284.92,22.6) v2(284.93,21.99) v2(284.93,21.4) v2(285.4,20.95) v2(285.49,21.64) v2(285.84,20.51) v2(285.98,21.16) v2(286.29,20.09) v2(286.43,20.69) v2(286.79,47.96) v2(287.26,3.83) v2(289.3,47.63) v2(289.8,3.83) v2(291.92,47.48) v2(292.34,3.83) v2(293.05,23.2) v2(293.05,19.27) v2(293.93,7.9) v2(294.52,47.47) v2(294.82,9.43) v2(294.82,6.37) v2(294.88,3.83) v2(295.02,21.23) v2(295.02,19.27) v2(296.58,9.43) v2(296.58,6.37) v2(296.98,23.2) v2(296.98,19.27) v2(297.06,47.47) v2(297.42,3.83) v2(297.47,7.9) v2(299.22,10.29) v2(299.6,47.47) v2(299.96,3.83) v2(300.7,9.25) v2(301.02,10.42) v2(301.43,34.29) v2(301.43,33.62) v2(301.49,3.83) v2(302.14,47.47) v2(302.67,17.21) v2(304.22,37.49) v2(304.3,38.58) v2(304.61,17.49) v2(304.68,47.47) v2(304.77,19.28) v2(305.06,37.25) v2(305.89,39.58) v2(305.88,33.9) v2(305.88,33.28) v2(306.21,19.16) v2(306.19,17.06) v2(307.07,3.83) v2(307.22,47.47) v2(307.37,23.72) v2(307.43,21.95) v2(308.14,20.42) v2(308.14,14.09) v2(309.16,25.45) v2(309.26,27.77) v2(309.76,47.47) v2(310.12,3.83) v2(311.94,29.69) v2(312.24,47.47) v2(312.64,3.83) v2(313.17,46.79) v2(313.17,44.25) v2(313.17,41.71) v2(313.17,39.17) v2(313.17,36.63) v2(313.17,34.09) v2(313.17,31.55) v2(313.17,29.01) v2(313.17,26.47) v2(313.17,23.93) v2(313.17,21.39) v2(313.17,18.85) v2(313.17,16.31) v2(313.17,13.77) v2(313.17,11.23) v2(313.17,8.69) v2(313.17,6.15) v3(12.45,9.84) v3(14.61,124.93) v3(15.38,100.58) v3(31.25,50.86) v3(48.68,41.48) v3(60.03,7.71) v3(60.18,7.72) v3(75.73,8.93) v3(79.27,44.51) v3(109.31,93.29) v3(119.89,88.53) v3(140.84,128.05) v3(144.66,121.96) v3(166.79,76.88) v3(167.89,130.16) v3(174.88,112.04) v3(193.45,63.51) v3(195.29,79.37) v3(227.28,55.45) v3(237.2,20.04) v3(238.29,11.49) v3(246.79,7.77) v3(250.91,34.19) v3(257.75,39.7) v3(260.65,45.3) v3(261.54,45.18) v3(273.65,12.33) v3(274.5,38.28) v3(286.9,21.23) v6(236.76,22.71) v6(236.76,22.1) v6(236.76,21.49) v6(236.78,20.85) v6(236.78,19.02) v6(236.78,18.36) v6(237.39,21.13) v6(237.42,18.92)
