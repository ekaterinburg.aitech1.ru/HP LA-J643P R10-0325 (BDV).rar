# Allegro board LAJ643PR10-0325.brd (continued)
## Nets (continued)
USB3_PTX_C_DRX_N1: CS34.1 RS27.1
USB3_PTX_C_DRX_P1: CS29.1 RS28.1
USB3_PTX_C_MRX_N4: CT288.1 UT11.7
USB3_PTX_C_MRX_P4: CT287.1 UT11.8
USB3_PTX_DRX_N1: CS34.2 UH1.F9
USB3_PTX_DRX_N2: JIO1.10 UH1.C3
USB3_PTX_DRX_N3: JIO1.16 UH1.F11
USB3_PTX_DRX_P1: CS29.2 UH1.F7
USB3_PTX_DRX_P2: JIO1.11 UH1.D4
USB3_PTX_DRX_P3: JIO1.17 UH1.G12
USB3_PTX_MRX_N4: CT288.2 UH1.B14
USB3_PTX_MRX_P4: CT287.2 UH1.C14
USB3_PTX_R_DRX_N1: DS6.4 DS6.7 JUSB3.8 RS27.2
USB3_PTX_R_DRX_P1: DS6.5 DS6.6 JUSB3.9 RS28.2
USB20_N1: UH1.J3 US2.2
USB20_N1_C: DS5.2 JUSB3.2 LS9.3
USB20_N2: JIO1.23 UH1.N13
USB20_N3: JIO1.26 UH1.K4
USB20_N4: ML11.4 UH1.M10 UU4.53
USB20_N4_L: DU3.5 DU3.6 JUSBC1.A7 JUSBC1.B7 ML11.3
USB20_N5: L1.1 UH1.M1
USB20_N5_R: D507.3 JEDP1.9 L1.2
USB20_N6: TH146.1(TP-1) UH1.K7
USB20_N9: TH148.1(TP-1) UH1.M6
USB20_N14: JWLAN1.5 UH1.E5
USB20_P1: UH1.J2 US2.3
USB20_P1_C: DS5.3 JUSB3.3 LS9.2
USB20_P2: JIO1.22 UH1.N15
USB20_P3: JIO1.25 UH1.K3
USB20_P4: ML11.1 UH1.L9 UU4.50
USB20_P4_L: DU3.4 DU3.7 JUSBC1.A6 JUSBC1.B6 ML11.2
USB20_P5: L1.4 UH1.L2
USB20_P5_R: D507.2 JEDP1.8 L1.3
USB20_P6: TH145.1(TP-1) UH1.K6
USB20_P9: TH147.1(TP-1) UH1.N8
USB20_P14: JWLAN1.3 UH1.F6
USB_CHARGE_EN: RS16.1 UK1.36
USB_CHARGE_EN_R: RS16.2 US2.5
USB_CTL1: RS41.2 UK1.84 US2.6
USB_CTL2: RS42.2 UK1.72 US2.7
USB_CTL3: RK28.2 UK1.38 US2.8
USB_IN_STATUS#: RS43.2 UK1.108 US2.9
USB_OC0#: RH217.1 RS10.1 UH1.AH36
USB_OC1#: RH215.1 UH1.AL40
USB_OC2#: RH214.1 UH1.AJ44
USB_OC3#: RH216.1 UH1.AL41
USB_OC4#: RH218.1 UH1.AV47
USB_OC5#: RH219.1 UH1.AR35
USB_OC6#: RH220.1 UH1.AR37
USB_OC7#: RH221.1 UH1.AV43
USB_ON#: JIO1.27 UK1.121
VCIN0_PH: PH1.1 PR9.2 UK1.109
VCIN1_AC_IN: R4960.1 UK1.27
VCIN1_AC_IN_R: R4960.2 R5094.2 UK1.110
VCIN1_ACOK: PRB23.2 PRB25.1 PUB01.2 R5094.1
VCIN1_PH: PH2.1 PR10.2 UK1.102
VGA_ALERT: RG397.2 UG1.M2
VGA_CORE_EN: CG197.2 DG4.1 PRV14.2 RG105.2
VGA_GATE: CG46.1 QG1.5 UG8.4
VGA_I2CS_SCL: QG2.4 RG36.1 UG1.T4
VGA_I2CS_SDA: QG2.1 RG35.1 UG1.T3
VGA_OVERT#: QG1.4 RG396.2 UG1.M1
VR_HOT#: CK11.2 PRZ5.2 PRZ14.2 RK8.1
VR_ON: PRZ26.2 UK1.85
VR_PWRGD: PRZ18.2 PUZ1.45 UK1.71
VRAM_VDD_CTL: PRW12.1 PRW14.1 UG1.L3
VRAM_VREF_CTL: QG3.2 QG4.2 RG401.2 UG1.L1
VREF: CA19.1 CA20.1 UA1.38
VSN_1PH: PCZ1.2 PRZ10.2 PUZ1.51
VSN_2PH: PCZ15.1 PRZ32.1 PUZ1.37
VSN_4PH: PCZ13.2 PRZ28.2 PUZ1.2
VSP_1PH: PCZ7.2 PRZ12.2 PUZ1.52
VSP_2PH: PCZ14.1 PRZ31.1 PUZ1.38
VSP_4PH: PCZ12.2 PRZ25.2 PUZ1.1
VTTREF_DDR: PCM15.1 PUM1.4
WAKE#: QR2.1 QWL1.1 RH171.1 UH1.BB47
WL_OFF#: JWLAN1.48 RH180.2 UH1.AW24
WL_PWREN_EC#: RWL30.2 UK1.98
WL_WAKE#: JWLAN1.47 QWL1.3 RWL4.2
XCLK_BIASREF: RH20.2 UH1.T3
XDP_BPM#0: TC295.1(TP-1) UC1.BR27
XDP_BPM#1: TC296.1(TP-1) UC1.BT27
XDP_BPM#2: TC101.1(TP-1) UC1.BM31
XDP_BPM#3: TC100.1(TP-1) UC1.BT30
XDP_ITP_PMODE: RC383.2 UH1.AL3
XDP_PRDY#: UC1.BP27 UH1.AM5
XDP_PREQ#: UC1.BL30 UH1.AL2
XGND: RL55.1 TSL1.25
XTAL_24M_PCH_IN: CH5.1 RH16.2 RH18.1 YH1.1
XTAL_24M_PCH_IN_R: RH18.2 UH1.U10
XTAL_24M_PCH_OUT: CH4.1 RH16.1 RH17.1 YH1.3
XTAL_24M_PCH_OUT_R: RH17.2 UH1.U9
XTAL_OUTBUFF: RG9.1 UG1.J4
XTAL_SSIN: RG11.1 UG1.H1
XTALIN: CG2.1 UG1.H3 YG1.3
XTALOUT: RG80.2 UG1.H2
XTALOUT_R: CG1.1 RG80.1 YG1.1
XTLI: CL25.2 RL7.2 UL1.28 YL1.1
XTLO: CL24.2 RL7.1 RL57.2 YL1.3
XTLO_R: RL57.1 UL1.29
N15156561: PCV26.1 PCV92.1 PCV93.1 PRV27.2 PUV2.8
N15160747: PCV18.1 PRV16.1 PRV18.2
N16789346: TC55.1(TP-1) UC1.BP1
N16789364: TC57.1(TP-1) UC1.B38
N16789382: TC59.1(TP-1) UC1.B2
N16789430: TC25.1(TP-1) UC1.E2
N16789448: TC26.1(TP-1) UC1.E1
N16789466: TC24.1(TP-1) UC1.D1
N16789484: TC27.1(TP-1) UC1.BR1
N16865170: TC94.1(TP-1) UC1.AU13
N16865242: TC95.1(TP-1) UC1.AY13
N16884472: TC51.1(TP-1) UC1.C38
N16884473: TC52.1(TP-1) UC1.C1
N16884474: TC53.1(TP-1) UC1.BR2
N16884482: TC29.1(TP-1) UC1.BT2
N16886077: TH1.1(TP-1) UH1.Y14
N16886097: TH2.1(TP-1) UH1.Y15
N16889098: TH4.1(TP-1) UH1.U35
N16889099: TH5.1(TP-1) UH1.N32
N16889100: TH6.1(TP-1) UH1.R32
N16889101: TH7.1(TP-1) UH1.AH15
N16889102: TH8.1(TP-1) UH1.AH14
N16889103: TH3.1(TP-1) UH1.U37
N16892256: TH11.1(TP-1) UH1.AN35
N16892639: TH19.1(TP-1) UH1.AW48
N16925558: TH74.1(TP-1) UH1.BE33
N16937432: CWL1.1 JWLAN1.6 RWL3.1
N16940119: TH122.1(TP-1) UH1.AL15
N16957386: C407.1 U11.6
N16983076: DH4.1 RC81.2 RC82.2 RH260.1
N16995670: PCV16.1 PRV7.2 PRV10.2 PRV11.1
N16995962: PRV29.2 PUV1.16
N17092107: PRV13.2 PRV15.1
N17105073: TH101.1(TP-1) UH1.AL35
N17435076: QH2.1 RH117.2
N17571862: PCW5.1 PQW3.2 PRW14.2
N17571879: PQW3.1 PRW8.2
N17571903: PRW7.2 PRW9.2 PRW10.1 PRW15.1
N17572010: PCW2.1 PRW2.2
N17572050: PCW4.2 PRW7.1
N17572133: PRW3.1 PRW16.1 PUW1.5
N17825974: TH4942.1(TP-1) UH1.AH47
N17825990: TH4943.1(TP-1) UH1.AH48
N18049479: TH4954.1(TP-1) UH1.BB24
N18049493: TH4956.1(TP-1) UH1.AP24
N18049500: TH4957.1(TP-1) UH1.BA24
N18051110: TH4968.1(TP-1) UH1.AV6
N19357453: QWL3.1 RWL7.1 RWL30.1 RWL31.2
N19377972: QWL2.2 RWL7.2
N20648577: PC1010.1 PU1001.16 PU1001.17
N20648709: PC1008.2 PR1020.1
N21429485: PCH6.2 PRH6.1
N21761451: CV49.1 RV48.2
N21819668: QV7.6 RV52.2
N21917236: PCZ1.1 PCZ4.2 PRZ9.2 PRZ10.1
N21917296: PCZ4.1 PRZ11.2 PRZ12.1 PRZ16.1
N21981722: PDB02.2 PRB17.2
N21981818: PDB02.3 PRB43.2
N22086953: PHZ5.1 PRZ75.2 PRZ78.1
N22096717: PHZ4.1 PRZ74.2 PRZ77.1
N22407346: PLZ2.3 PRZ84.1
N22407630: PLZ1.3 PRZ81.1
N22480039: PLZ3.3 PRZ87.1
N22480324: PLZ4.3 PRZ90.1
N22481576: PCA7.1 PRA3.2
N22481729: PLG1.3 PRG3.1
N23058063: QG55.2 RG114.1 UG28.4
N23083473: PJPB1.7 PR21.1
N23083645: PJPB1.5 PR14.1
N23083647: PJPB1.8 PR17.1
N23083649: PJPB1.6 PR15.1
N23332881: PQ1.2 PQ2.5 PQ2.6 PR18.2 PR20.1
N23332897: PQ2.3 PR19.2
N23332925: PQ1.1 PR22.2
N23572335: PCZ18.2 PRZ37.2 PUZ1.3
N23773631: RV19.1 UV2.35
N24329755: RR10.1 UR1.9
N24329881: RR11.1 UR1.28
N24337743: CA29.1 RA19.2 RA20.1
N24338104: QA2.2 RA25.2
N24626028: CD82.2 RD29.2
N24676202: PQB02.2 PRB01.2 PRB02.1
N25261682: QC11.5 RH252.1
N25355771: R5798.1 U9.2
N25359800: CS108.1 QS1.6 RS39.1 US3.4
N25359816: RS10.2 US2.13
N25359920: RS14.2 US2.16
N25359932: RS13.2 US2.15
N25488166: CG335.1 UG27.12
N25488171: CG336.1 UG27.10
N25488216: QG17.6 RG391.1
N25528173: QG56.2 RG395.1 UG29.4
N25943161: CD15.2 RD11.2
N26573576: RG404.2 UG1.AD6
N26746335: R5807.2 U12.3
N26747017: R5804.1 U12.5
N26747180: R5806.1 U12.4
N27182711: PCZ22.1 PRZ42.2
N27734948: T165.1(TP-1) UU4.21
N27734950: T166.1(TP-1) UU4.22
N27734952: T167.1(TP-1) UU4.23
N27734954: T162.1(TP-1) UU4.31
N27734984: T155.1(TP-1) UU4.42
N27734986: T156.1(TP-1) UU4.43
N27734988: T158.1(TP-1) UU4.49
N27734990: T161.1(TP-1) UU4.48
N27735020: T154.1(TP-1) UU4.41
N27735022: T153.1(TP-1) UU4.40
N27735038: T159.1(TP-1) UU4.54
N27735040: T160.1(TP-1) UU4.55
N27740851: UU4.8 UU4.15 UU4.19 UU4.58
N27779968: D513.1 JSSD1.10
N27801570: UU4.7 UU4.52 UU4.56 UU4.57
N28152235: PCZ14.2 PCZ15.2 PRZ32.2 PRZ33.1
N28152401: PCZ31.2 PRZ55.2 PUZ1.15
N28152465: PCZ23.1 PRZ40.1 PUZ1.36
N28152469: PRZ57.1 PUZ1.24
N28152784: PCZ33.1 PRZ56.2 PUZ1.16
N28152958: PHZ1.2 PRZ46.2 PRZ50.1
N28153073: PHZ2.2 PRZ2.1
N28153589: PRZ26.1 PUZ1.43
N28153954: PCZ19.1 PRZ38.2
N28154016: PCZ12.1 PCZ13.1 PRZ27.2 PRZ28.1
N28154283: PHZ3.2 PRZ45.2 PRZ49.1
N28180064: PCZ10.1 PRZ22.2
N28185893: PCZ20.1 PRZ39.2
N28185971: PCZ17.1 PRZ35.2
N28452300: RV135.1 UC3.4
N28452491: RV136.2 UC3.6
N28587479: RA55.1 UA1.5
N28622063: D517.2 U4019.3
N28622074: R125.1 U4019.6
N28622080: Q32.1 R13.1 U4019.7
N28622090: R124.1 U4019.2
N28781721: QG16.1 RG40.2
N29132963: RV18.1 UV2.36
N29227301: PCZ7.1 PRZ16.2
N29270156: CG2818.1 RG14.2 RG407.2 UG2.5
N29645650: RA56.2 UA1.4
N29662755: QC10.6 RH261.1
N29662764: QC10.3 RH262.1
N29905583: JWLAN1.42 RWL5.1
N30629862: RH272.1 UH1.BD21
N31026763: QG57.1 RG3019.2
N31140794: CC392.1 UC4.12
N41203729: CC393.1 UC4.10
N52218840: PRZ47.2 PUZ1.27
N64766033: RV11.2 UV2.37
N65230032: RV31.2 RV33.1 UV3.6
N80922351: PCF1.2 PJF1.2 PUF1.4
N80922387: PCF6.1 PRF3.2
N99531586: JKB1.29 R5238.2
N99531588: JKB1.28 R5237.2
N100118189: CL2.2 DL1.3 RL58.2 RL59.2 RL60.2 RL61.2
N108444806: C404.1 U10.10
N108444906: C403.1 U10.12
N113120205: RG5.1 UG1.R2
N113120207: RG6.1 UG1.R3
N113204452: RG59.1 UG4.J1
N113204609: RG57.1 UG4.J10
N113204711: RG60.1 UG5.J10
N113205003: RG55.2 UG5.J1
N113272266: RG73.1 UG6.J10
N113272493: RG75.1 UG6.J1
N113273868: RG71.1 UG7.J10
N113274261: RG69.2 UG7.J1
N121190088: RG86.1 UG1.R7
N121190090: RG85.1 UG1.R6
N121269248: CG190.1 RG63.2 RG95.2
N121271262: CG191.1 RG62.2 RG96.2
N121271857: CG192.1 RG97.2 RG98.2
N121272457: CG193.1 RG76.2 RG77.2
N121863790: QG8.5 QG8.6 RG111.2
N125363899: RG381.2 UG1.AF8

Pads without a net: D3 2; DV1 5 6; FD1 1; FD2 1; FD3 1; FD4 1; JDIMM1 87 88 91 92 95 97 100 101 104 105 162 165; JDIMM2 87 88 91 92 95 97 100 101 104 105 162 165; JEDP1 3 4 15 16 37; JHDD1 4 5; JHDMI1 13 14; JKB1 30 31; JPWR1 6; JSSD1 6 8 20 22 24 26 28 30 32 34 36 40 42 44 46 48 54 56 58 59 60; JWLAN1 8 12 13 16 19 20 34 36 38 40 50 52 54 58 60 62; PJP1 7; PU301 10 15; PU1001 9 10 12; PU1801 5; PUB01 8; PUH1 9 10 12; U9 11; U4019 5; UA1 1 6 7 8 9 10 11 12 29 35 36; UC1 A19 A21 A23 A25 A27 AA14 AD2 AD4 AE1 AE5 AE9 AE10 AE11 AE29 AF10 AJ8 AJ10 AJ11 AK3 AL1 AL2 AL3 AM10 AM11 AP14 AP29 AT3 AT5 AT7 AT11 AT13 AW7 AW8 AW9 AW10 AW11 AW13 AY1 AY2 AY3 AY4 AY5 AY7 AY8 AY9 AY10 AY11 B18 B19 B20 B21 B22 B23 B24 B25 B27 B30 B33 B34 B36 BA1 BA2 BA3 BA4 BA5 BH30 BJ28 BK28 BL31 BL34 BM19 BN22 BN23 BN27 BN28 BN33 BN35 BP19 BP22 BP23 BR19 BR22 BR23 BR31 BR35 BT19 BT22 BT23 C18 C20 C22 C24 C30 C33 C34 D19 D21 D23 D25 D27 D34 E18 E19 E20 E21 E22 E23 E24 E25 E26 E27 E30 E33 E36 E37 F18 F20 F22 F24 F26 F30 F33 F34 F35 F37 G3 G13 G38 H24 H33 H34 H36 H37 J3 J24 J34 J35 J37 J38 K36 K37 N29 R14; UC2 1; UG1 A9 A26 A27 A30 AC6 AC28 AD4 AD5 AE3 AE4 AF1 AF2 AF3 AF4 AF5 AF30 AF32 AG1 AG7 AG10 AG12 AG20 AG23 AG26 AH6 AH8 AH9 AH20 AH23 AH31 AJ4 AJ5 AJ6 AJ8 AJ9 AJ11 AJ20 AJ21 AJ23 AJ24 AJ26 AJ28 AJ31 AJ32 AJ33 AK2 AK3 AK4 AK5 AK6 AK8 AK9 AK20 AK21 AK22 AK23 AK24 AK25 AK26 AK31 AL3 AL4 AL6 AL7 AL8 AL9 AL10 AL11 AL22 AL25 AM1 AM2 AM3 AM4 AM5 AM6 AM7 AM8 AM9 AM21 AM23 AM24 AM26 AM27 AM34 AN2 AN3 AN5 AN6 AN8 AN9 AN21 AN23 AN24 AN26 AN27 AP3 AP5 AP6 AP8 AP9 AP20 AP21 AP23 AP24 AP26 AP27 B2 B6 B23 C6 C15 D6 D7 D9 D19 D20 D22 D23 D26 D28 E4 E26 E34 F26 G14 G20 H6 H30 H31 J30 J31 J32 J33 K3 K4 L2 M4 M5 M6 M30 M34 N4 N8 P1 P2 P3 P8 R4 R5 R28 V32; UG4 A5 A10 U5 U10; UG5 A5 A10 U5 U10; UG6 A5 A10 U5 U10; UG7 A5 A10 U5 U10; UH1 A17 A22 A25 A42 A44 AA1 AA45 AB48 AC6 AC7 AC9 AC11 AC14 AC15 AC39 AC41 AC43 AC44 AC48 AD47 AD48 AE9 AE11 AE39 AE41 AE44 AE47 AE48 AF47 AF48 AG45 AH41 AH46 AJ6 AJ7 AK47 AM7 AM43 AM46 AM48 AN4 AN18 AN37 AN40 AN47 AP2 AP3 AP21 AP41 AP47 AP48 AR18 AR42 AR48 AT10 AU46 AU47 AV7 AV13 AV16 AV18 AW2 AW3 AW15 AW18 B15 B17 B18 B19 B21 B23 B24 B25 B26 B27 B42 B44 BA20 BB16 BB20 BC1 BC17 BC33 BD8 BD17 BD34 BD38 BE8 BE9 BE14 BE15 BE17 BE18 BE19 BE29 BE34 BF8 BF9 BF14 BF17 BF18 BF19 BF29 BF31 BF33 BF36 BG8 C15 C16 C17 C18 C19 C20 C21 C23 C24 C26 C27 C42 C44 D20 D21 D29 D42 D43 E28 F14 F16 F20 F24 F26 F46 G1 G2 G4 G5 G14 G17 G20 G24 G26 G45 G46 G47 G48 G49 H2 H3 H47 H48 J13 J18 J21 J24 K13 K18 K21 K29 K43 K44 L3 L4 L24 L26 L46 L47 L48 M26 M29 M44 M45 N2 N3 N18 N42 N47 N48 P9 P21 P24 P41 P47 P48 R10 R13 R15 R18 R21 R24 R35 R37 R40 R44 R46 T1 T2 T43 T45 T46 U2 U3 U13 U40 U41 U47 U48 V2 V3 V47 V48 W3 W4 W6 W7 W43 W44 W46 W47 Y2 Y35 Y36 Y40 Y41 Y46 Y47 Y48; UL2 3; UR1 13 22 23 24 25 26 31; UT1 3 4 5 10 11 12 13 15 25 26 27 28 29 30 31; UU4 29; UV1 5; UV2 2 4 9 10 12 25 26; UV3 5; YG1 2 4; YL1 2 4

## Via types
v1: diameter 0.305, hole 0.152, TOP to BOTTOM, 658 vias
v2: diameter 0.457, hole 0.203, TOP to BOTTOM, 8274 vias
v3: diameter 0.406, hole 0.203, TOP to BOTTOM, 217 vias
v4: diameter 0.757, hole 0.378, TOP to BOTTOM, 39 vias
v5: diameter 0.884, hole 0.442, TOP to BOTTOM, 17 vias
v6: diameter 0.508, hole 0.254, TOP to BOTTOM, 69 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
1.0VSDGP_ON:
  vias: v1(179.37,101)
1.0VSDGPU_EN: length 125.2
  TOP w0.127: v2(238.52,46.18) v3(239.18,46.18)
  IN1 w0.127: v2(232.1,46.84) 233.99,46.84 234.59,47.44 236.65,47.44 237.76,48.54 238.15,48.54 239.02,47.67 239.02,46.55 238.64,46.18 v2(238.52,46.18) ; v2(188.23,97.89) 182.13,103.99 178.92,103.99 v2(178.82,104.09)
  IN3 w0.127: v2(232.1,46.84) 232.09,46.85 231.58,46.85 231.21,46.48 231.21,44.42 230.23,43.44 222.59,43.44 219.95,46.08 210.09,46.08 204.23,51.95 201.39,51.95 200.81,52.52 195.44,52.52 192.85,55.12 192.85,68.61 193.96,69.72 193.96,70.21 194.42,70.67 194.42,76.81 195.6,78 195.6,82.99 196.07,83.46 196.07,83.97 197.16,85.06 197.16,86.24 196.91,86.49 195.29,86.49 195.06,86.72 191.4,86.72 189.28,88.84 189.28,92.86 187.87,94.27 187.87,97.53 v2(188.23,97.89)
  BOTTOM w0.127: PRF1.1 v2(178.82,104.09) ; DG5.2 238.77,43.25 239.05,43.54 RG103.2 CG196.2 239.05,45.65 v2(238.52,46.18)
1.8VSDGPU_MAIN: length 11.3
  BOTTOM w0.127: RG108.2 235.71,46.94 236.14,47.37 236.53,47.37 v1(236.67,47.23) ; RG108.2 235.23,47.41 233.89,47.41 232.95,46.47 232.95,44.78 232.15,43.99 232.15,43.14 231.07,42.06 QG7.3 ; RG108.2 235.7,46.57 235.67,46.53 UG10.1
1.8VSDGPU_MAIN_EN: length 86.9
  TOP w0.102: v2(209.44,81.1) 209.81,80.72 209.81,80.03 209.6,79.81 209.6,78.83 210.3,78.13 210.3,77.6 210.43,77.46 210.43,76.73 211.91,75.26 213.59,75.26 214.11,74.74 214.11,74.44 214.48,74.07
  TOP w0.127: 214.48,74.07 214.48,72.75 216.52,70.71 v3(218.03,70.71) 218.93,70.71 219.15,70.48 222.86,70.48 226.27,67.08 226.27,63.36 225.36,62.45 224.25,62.45 223.91,62.12 RG403.2 224.37,61.91 v2(224.53,62.06)
  IN1 w0.127: v2(236.66,56.49) 236.66,57.63 234.07,60.21 227.09,60.21 225.24,62.06 v2(224.53,62.06)
  BOTTOM w0.127: 235.29,49.19 235.84,49.19 237.32,47.71 238.4,47.71 239.5,46.6 239.5,43.43 239.02,42.95 239.02,42.19 239.43,41.78 239.43,38.88 239.72,38.59 241.94,38.59 242.24,38.89 242.24,39.72 242.6,40.08 243.04,40.08 RG179.2 ; 235.29,49.19 232.68,46.58 232.68,44.89 231.89,44.1 231.89,43.25 231.29,42.64 230.11,42.64 229.8,42.33 QG7.2 ; 235.29,49.19 235.29,50.2 235.44,50.34 235.44,53.76 236.39,54.71 236.39,56.22 v2(236.66,56.49) ; UG1.P7 v2(209.44,81.1)
  BOTTOM w0.203: RG179.2 243.32,40.79 243.62,41.09 UG27.5
1.8VSDGPU_MAIN_EN#: length 11.4
  BOTTOM w0.127: RG106.2 233.28,42.73 v1(231.98,41.43) 231.33,40.79 230.23,40.79 229.8,40.36 QG7.5 229.8,39.85 229.62,39.68 229.28,39.68 229.15,39.81 QG7.6 224.92,40.16 QG57.2
1.35VS_DGPU_EN: length 3.9
  BOTTOM w0.254: PUW1.3 v2(241.45,56.32) 241.45,56.96 PCW1.1 241.44,57.15 240.73,57.86 PRW6.1 PRW5.1
1.35VS_DGPU_FB: length 6.3
  BOTTOM w0.254: PRW8.1 242.21,57.31 242.27,57.31 PRW10.2 PCW4.1 243.18,57.29 PRW11.1 244,56.87 243.78,56.64 v2(242.79,56.64) 241.95,55.8 PUW1.4
1.35VSDGPU_PWR_EN: length 9.6
  TOP w0.127: v2(238.95,58.68) v3(238.95,57.9) 238.95,56.93 237.62,55.59 237.62,52.17 RG12.1 237.31,51.86 237.31,51.51 DG3.1
  BOTTOM w0.127: PRW5.2 v2(238.95,58.68)
1V8_AON_EN_R: length 3.9
  BOTTOM w0.127: RG148.2 245.95,38.89 DG1.1 245.86,39.87 CG269.1 245.11,40.49 v2(244.9,40.69) 244.42,41.18 UG27.3
1VSDGPU_PG: length 121.3
  TOP w0.127: v2(238.6,46.76) 238.82,46.98 v1(238.82,48.07) 238.82,49.36 DG3.3
  IN2 w0.127: v2(190.15,77.92) 189.79,77.57 189.79,75.29 191.24,73.83 191.24,71.3 190.65,70.71 190.65,69.53 190.97,69.2 190.97,55.15 192.22,53.9 193.52,52.59 195.61,50.51 196.62,50.51 196.66,50.46 220.73,50.46 223.69,47.5 231.17,47.5 231.33,47.35 232.29,47.35 232.7,46.94 235.59,46.94 235.99,47.34 237.2,47.34 237.78,46.76 v2(238.6,46.76) ; v2(180.9,79.8) 180.79,79.92 180.79,88.52 175.25,94.06 175.25,102.25 v6(174.1,103.41)
  BOTTOM w0.127: v6(174.1,103.41) 174.2,103.52 PRF2.2 174.84,102.53 PUF1.5 ; v2(190.15,77.92) 188.93,76.71 186.24,76.71 185.44,75.91 UG11.1 185.44,75.81 185.05,75.41 183.3,75.41 180.9,77.81 v2(180.9,79.8)
3V_FB: length 1.8
  BOTTOM w0.254: PC312.1 252.32,29.83 252.06,30.09 PU301.13
3V_FB_1: length 1.9
  BOTTOM w0.127: v1(254.59,28.85) 253.77,28.85 PR304.1
  BOTTOM w0.254: PC312.2 253.63,29.83 PR304.1
3V_SN: length 1.3
  BOTTOM w0.508: PC311.1 250.12,21.21 PR302.2
5V_3V_EN: length 206.6
  IN2 w0.127: v2(79.37,15.84) 98.78,15.84 101.86,12.75 109.56,12.75 110.24,12.06 118.9,12.06 119.45,11.51 124.42,11.51 126.07,13.15 132.43,13.15 133.08,12.5 145.31,12.5 145.9,13.09 150.82,13.09 151.86,14.12 152.33,14.12 154.2,15.99 168.05,15.99 169.26,17.2 181.26,17.2 182.36,16.09 182.36,14.63 182.96,14.03 186.66,14.03 187.86,12.82 189.89,12.82 190.62,13.56 192.92,13.56 194.16,14.79 197.68,14.79 197.76,14.87 207.95,14.87 209,15.92 209,17.36 210.31,18.67 213.78,18.67 215.75,20.64 217.7,20.64 218.25,21.18 220.15,21.18 222.06,23.09 222.06,24.83 228.11,30.88 236.96,30.88 237.53,30.88 237.92,31.27 238.23,31.27 240.34,31.27 240.34,31.27 247.25,31.27 247.97,30.56 249.4,30.56 253.09,30.56 254.49,29.16 v2(255.18,29.16)
  BOTTOM w0.127: v2(79.37,15.84) 79.16,15.84 v1(78.37,15.04) 78.15,15.04 76.39,13.27 76.39,11.33 75.63,10.57 PU302.6 ; PU301.12 251.58,30.54 251.73,30.69 PC328.1 253.39,30.69 PR313.1 253.53,30.55 PR311.2 PR310.2 254.62,29.72 v2(255.18,29.16)
5V_FB: length 2.3
  BOTTOM w0.254: PU302.7 76.08,10.46 76.74,11.12 v2(76.79,11.12) 76.98,11.3 76.98,11.8 PC327.1
5V_FB_1: length 1.9
  BOTTOM w0.127: PR312.1 77.82,13.57 v1(77.67,13.73)
  BOTTOM w0.254: PR312.1 77.82,12.73 PC327.2
5V_SN: length 2.8
  TOP w0.127: PC325.1 v1(69.98,9.33)
  TOP w0.508: PC325.1 69.98,6.5 PR307.2
+0.6V_A_VREFDQ: length 4.4
  BOTTOM w0.102: UC1.BP13 128.57,90.54 128.2,90.17 127.18,90.17 126.98,90.37 126.12,90.37
  BOTTOM w0.135: TC286.1 124.85,90.37 126.12,90.37
+0.6V_B_VREFDQ: length 124.6
  TOP w0.508: v2(121.81,27.94) 122.41,27.34 133.72,27.34 134.53,28.15 138.89,28.15 139.24,28.5 CD82.1 139.89,28.16 RD27.2
  IN1 w0.508: v2(126.75,91.74) 126.75,91.79 125.4,93.14 122.62,93.14 120.11,90.63 119.2,90.63 115.44,86.88 114.24,86.88 112.13,84.76 arc(110.67,82.57) 110.15,79.99 110.15,75.47 109.58,74.9 109.58,72.88 100.01,63.31 100.01,55.06 97.06,52.11 97.06,46.46 98.03,45.49 98.03,43.62 99.56,42.08 99.56,36.44 98.56,35.43 98.56,32.98 102.37,29.17 117.22,29.17 117.58,28.81 120.94,28.81 v2(121.81,27.94)
  BOTTOM w0.254: UC1.BR13 127.55,90.93 127.08,90.93 126.81,91.2 126.81,91.68 v2(126.75,91.74)
+0.6V_DDR_VREFCA: length 7.9
  TOP w0.381: v2(145.85,40.25) 146.15,40.25 146.68,40.79 CD12.2 147.07,41.5 CD11.2 CD14.2 146.28,42.44 RD10.2 145.52,42.42 RD9.1 RD8.1
  BOTTOM w0.356: v2(145.85,40.25) 146.18,40.25 146.77,40.85 JDIMM1.164
+0.6V_DDRB_VREFCA: length 11.5
  TOP w0.381: RD26.1 142.8,28.85 RD28.2 142.83,28.51 143.35,27.99 144.44,27.99 144.89,28.44 CD72.2 CD69.2 144.81,29.69 CD70.2 145.24,30.38 145.52,30.65 v1(145.52,31.07) 145.52,31.41 145.77,31.67 v2(145.9,31.67)
  TOP w0.508: RD27.1 140.39,29.08 CD81.2 141.58,29.08 141.81,28.85 RD26.1
  BOTTOM w0.305: JDIMM2.164 145.28,31.03 145.67,31.42 145.67,31.44 145.9,31.67 v2(145.9,31.67)
+0.6V_VREFCA: length 141.3
  TOP w0.508: v2(144.1,40.16) 143.76,40.16 143.39,40.52 143.39,41.93 143.9,42.44 RD9.2 ; v2(128.91,90.94) 128.91,90.59 129.24,90.26 CD15.1
  IN1 w0.508: v2(128.91,90.94) 128.79,91.06 126.47,91.06 125.18,92.35 122.74,92.35 120.38,89.99 119.46,89.99 115.71,86.23 114.51,86.23 112.58,84.31 arc(111.26,82.33) 110.8,79.99 110.8,73.19 100.65,63.04 100.65,54.8 97.7,51.85 97.7,46.73 98.67,45.76 98.67,43.88 100.21,42.35 100.21,35.99 99.75,35.53 99.75,32.69 102.64,29.81 117.49,29.81 117.85,29.45 121.21,29.45 v2(122.71,27.95)
  IN3 w0.508: v2(122.71,27.95) 124.75,29.99 125.71,29.99 127.05,31.34 127.05,37.65 131.08,41.68 135.5,41.68 135.93,41.25 140.33,41.25 140.62,41.54 142.99,41.54 143.4,41.13 143.4,40.45 143.69,40.16 v2(144.1,40.16)
  BOTTOM w0.254: UC1.BN13 v2(128.91,90.94)
+0.6VS_VTT: length 78.9
  TOP w0.127: v3(171.73,42.52) 172.17,42.52 172.93,41.76 CD8.1
  IN2 w1.524: 167.25,36.89 166.53,37.61 158.66,37.61 158.38,37.89 146.5,37.89 145.94,37.34 127.31,37.34 126.67,37.98 101.28,37.98 98.86,35.56 98.86,34.86 96.87,32.87
  BOTTOM w0.305: JDIMM1.258 170.27,40.94 170.58,40.63
  BOTTOM w0.381: v2(171.73,41.27) 171.79,41.22 v2(171.79,40.63) 170.58,40.63
  vias: v2(95.33,32.92) v2(95.33,32.28) v2(95.33,31.65) v2(169.31,31.27) v2(169.76,31.6) v2(170.13,32.02)
+0.6VSP: length 3.2
  BOTTOM w0.203: PUM1.20 92.45,28.84 92.61,29 93.65,29 ; PUM1.2 93.78,27.35 93.88,27.45 94.37,27.45 94.63,27.71
  vias: v1(94.32,28.66)
+0.95VS_VCCIO: length 48.2
  TOP w0.381: v6(170.97,108.01) 170.26,108.01 168.12,105.87 165.67,105.87 165.15,105.36 RC1.2
  TOP w0.508: CC35.1 162.8,94.95 v2(162.97,95.12)
  IN1 w0.381: v2(149.24,89.96) 149.76,90.47 150.47,90.47 150.88,90.07 161.4,90.07 162.39,91.06
  IN1 w0.508: v2(164.32,93.55) 164.32,93.76 164.9,94.33 167,94.33 167.59,93.74 167.59,91.3 168.17,90.73 169.33,90.73 174.92,85.14 174.92,83.4 v2(174.68,83.16)
  BOTTOM w0.254: UC1.AG12 149.07,89.96 v2(149.24,89.96)
  BOTTOM w0.406: RC9.1 171.16,79.32 174.68,82.84 v2(174.68,83.16)
  vias: v2(162.12,100.07) v2(162.12,99.43) v2(162.13,96.67) v2(162.13,95.91) v2(162.13,95.15) v2(162.13,93.62) v2(162.13,92.73) v2(162.97,96.7) v2(162.97,95.91) v2(163.62,96.7) v2(163.62,95.91) v2(163.62,95.12) v2(163.62,93.55) v2(164.32,96.7) v3(162.65,98.83) v6(170.35,108.64) v6(170.99,108.64) v6(171.61,108.63) v6(171.62,107.99) v6(171.68,107.38) v6(172.26,108.53) v6(172.27,107.89) v6(172.29,107.27) v6(172.89,108.54) v6(172.9,107.9) v6(172.92,107.28)
+0.95VS_VCCIOP: length 6.5
  BOTTOM w0.127: v1(172.95,111) 174.41,109.54 174.6,109.54
  BOTTOM w0.203: 177.78,107.39 179.88,105.29 PCH6.1 181.09,105.29 PRH4.1
+1.0VSDGPU: length 95.1
  IN2 w0.254: v2(238.98,41.5) 238.95,41.53 238.95,42.94 238.12,43.77 225.03,43.77 218.68,50.13 196.53,50.13 196.48,50.18 195.47,50.18 190.51,55.13 190.51,68.85 189.5,69.87 189.5,70.71 190.91,72.12 190.91,73.69 189.33,75.28 189.33,77.79 189.35,77.82 189.35,83.46 190.37,84.47 190.37,86.08 190.89,86.6
  BOTTOM w0.305: UG1.AC8 v2(201.06,81.07) UG1.AC7 ; v2(197.64,81.1) UG1.AG8 UG1.AG9 ; UG1.AG6 v2(198.59,80.23) UG1.AF6
  BOTTOM w0.356: v2(197.65,95.32) 197.28,95.69 UG1.AH25 ; v2(198.46,95.26) 198.08,94.88 UG1.AG24
  BOTTOM w0.508: RG391.2 238.63,40.43 238.98,40.78 v2(238.98,41.5)
  vias: v2(197.68,92.81) v2(198.46,96.12) v2(198.57,92.6) v2(198.82,91.81) v2(198.87,93.13) v2(198.92,90.54) v2(199.06,91.16) v3(198.3,92.09) v6(183.01,97.52) v6(183.04,96.91) v6(183.06,96.3) v6(183.65,96.89) v6(183.67,97.55) v6(183.67,96.24)
+1.0VSDGPUP: length 12.6
  IN3 w0.254: v2(181.6,98.23) 180.62,99.21 180.62,103.68 v2(179.31,105)
  BOTTOM w0.127: v1(177.27,95.44) 177.88,95.44 PLF1.2
  BOTTOM w0.305: v2(179.31,105) 178.56,105 PCF2.1 177.76,104.26 PRF4.1
+1.2V_HDMI: length 7.3
  BOTTOM w0.135: v2(24.14,57.3) 24.46,57.62 UV2.46 ; v2(25.74,57.36) 25.66,57.43 UV2.43
  BOTTOM w0.191: UV2.11 22.29,63.08 22.15,63.22 22.15,63.77 22.32,63.94 v2(22.69,63.94)
  BOTTOM w0.203: UV2.18 v2(25.66,65.1) ; UV2.30 29.71,61.48 v2(29.88,61.64) ; v2(24.46,65.1) UV2.15 ; UV2.6 v2(21.97,61.08)
  vias: v3(21.19,62)
+1.2V_VCCPLL_OC: length 52.9
  TOP w0.254: CC36.1 163.67,88.29 v2(163.67,88.83)
  TOP w0.381: v2(131.88,90.16) 131.62,90.41 CC37.1
  TOP w0.508: RC375.2 RC374.2 CC401.1 v3(120.87,90.78) 121.97,90.78 122.4,91.21 v2(125.26,91.21)
  IN1 w0.381: v2(131.88,90.16) 128.51,90.16 128.15,90.52 126.12,90.52 125.44,91.21 v2(125.26,91.21)
  IN2 w0.381: v2(163.67,88.83) 163.67,89.59 163.24,90.03 150.87,90.03 150.14,90.75 146.63,90.75 145.84,89.96 143.59,89.96 142.35,91.21 142.04,91.21 141.22,92.03 137.76,92.03 135.77,90.04 v2(132.77,90.04)
  BOTTOM w0.254: UC1.G11 163.97,89.19 v2(163.67,88.83) ; v2(132.77,90.04) UC1.BH13 v2(131.88,90.16) UC1.BJ13
+1.2V_VCCSFR_OC_OUT:
  vias: v1(117.11,88.36)
+1.2V_VDDQ: length 174.7
  TOP w0.254: 164.39,27.47 164.86,27.01 164.86,25.01 165.69,24.17 v2(165.69,23.59)
  IN2 w0.508: v2(92.41,29.44) 96,29.44 96.01,29.44 99.17,29.44 v2(101.66,31.93)
  BOTTOM w0.203: PUM1.19 92.05,28.95 92.41,29.31 v2(92.41,29.44)
  BOTTOM w0.254: v2(165.69,23.59) 165.82,23.59 167.02,24.79 171.26,24.79 172,24.79 176.58,20.2 180.34,20.2 183.24,17.3 183.85,17.3 183.96,17.41 185.28,17.41 185.32,17.37 RH39.2 ; JDIMM2.241 164.53,39.64 164.13,40.04 163.59,40.04 v2(163.58,40.05) ; v2(145.85,40.84) 145.77,40.92 JDIMM1.160 ; JDIMM1.12 106.77,41.11 106.46,40.79 105.62,40.79 v2(105.62,40.79) ; v2(105.36,31.03) 105.28,30.94 JDIMM2.12
  BOTTOM w0.305: JDIMM1.117 133.02,51.14 133.6,51.71 v2(134.57,51.71) 134.53,51.66 JDIMM1.123 ; JDIMM1.130 136.28,41.09 135.87,40.69 134.74,40.69 v2(134.68,40.75) 134.77,40.85 JDIMM1.124 ; v2(144.05,51.48) 144.02,51.46 JDIMM1.153 ; v2(148.42,51.71) 147.91,51.71 147.63,51.43 146.83,51.43 146.52,51.13 JDIMM1.163 ; JDIMM1.241 166.02,51.82 v2(165.8,52.04) ; v2(113.09,52.58) 112.93,52.58 112.02,51.67 JDIMM1.33 ; v2(134.7,39.38) 134.53,39.21 JDIMM2.129 ; v2(135.53,32.2) 135.93,31.79 135.93,31.24 136.28,30.9 JDIMM2.136 ; JDIMM2.141 137.53,38.85 137.73,39.06 v2(137.73,39.36) 136.38,39.36 136.03,39 JDIMM2.135 ; v2(131.44,51.62) 131.53,51.54 JDIMM1.111 ; JDIMM2.118 131.78,28.49 131.4,28.11 v2(131.4,27.96) ; v2(144.81,32.45) 144.81,31.46 144.28,30.92 JDIMM2.160 ; JDIMM2.220 159.28,28.16 159.39,28.04 v2(159.39,27.99) ; JDIMM1.220 160.77,41.06 160.38,40.67 v2(160.38,40.56) ; JDIMM2.130 134.78,28.33 134.47,28.02 v2(133.53,28.02) 133.28,28.28 JDIMM2.124 ; v2(131.73,40.84) 131.77,40.89 JDIMM1.112 ; JDIMM1.136 137.77,41.14 137.73,41.1 v2(137.73,40.62) 137.76,40.6 138.79,40.6 139.28,41.08 JDIMM1.142 ; v2(124.52,52.12) 122.98,52.12 122.53,51.67 JDIMM1.75 ; JDIMM2.163 145.03,38.97 144.51,39.49 v2(144.1,39.49) 144.03,39.42 JDIMM2.159 ; JDIMM2.153 142.53,39.17 v2(142.64,39.28) ; v2(148.78,31.13) 148.78,31.12 JDIMM2.178 ; JDIMM2.154 v2(142.78,31.16) ; JDIMM2.123 133.03,38.86 132.71,39.17 131.79,39.17 v2(131.79,39.18) ; JDIMM1.118 133.27,40.67 133.83,40.12 v2(134.68,40.12) ; JDIMM1.148 142.79,42.04 142.79,40.95 v2(142.65,40.82) ; JDIMM2.199 154.03,38.96 153.58,39.41 v2(153.43,39.41) ; v2(131.79,39.18) 130.29,39.18 130.03,38.91 JDIMM2.111 ; v2(131.79,39.18) 131.53,38.91 JDIMM2.117 ; v2(137.37,52.22) 136.91,52.22 136.02,51.33 JDIMM1.129 ; v2(149.84,40.53) 150.28,40.96 JDIMM1.178 ; v2(115.88,28.06) 115.88,28.36 115.78,28.47 JDIMM2.54 ; v2(142.52,51.51) JDIMM1.147 ; JDIMM2.96 126.28,28.33 v2(126.54,28.06) ; JDIMM1.154 144.28,41.02 v2(144.1,40.84) ; JDIMM2.147 141.03,38.85 140.66,39.22 139.83,39.22 v2(139.69,39.07) ; JDIMM1.141 139.02,51.34 139.35,51.66 v2(139.43,51.66) ; JDIMM2.112 130.28,28.19 v2(130.42,28.05) ; v2(154.63,51.75) 154.87,51.51 155.22,51.51 155.52,51.2 JDIMM1.199 ; JDIMM2.75 121.03,39.22 v2(120.99,39.26) ; v2(117.48,40.82) 117.27,41.02 JDIMM1.54 ; JDIMM1.96 127.77,41.07 128.28,40.57 v2(128.48,40.57) ; v2(141.28,31.13) JDIMM2.148 ; JDIMM2.33 110.53,39.52 110.11,39.93 v2(109.42,39.93) ; JDIMM1.135 137.52,51.43 v2(137.37,51.59) ; JDIMM1.159 v2(145.52,51.51)
  BOTTOM w0.33: JDIMM2.142 137.78,30.95 v2(137.92,31.09)
  BOTTOM w0.432: UC2.5 119.95,85.99 119.64,85.67 CC41.2
  BOTTOM w0.508: CC41.2 119.64,83.35 121.21,81.77 121.21,78.17 118.41,75.36 108.01,75.36 106.63,73.99 106.63,73.5 v2(107.57,72.56)
  vias: v2(98.53,39.3) v2(98.53,38.54) v2(98.53,37.8) v2(98.53,37.02) v2(98.94,38.92) v2(98.95,38.17) v2(98.93,37.41) v2(107.11,71.27) v2(107.17,72.11) v2(107.5,71.67) v2(107.9,72.06) v2(108.13,72.99) v2(108.29,72.46) v2(108.69,72.85) v2(119.22,40.66) v3(161.63,54.33)
+1.2V_VDDQ_CPU: length 19.5
  BOTTOM w0.203: UC1.AA6 153.95,85.76 v2(154.33,85.38) 154.35,85.38 154.73,85.77 UC1.W6 ; UC1.AL11 146.14,89.03 146.51,89.4 v2(146.53,89.4) ; UC1.AF6 149.6,85.77 v2(149.26,85.43) ; UC1.AF5 149.57,85.12 v2(149.26,85.43) ; UC1.K12 162.25,89.86 161.78,89.86 UC1.L12 ; UC1.L6 161.49,85.77 161.69,85.96 162.13,85.96 UC1.K6 ; UC1.AG9 149.23,88.16 v2(149.24,88.16) ; v2(149.26,85.43) 148.95,85.12 UC1.AG5 ; UC1.AY6 138.9,85.77 v2(139.29,85.38) ; v2(154.74,89.39) 154.6,89.39 154.31,89.68 UC1.Y12 ; v2(141.77,85.4) 141.85,85.4 UC1.AR6 UC1.AP6 143.31,86.03 UC1.AP7
  BOTTOM w0.254: v2(142.83,89.89) 142.6,89.89 UC1.AR12 ; v2(141.95,90.05) 142.02,90.05 UC1.AR12 ; v2(157.49,87.51) 157.49,86.34 157.3,86.14 UC1.T6 ; UC1.AE12 150.62,89.63 150.31,89.32 150.22,89.32 v2(150.18,89.28) ; UC1.AT12 141.8,89.35 v2(141.94,89.35) 142.07,89.35 UC1.AR12 ; v2(156.86,85.41) 156.94,85.41 UC1.T6 ; v2(162.91,89.48) UC1.K12 ; UC1.T6 UC1.R6 ; UC1.AJ12 147.02,89.68 v2(147.38,89.32) ; UC1.K6 162.33,85.73 v2(162.69,85.44) 163.13,85.77 UC1.J6 v2(163.59,85.46) UC1.J5
  BOTTOM w0.305: v2(139.28,86.11) 139.63,85.77 UC1.AW6
  vias: v1(131.72,73.89)
+1.2VP: length 20.1
  BOTTOM w0.203: PRM6.2 94.21,25.47 93.76,25.92 93.76,25.93 93.54,26.15 PUM1.5
  BOTTOM w0.254: PCM10.1 96.89,40.29 96.89,26.5 96.59,26.2 96.33,26.2 96.15,26.02 95.12,26.02 94.9,25.81 PRM6.2
  vias: v1(94.23,42.56) v2(93.05,41.68) v2(93.68,41.68) v2(94.82,40.79) v2(94.82,40.03) v2(94.82,39.27) v2(94.82,38.5) v2(94.82,37.87) v2(95.33,40.28) v2(95.33,39.65) v2(95.33,38.89) v2(95.33,38.25) v2(95.33,37.62) v2(95.33,36.98) v2(95.33,36.35)
+1.05V_BCLKPLL2: length 8.1
  BOTTOM w0.254: UH1.B1 UH1.B2 UH1.B3
  BOTTOM w0.305: 214.14,40.97 214.42,40.69 214.42,40.16 UH1.B1
  BOTTOM w0.508: RH88.2 215.7,44.5 215.65,44.55 CH106.1 v1(214.22,44.55) 214.05,44.55 213.8,44.3 213.8,43.61 CH23.1 213.82,42.03 214.14,41.71 214.14,40.97
+1.05V_CNV_HVLDO: length 2.6
  TOP w0.127: v1(208.45,29.59) RH57.2
  TOP w0.508: v2(206.75,29.22) 207.12,29.59 RH57.2
  BOTTOM w0.305: UH1.AE17 206.75,28.73 v2(206.75,29.22)
+1.05V_FHV0: length 11.4
  TOP w0.508: v2(199.83,28.72) 199.34,28.72 199.02,29.04 v1(198.6,29.04) 196.48,29.04 195.34,30.18 194.3,30.18 193.92,29.8 192.36,29.8 191.28,30.88 RH120.2
  BOTTOM w0.254: UH1.AF31 199.8,28.72 v2(199.83,28.72)
+1.05V_FHV1: length 11.4
  TOP w0.508: RH119.2 191.18,30.12 192.11,29.2 194.17,29.2 194.55,29.57 195.09,29.57 195.98,28.69 195.98,28.68 196.23,28.43 v1(196.94,28.43) 198.71,28.43 199.09,28.06 v2(199.79,28.06)
  BOTTOM w0.254: UH1.AG31 199.4,27.67 v2(199.79,28.06)
+1.05V_FUSE: length 11.4
  TOP w0.508: RH56.2 191.47,31.65 v1(191.81,31.3) 192.7,30.41 193.65,30.41 194.12,30.88 195.5,30.88 196.26,30.13 196.71,29.68 199.6,29.68 v2(199.79,29.49)
  BOTTOM w0.254: v2(199.79,29.49) UH1.AD31
+1.05V_OC: length 2.9
  TOP w0.127: v2(205.23,31.83) v1(204.82,31.42)
  TOP w0.508: v2(205.23,31.83) 205.68,32.28 CH22.1 RH87.2
  BOTTOM w0.254: v2(205.23,31.83) UH1.V19
+1.05V_OCPLL1: length 6
  BOTTOM w0.254: UH1.C2 213.9,39.4 214.21,39.59 UH1.C1
  BOTTOM w0.305: UH1.C1 214.4,39.56 215.07,40.23
  BOTTOM w0.508: 215.07,40.23 215.13,40.29 216.52,40.29 217.1,40.87 217.33,40.87 217.35,40.89 CH21.1 217.42,40.96 217.81,41.35 CH105.1 RH86.2
+1.05V_PCH: length 5.8
  TOP w0.508: RH59.1 v1(188.08,35.08) v2(186.87,35.08) ; RH119.1 RH120.1 RH56.1 189.31,33.21 v2(189.54,33.44)
  vias: v2(186.87,34.44) v2(207.94,33.02) v2(209.6,30.34) v2(214.71,41.07) v2(215.3,41.07) v2(215.88,41.07) v2(216.46,41.07)
+1.05V_PCH_PRIM: length 0.8
  TOP w0.381: v2(202.21,28.71) 202.18,28.74 CH62.1
  vias: v1(204.54,34.99) v2(200.48,28.72) v2(200.56,30.26) v2(200.56,29.56) v2(201.34,30.26) v2(201.34,29.49) v2(202.16,29.44) v2(202.89,30.26) v2(203.63,29.46) v2(203.66,30.26) v2(203.66,28.71) v2(203.75,37.46) v2(203.85,36.78) v2(203.85,35.89) v2(204.24,35.4) v2(204.27,36.33) v2(204.35,37.47) v2(204.43,29.42) v2(204.47,36.93) v2(204.91,36.03) v2(205.17,36.62) v2(205.17,29.45) v2(205.31,37.49) v2(205.46,36.14) v2(205.58,37)
+1.05V_SRC: length 3.1
  TOP w0.127: v1(205.92,30.11) RH85.2
  TOP w0.508: RH85.2 205.61,31.27 205.38,31.04 v2(205.21,31.04)
  BOTTOM w0.254: UH1.W20 v2(205.21,31.04) 205.25,31.08 UH1.W19
+1.05V_VCCAMPHYPLL:
  vias: v1(186.42,35.79)
+1.05V_VCCAZPLL: length 5.4
  BOTTOM w0.254: UH1.E1 UH1.D1
  BOTTOM w0.406: UH1.D1 215.11,39.06
  BOTTOM w0.508: RH84.2 218.42,39 217.82,39.6 CH17.1 217.45,39.6 216.92,39.06 215.11,39.06
+1.05V_VCCCLPLLEBB: length 11.9
  TOP w0.508: v2(198.93,30.79) 198.77,30.94 197.17,30.94 195.84,32.28 195.51,32.28 195.17,32.61 195.17,33.38 193.35,35.2 v1(193.07,35.2) CH15.1 190.35,35.2 RH59.2
  BOTTOM w0.305: UH1.W31 199.4,31.26 v2(198.93,30.79)
+1.05V_VCCDSW: length 4.5
  BOTTOM w0.305: 191.98,17.46 191.98,17.72 UH1.BG46 UH1.BG45
  BOTTOM w0.381: 191.98,17.46 190.9,16.38 190.9,15.2 191.47,14.63 CH16.1
+1.05V_VCCMPHY:
  vias: v1(200.49,32.19) v2(198.86,32.27) v2(198.89,31.63) v2(199.61,35.46) v2(199.79,32.59) v2(199.79,31.81) v2(199.93,33.16) v2(200.1,36.05) v2(200.17,35.43) v2(200.47,38.29) v2(200.5,36.94) v2(201.02,37.99) v2(201.02,37.43) v2(201.02,36.7) v2(201.02,36.1) v2(201.02,35.55) v2(201.27,35.05) v2(201.33,33.82) v2(201.33,33.23) v2(201.34,32.59) v2(201.34,31.81) v2(202.11,31.81) v2(202.45,33.36) v2(202.46,32.76)
+1.05V_VCCSFR: length 14.4
  TOP w0.508: CH103.1 162.72,101.43 163.62,100.53 v1(164.05,100.53) 165.31,100.53 CH102.1 172.85,100.28 173.63,101.06 RC143.2
  BOTTOM w0.254: UC1.J28 162.74,102.5 163.23,102.5 UC1.H28 163.31,102.71 v2(163.05,102.97)
+1.05V_VCCST: length 452.7
  TOP w0.229: UK1.117 134.66,14.22 134.43,13.99 134.43,13.91 133.98,13.46 CK16.1
  TOP w0.254: UK1.117 136.78,14.22 137.39,14.83 137.39,15.75 137.7,16.05 v2(137.7,16.62)
  TOP w0.381: RH166.1 v1(221.46,29.38) 222.18,29.38 222.37,29.2 v2(222.37,29.19)
  TOP w0.508: v2(164.06,104.81) 164.01,104.86 164.01,106.09 CC38.1 163.91,106.6 163.96,106.65 163.96,109.75 165.99,111.78 v2(169.5,111.78) 169.75,112.04 169.75,114.23 168.81,115.17 v2(168.81,120.11) ; PRZ8.1 PRZ7.1 PRZ6.2 PRZ5.1 172.98,133.84 PCZ3.2 172.39,134.01 171.91,133.53 v2(171.91,132.81) ; v2(172.84,99.41) 173.57,99.41 RC140.2
  IN1 w0.381: v2(188.83,49.22) 193.21,49.22 193.69,48.75 194.11,48.75 194.34,48.52 219.91,48.52 220.95,47.49 230.82,47.49 232.98,49.64 v2(233.12,49.64)
  IN1 w0.508: v2(120.99,107.72) 120.99,102.99 121.39,102.59 124.46,102.59 124.85,102.97 v2(125.73,102.97)
  IN2 w0.254: v2(120.99,107.72) 121.04,107.67 121.04,101.75 123.28,99.5 123.28,88.42 121.12,86.26 121.12,77.98 118.97,75.82 113.43,75.82 112.62,75.01 104.14,75.01 103.34,74.2 v2(102.1,74.2)
  IN2 w0.381: v2(188.83,49.22) 186.77,49.22 185.42,50.57 180.76,50.57 177.29,54.03 177.29,60.18 176.45,61.03 176.45,68.39 180.73,72.67 180.73,77.48 178.98,79.22 178.98,81.75 178.04,82.7 v2(177.97,82.7)
  IN2 w0.508: v2(172.84,99.41) 172.84,88 177.97,82.87 v2(177.97,82.7)
  IN3 w0.127: 163.09,104.36 162.94,104.51 162.94,105.71 163.21,105.98 163.56,105.98 164.06,105.49 v2(164.06,104.81)
  IN3 w0.254: v2(102.1,74.2) 101.99,74.19 101.14,73.11 100.11,70.66 99.4,69.08 98.78,67.87 98.03,66.51 97.38,65.4 96.47,64.02 96.47,61.14 95.11,59.78 95.11,57.24 94.07,56.2 91.53,56.2 87.56,52.23 86.14,52.23 82.79,48.88 81.94,48.88 81.32,48.26 78.72,48.26 76.21,45.75 76.21,29.4 78.47,27.14 78.47,22.14 82.98,17.63 86.96,17.63 95.42,26.1 96.63,26.1 96.83,26.3 97.82,26.3 98.71,25.41 98.71,23.89 100.58,22.02 111.53,22.02 112.95,23.44 118.17,23.44 120.42,21.19 v2(120.42,19.87)
  IN3 w0.381: v2(222.37,29.19) 225.14,31.96 225.14,36.95 232.89,44.7 232.89,47.35 232.34,47.9 232.34,48.6 233.12,49.38 v2(233.12,49.64) ; 163.09,104.36 163.61,104.36 v2(164.06,104.81)
  IN3 w0.508: v2(171.91,132.81) 171.91,130.22 171.63,129.94 171.63,126.34 171.07,125.78 171.07,124.94 171.43,124.58 171.43,123.06 170.75,122.37 170.16,122.37 168.81,121.03 v2(168.81,120.11) ; v2(172.84,99.41) 173.41,99.98 173.41,104.11 172.94,104.59 172.94,105.02 169.5,108.46 169.5,108.51 169.6,108.61 169.6,109.11 169.5,109.22 v2(169.5,111.78) ; 163.09,104.36 162.42,103.7 162.42,102.7 161.9,102.18 160.62,102.18 159.25,103.54 133.36,103.54 131.92,102.11 126.6,102.11 v2(125.73,102.97)
  BOTTOM w0.254: v2(120.42,19.87) 120.42,19.62 120.65,19.39 121.53,19.39 121.63,19.49 131.71,19.49 132.85,18.35 134.46,18.35 136.66,16.16 137.24,16.16 v2(137.7,16.62) ; v2(164.06,104.81) UC1.H30
  BOTTOM w0.356: v2(120.99,107.72) CC406.1 120.45,107.69 RC40.1 RC41.2
  BOTTOM w0.508: RC20.2 177.97,83.55 v2(177.97,82.7)
+1.05V_VCCSTU: length 132.7
  TOP w0.127: CC391.1 251.96,41.69 v3(251.43,42.22)
  TOP w0.508: v2(175.9,99.67) 175.35,100.22 RC140.1 175.35,100.28 RC143.1
  IN2 w0.508: v2(253.01,41.43) 252.85,41.59 244.74,41.59 243.83,40.68 242.96,40.68 241.93,39.65 240.13,39.65 239.45,40.33 238.49,40.33 238,40.82 232.75,40.82 232.71,40.86 225.09,40.86 217.47,48.49 195.85,48.49 195.8,48.53 194.79,48.53 188.1,55.23 188.1,67.84 186.04,69.89 186.04,80.59 185.68,80.95 185.68,84.55 188,86.87 188,93.61 187.1,94.51 185.48,94.51 184.87,93.9 178.16,93.9 176.56,95.5 176.56,97.09 175.9,97.75 v2(175.9,99.67)
+1.05V_VCCUSB: length 3.5
  TOP w0.127: v1(203.31,31.42) 203.66,31.77 v2(203.66,31.81)
  TOP w0.508: RH58.2 204.91,32.66 CH14.1 203.79,32.41 203.79,31.94 v2(203.66,31.81)
  BOTTOM w0.254: UH1.W22 204.05,31.42 203.98,31.49 v2(203.66,31.81) 203.28,31.42 UH1.W23
+1.05V_XTAL: length 8.1
  BOTTOM w0.508: RH83.2 CH109.1 220.04,36.93 CH20.1 CH101.1 218.2,36.43 217.8,36.03 v1(216.93,36.03) 216.78,36.03 216.38,35.63 215.73,35.63 215.31,35.21 215.31,34.84 214.8,34.33 214.45,34.33
+1.05VALW: length 119.3
  TOP w0.508: RC383.1 218.27,30.28 v2(218.37,30.39)
  IN2 w0.508: v2(176.7,108.06) 176.7,104.63 178.19,103.15 178.19,98.04 181.06,95.16 184.37,95.16 184.96,95.76 187.62,95.76 189.66,93.71 189.66,86.78 188.83,85.94 188.83,81.4 187.29,79.86 187.29,70.4 189.34,68.35 v2(189.34,57)
  IN3 w1.016: 226.96,27.05 235.95,36.04 250.17,36.04 251.29,37.16
  BOTTOM w0.508: v2(203.22,43.12) 203.22,43.37 199.2,47.39 195.06,47.39 192.68,49.77 192.68,54.16 189.85,57 v2(189.34,57)
  vias: v2(203.22,42.54) v2(203.22,41.91) v2(203.8,43.12) v2(203.8,42.54) v2(203.8,41.91) v2(204.38,43.12) v2(204.38,42.54) v2(204.38,41.91) v2(204.97,43.12) v2(204.97,42.54) v2(204.97,41.91) v2(205.55,43.12) v2(205.55,42.54) v2(205.55,41.91) v2(225.68,24.73) v2(225.68,24.15) v2(225.68,23.57) v2(225.68,22.98) v2(225.68,22.4) v2(225.68,21.81) v2(225.68,21.23) v2(226.28,25.29) v2(226.26,24.73) v2(226.26,24.15) v2(226.26,23.57) v2(226.26,22.98) v2(226.26,22.4) v2(226.26,21.81) v2(226.26,21.23) v2(226.88,25.28) v2(252.37,37.63) v2(252.95,37.63) v3(206.71,42.68)
+1.05VALWP: length 8.5
  BOTTOM w0.254: PC1005.1 235.45,17.8 237.19,17.8 237.94,18.56 237.94,21.53 237.83,21.64 PC1008.1 237.83,22.5 237.93,22.6 PR1006.1
  vias: v1(233.23,19.07) v2(231.52,22.38) v2(231.52,21.79) v2(231.52,21.21) v2(231.52,20.63) v2(232.11,22.38) v2(232.11,21.79) v2(232.11,21.21) v2(232.11,20.63) v2(232.72,22.43) v2(232.72,21.84) v2(232.72,21.26) v2(232.72,20.68) v2(233.3,22.43) v2(233.3,21.84) v2(233.3,21.26) v2(233.3,20.68)
+1.05VS_VCCSTG: length 66.6
  TOP w0.508: v2(163.68,103.75) 163.97,103.75 164.74,104.52 CC40.1 166.36,104.52 166.93,105.08 168.11,105.08 169.85,103.35 170.7,103.35 171.21,103.86 171.21,104.54 v3(171.85,105.18) 172.41,105.74 CC398.1
  IN1 w0.508: v2(126.9,98.85) 126.29,99.46 123.58,99.46 122.71,100.33 v2(121.11,100.33)
  IN3 w0.508: v2(126.9,98.85) 126.9,99.85 127.28,100.23 129.34,100.23 130.08,99.49 132.26,99.49 132.4,99.63 132.4,100.99 133.23,101.81 135.25,101.81 136.33,102.89 158.98,102.89 160.35,101.53 162.5,101.53 163.68,102.7 v2(163.68,103.75)
  BOTTOM w0.254: UC1.H29 v2(163.68,103.75) UC1.G30 ; RC18.2 121.14,100.36 v2(121.11,100.33) RC381.2 RC380.2 RC384.2
+1.8V_PG: length 40.5
  TOP w0.127: v2(241.83,22.92) v3(241.08,22.92)
  IN1 w0.254: v2(252.09,23.41) 252.09,23.9 249.59,26.4 248.74,26.4 248.04,27.09 243.45,27.09 241.83,25.47 241.83,22.93 v2(241.83,22.92)
  IN2 w0.254: v2(252.09,23.41) 252.38,23.41 252.8,22.99 267.21,22.99 268.65,21.56 v2(268.65,21.35)
  BOTTOM w0.254: PU1801.2 266.59,20.82 266.81,20.6 268.15,20.6 268.65,21.09 v2(268.65,21.35) 268.65,21.64 267.8,22.49 PR1801.2 ; PR1003.1 241.83,23.44 v2(241.83,22.92)
+1.8V_PHVLDO: length 2.2
  TOP w0.127: v1(206.3,28.17) 205.96,28.51 v2(205.96,28.69)
  BOTTOM w0.305: UH1.AF20 204.83,28.33 v2(205.19,28.69) 205.55,28.33 UH1.AF19 v2(205.96,28.69)
+1.8V_PRIM: length 163.5
  TOP w0.508: RH146.2 193.42,32.05 v2(194.39,33.02) ; v2(205.19,27.93) 205.07,27.81 RH172.2 203.28,27.81 202.71,27.24 202.71,25.93 202.33,25.55 RH150.2 ; RWL12.1 RWL13.1 v2(309.4,17.68) ; RH147.2 195.53,28.24 v2(194.8,28.96)
  IN2 w0.508: v2(300.45,6.94) 297.08,10.31 297.08,16.3 296.8,16.59 295.78,16.59 295.34,16.15 288.58,16.15 286.46,18.27 285.34,18.27 282.16,21.45 282.16,23.53 283.57,24.94 283.57,27.06 282.72,27.91 273.41,27.91 273.24,27.74 258.91,27.74 254.74,31.91 253.47,31.91 252.85,31.29 249.1,31.29 248.27,31.29 247.56,32 240.03,32 240.03,32 238.54,32 238.54,32 238.43,32 238.24,32.19 228.14,32.19 221.33,25.38 221.33,23.4 220.27,22.33
  IN3 w0.508: v2(309.4,17.68) 310.2,16.87 310.2,12.62 309.67,12.09 306.19,12.09 305.82,12.46 303.9,12.46 303.04,11.6 303.04,8.5 302.29,7.75 300.94,7.75 300.45,7.26 v2(300.45,6.94) ; v2(207.42,24.2) 207.01,24.2 205.88,25.33 205.88,27.24 v2(205.19,27.93) 200.53,27.93 200.05,27.45 199.54,27.45 199.15,27.84 199.15,28.1 198.72,28.53 195.24,28.53 v2(194.8,28.96) 194.49,29.28 194.49,31.6 194.27,31.82 194.27,32.91 v2(194.39,33.02)
  BOTTOM w0.127: v2(219.38,22.32) v1(220.01,22.32)
  BOTTOM w0.254: UH1.AG19 205.25,27.87 v2(205.19,27.93) UH1.AG20 ; v2(208.52,21) 208.52,20.91 209.12,20.3 UH1.BB11 ; v2(207.42,23.16) UH1.AR15 ; v2(207.42,24.2) UH1.AN15
  BOTTOM w0.508: RH167.2 218.67,21.23
  vias: v2(218.83,22.31)
+1.8V_TBTC_PDLDO: length 5.6
  TOP w0.203: UU4.35 51.39,43.26
  TOP w0.254: CU69.1 52.68,43.5 51.63,43.5 v1(51.56,43.43) 51.39,43.26
  TOP w0.508: CU74.1 55.15,44.24 53.26,44.24 52.75,43.73 CU69.1
+1.8VALW: length 51
  TOP w1.016: 221.98,23.07 224.2,25.3 224.2,30.24 223.22,31.22 223.22,32.34
  IN2 w1.016: 253.53,36.79 253.51,36.77 247.1,36.77 245.92,35.58 239.98,35.58 239.86,35.71 224.5,35.71 223.64,34.85
  BOTTOM w1.524: 256.8,35.78 256.8,33.13 259.94,30 259.94,27.47
  vias: v2(223.14,33.88) v2(223.14,33.24) v2(246.96,40.71) v2(247.52,40.72) v2(255.91,38.1) v2(256.47,38.1) v2(257,37.91) v3(221.11,22.98) v6(240.39,40.29) v6(241.05,40.29) v6(241.66,40.29)
+1.8VALWP: length 6.3
  BOTTOM w0.254: PC1802.1 265.21,23.03 265.19,23.05 PR1803.1 265.19,24.32 264.34,25.17 v1(263.54,25.17) 261.94,25.17 261.35,24.57
+1.8VS: length 135
  TOP w0.254: 255.84,42.52 255.83,42.53 255.83,43.27 255.43,43.67 254.25,43.67 253.02,44.9 249.23,44.9 248.93,44.6 248.93,42.25 247.97,41.3 243.67,41.3 243.39,41.02 237.96,41.02 233.63,45.35 233.63,46.17 v3(230.99,48.82) 230.99,50.98 230.64,51.33 228.01,51.33 227.24,52.1 227.24,53.7 226.78,54.15 225.8,54.15 PRV5.1
  TOP w0.508: v2(310,34.44) 311.26,33.18 311.26,27.2 310.11,26.06 309.31,26.06 308.83,26.54 306.79,26.54 305.64,25.4 305.64,22.63 305.01,21.99 LA3.2
  IN3 w0.508: v2(310,34.44) 310.55,34.44 310.95,34.85 310.95,40.51 310.28,41.18 310.28,44.59 308.39,46.48 275.15,46.48 272.69,48.94 266.41,48.94 262.08,44.61 259.86,44.61 259.29,44.03 259.29,43.08 258.31,42.1 257.49,42.1 257.28,41.9 v6(255.74,41.9)
+1.8VS_AVDD: length 3.4
  TOP w0.203: UA1.20 299.2,21.83 299.28,21.76 299.46,21.76 299.57,21.87 CA13.1
  TOP w0.381: CA13.1 300.23,21.87 300.33,21.97 CA14.2
  TOP w0.508: LA3.1 301.3,21.97 CA14.2
+1.8VSDGPU_AON: length 311.5
  TOP w0.381: RG399.1 219.53,67.45 RG85.2 219.51,66.65 RG86.2 219.5,66.4 218.78,65.68 218.78,65.01 218.22,64.46 v2(218.22,62.93) ; v2(220.68,64.18) 220.76,64.11 RG400.1
  TOP w0.508: v2(191.68,83.61) 191.12,84.17 188.49,84.17 188.28,84.38 186.68,84.38 185.6,83.3 ; RG37.1 225.98,61.15 226.54,61.71 v2(226.54,61.95) ; RV36.2 19.5,69.06 QV2.5 QV2.2 19.5,66.11 19.18,65.79 19.18,65.61 18.77,65.19 v2(18.57,65.19) 17.84,65.93 RV37.2 ; v2(182.39,84.3) 183.39,83.3 v3(183.85,83.3) 185.6,83.3 ; v2(186.69,81.2) 186.02,81.2 185.6,81.62 185.6,83.3 ; RG403.1 223.68,60.99 223.13,61.54 RG34.1 222.92,61.83 222.51,61.83 v2(222.48,61.85) 221.94,61.85 RG38.1
  IN1 w0.381: v2(220.68,64.18) 219.1,64.18 218.22,63.3 v2(218.22,62.93)
  IN1 w0.508: v2(198.54,97.83) 198.54,97.01 199.05,96.5 199.05,95.02 198.7,94.68 191.71,94.68 191.27,94.24 190.8,94.24 189.55,92.99 189.55,90.48 192.27,87.76 192.27,84.2 v2(191.68,83.61) ; v2(93.53,59.99) 93.6,59.92 93.6,59.17 92.29,57.86 91.88,57.86 86.1,52.08 v2(86.1,51.36)
  IN2 w0.508: 48.76,41.84 49.11,41.49 56.22,41.49 57.22,42.49 67.63,42.49 68.3,43.17 77.82,43.17 78.03,43.37 80.36,43.37 81.64,44.65 82.8,45.82 84.59,45.82 86.1,47.32 v2(86.1,51.36) ; 43.82,42.39 43.36,42.39 38.83,46.93 38.5,46.93 35.18,50.24 35.18,50.93 34.73,51.38 33.84,51.38 32.93,52.29 30.58,52.29 30.31,52.55 27.48,52.55 24.38,55.65 24.11,55.65 22.69,57.07 21.82,57.07 21.35,57.55 21.35,61.42 18.42,64.35 18.42,65.04 v2(18.57,65.19)
  IN3 w0.381: 242.54,43.69 242.34,43.49 239.48,43.49 239.01,43.03 239.01,42.24 239.53,41.73 239.53,40.2 240.19,39.54 v2(242.71,39.54)
  IN3 w0.508: v2(198.54,97.83) 198.54,97.35 200.3,95.59 211.16,95.59 213.06,93.7 ; 213.29,87.87 213.01,87.59 213.01,83.66
  BOTTOM w0.381: CG563.1 240.9,61.77 UG29.5 v2(240.32,61.74) ; RG35.2 218.22,62.59 v2(218.22,62.93) 218.22,63.28 RG36.2 ; RG127.2 227.76,62.73 RG132.2 ; v2(242.71,39.54) 242.81,39.44 RG179.1 ; RG180.1 236.43,64.79 CG340.1 237.19,64.4 236.94,64.14 v2(236.94,63.77) UG28.5 ; RG394.1 v2(240.39,63.78) ; UG8.5 186.14,80.65 v2(186.69,81.2) ; RG129.2 220.54,69.1 220.54,67.76 RG124.2
  BOTTOM w0.508: v2(182.39,84.3) 181.96,84.3 181.59,83.93 RG7.1 181.59,82.71 181.53,82.65 ; RG100.1 RG397.1 235.02,58.95 RG396.1 235.81,58.96 RG398.1 v2(235.81,59.64) ; v2(93.53,59.99) 94.76,59.99 101.06,66.29 159.34,66.29 174.58,81.53 178.43,81.53 179.55,82.65 181.53,82.65 ; RG83.2 182.2,78.14 181.53,78.81 181.53,82.65 ; RG126.2 230.17,61.4 230.66,61.4 RG130.2 RG125.2 231.87,61.45 232.25,61.45 RG131.2 v2(233.13,61.59) ; RG124.2 220.35,67.18 220.37,67.16 RG39.1 220.36,66.75 RG6.2 RG5.2 220.36,64.5 v2(220.68,64.18) ; RG407.1 v2(236.61,59.61) ; RG132.2 226.54,62.33 v2(226.54,61.95) 225.92,61.95 RG128.2
  vias: v2(212.49,82.53) v2(212.49,81.97) v2(213.05,82.61) v2(213.08,81.97) v2(224.23,67.12) v2(224.62,66.73) v2(245.13,44.92) v2(245.69,44.92) v2(246.27,44.92) v2(246.83,44.92) v2(247.42,44.92)
+1.8VSDGPU_MAIN: length 48.9
  TOP w0.508: v2(234.37,45.54) 234.37,45.33 236.2,43.51 239.27,43.51 239.67,43.9
  IN2 w0.508: v2(211.02,81.98) 211.71,81.29 211.71,76.33 212.29,75.75 212.29,75.73 212.32,75.7 212.32,72.6 217.19,67.73 217.19,65.42 218.83,63.78 v2(218.83,62.93)
  BOTTOM w0.356: UG1.M8 210.44,81.87 v2(210.38,81.98) ; UG1.L8 211.11,81.87 v2(211.02,81.98)
  BOTTOM w0.381: v2(218.83,62.93) 218.92,62.93 219.16,63.17 QG2.2 ; v2(191.65,81.49) 190.94,80.79 189.29,80.79 189.18,80.89 188.6,80.89 187.73,80.02 185.76,80.02 184.77,79.04 UG8.2 ; QG2.5 v2(220.7,63.17)
  BOTTOM w0.508: v2(234.37,45.54) 234.34,45.54 232.61,43.81 232.61,42.95 230.95,41.3 228.85,41.3 228.4,40.85 RG3019.1
  vias: v2(193.59,96.95) v2(194.41,96.93) v2(195.15,96.95) v2(195.99,96.97) v2(196.8,96.97) v2(197.7,96.09) v2(197.68,90.31) v2(197.7,87.73) v2(197.7,84.42) v2(198.95,89.1) v2(198.95,88.09) v2(198.96,86.21) v2(198.96,85.49) v2(240.01,44.48) v2(240.3,44.96) v2(240.55,44.34) v2(240.84,44.82) v2(241.11,44.31) v2(241.4,44.86) v2(241.67,44.37) v3(193.26,95.01) v6(189.77,97.05) v6(190.48,96.99) v6(190.8,96.45) v6(191.19,95.92)
+1.24V_PRIM_DPHY: length 5
  TOP w0.508: RH174.1 205.57,25.68 205.82,25.93 205.82,26.82 205.66,26.99 v1(205.43,26.99) 203.79,26.99 v2(203.65,27.12)
  BOTTOM w0.254: UH1.AJ23 v2(203.65,27.12) UH1.AJ22
+1.24V_PRIM_MAR: length 3.2
  TOP w0.127: v2(213.37,16.57) 213.82,16.57 214,16.39 v1(214,16.22)
  TOP w0.508: v2(213.37,16.57) 212.72,16.57 CH36.1
  BOTTOM w0.254: v2(213.37,16.57) 212.46,17.48 UH1.BG5
+1.24V_VCCLDOSRAM_IN: length 3
  TOP w0.127: v1(203.28,25.73) 203.28,26.17 203.5,26.4 v2(203.63,26.4)
  TOP w0.508: RH174.2 203.91,26.04 203.91,26.12 v2(203.63,26.4)
  BOTTOM w0.254: UH1.AK23 v2(203.63,26.4) UH1.AK22
+1.35VRAMP: length 6
  TOP w0.127: v2(251.7,57.97) 252.39,57.97 v1(253.32,57.05)
  BOTTOM w0.254: v2(245.4,63.17) 245,62.77 245,60.96 244.12,60.08 PRW9.1
  vias: v2(245.93,62.92) v2(246.17,62.4) v2(246.3,63.34) v2(246.51,61.94) v2(246.71,62.93) v2(246.92,62.35) v2(246.92,61.52) v2(247.33,61.94) v2(247.54,61.28) v2(247.95,61.69) v2(247.95,60.87) v2(248.36,61.28) v2(248.78,60.87) v2(249.19,60.45) v2(249.6,60.04) v2(249.6,59.21) v2(250.02,59.63) v2(250.02,58.8) v2(250.43,59.21) v2(250.43,58.39) v2(250.84,58.8) v2(250.86,57.97) v2(251.28,58.38) v2(251.29,57.52)
+1.35VSDGPU: length 26.1
  TOP w0.254: v2(216.98,91.12) 216.98,91.2 217.43,91.65 CG19.1
  TOP w0.4: v2(221.4,129.8) v2(222.2,129.8) v2(223,129.8) v2(223,129) ; v2(213.2,130.2) UG4.M1 v2(214.2,129.8) ; v2(213.2,130.2) v2(212.6,130.2) ; v2(213.2,130.2) v2(213.2,129.4) v2(212.6,129.4) ; v2(212.6,131.8) v2(213.2,131.8) ; v2(212.6,133.4) v2(213.2,133.4)
  TOP w0.406: v2(224.8,129.4) UG4.L14 v2(223.8,129) v2(223,129) ; v2(215,129) v2(215.8,129.8)
  IN1 w0.508: 242.14,65.42 242.14,63.95 244.2,61.89 v2(244.2,61.52)
  IN3 w0.4: v2(222.2,132.2) v2(222.2,133) v2(221.4,133)
  BOTTOM w0.305: v2(236.64,76.67) 237.04,76.28 UG6.C5
  BOTTOM w0.4: UG1.T33 206.93,101.94 v2(206.91,101.94) ; UG1.W30 205.22,99.55 v2(205.28,99.55) ; v2(219.38,85.27) 219.38,85.29 UG1.B13 ; UG1.AB33 202.08,102.59 201.93,102.74 v2(201.91,102.74) ; UG1.E13 v2(216.16,86.12) ; UG1.W33 v2(204.83,102.94) ; v2(216.98,91.12) 216.98,91.09 UG1.E19 ; v2(216.16,88.62) UG1.E16 ; UG1.T30 v2(207.76,99.52) ; UG1.AA30 v2(202.76,99.52) ; v2(219.38,91.12) 219.38,91.09 UG1.B19 ; v2(219.63,88.19) UG1.B16
  BOTTOM w0.406: v2(215.8,121.8) 215.4,122.19 UG4.B3
  BOTTOM w0.508: v2(244.2,61.52) 244.2,61.32 RG45.2
  vias: v2(185.95,133.4) v2(185.95,131.8) v2(185.95,130.2) v2(185.95,126.2) v2(185.95,125.4) v2(185.95,123.8) v2(185.95,122.2) v2(186.55,133.4) v2(186.55,131.8) v2(186.55,130.2) v2(186.55,129.4) v2(186.55,126.2) v2(186.55,125.4) v2(186.55,123.8) v2(186.55,122.2) v2(187.55,130.6) v2(187.55,129) v2(187.55,125.8) v2(188.35,129.8) v2(188.35,129) v2(188.35,126.6) v2(188.35,125.8) v2(188.35,123.4) v2(188.35,121.8) v2(188.35,121) v2(189.15,133) v2(189.15,132.2) v2(189.15,129.8) v2(189.15,125.8) v2(189.15,123.4) v2(189.95,132.2) v2(189.95,124.2) v2(189.95,122.6) v2(190.76,133) v2(190.75,131.4) v2(190.75,130.6) v2(193.3,131.4) v2(193.95,133) v2(193.95,130.6) v2(193.95,124.2) v2(194.75,125.8) v2(194.75,125) v2(194.75,124.2) v2(194.75,122.6) v2(195.55,129.8) v2(195.55,128.2) v2(195.55,125.8) v2(195.55,123.4) v2(195.55,121.8) v2(196.35,133) v2(196.35,132.2) v2(196.35,129.8) v2(196.35,126.6) v2(196.35,125.8) v2(196.36,120.94) v2(197.15,125.8) v2(197.15,124.2) v2(197.15,121.8) v2(198.15,133.37) v2(198.15,131.8) v2(198.15,130.39) v2(198.15,129.4) v2(198.15,126.2) v2(198.15,125.4) v2(198.15,123.8) v2(198.15,122.2) v2(198.75,131.8) v2(198.78,130.31) v2(198.77,129.37) v2(198.75,127.78) v2(198.75,126.2) v2(198.75,125.4) v2(198.75,123.8) v2(198.75,122.2) v2(200.34,96.98) v2(201.06,97.01) v2(201.91,97.08) v2(202.76,97.08) v2(203.55,97.85) v2(203.59,97.06) v2(205.26,97.84) v2(205.25,97.08) v2(208.58,97.06) v2(209.41,97.07) v2(210.26,97.09) v2(211.03,97.01) v2(212.6,126.2) v2(212.6,125.4) v2(212.6,123.8) v2(212.6,122.2) v2(212.82,96.55) v2(213.2,126.2) v2(213.2,125.4) v2(213.2,123.8) v2(213.2,122.2) v2(213.34,94.65) v2(213.53,94.11) v2(213.6,91.17) v2(213.6,89.27) v2(213.63,84.49) v2(213.69,92.69) v2(213.68,85.25) v2(213.66,82.67) v2(213.69,81.92) v2(214.2,125.8) v2(214.49,92.77) v2(214.47,83.58) v2(215,132.2) v2(215,126.6) v2(215,125.8) v2(215,123.4) v2(215,121.8) v2(215,121) v2(215.8,133) v2(215.8,128.2) v2(215.8,127.4) v2(215.8,125.8) v2(216.6,129) v2(216.6,125) v2(216.6,124.2) v2(216.6,122.6) v2(217.4,133) v2(217.4,130.6) v2(217.79,131.85) v2(220.6,133) v2(220.58,130.63) v2(221.4,124.2) v2(221.4,122.6) v2(222.2,125.8) v2(222.2,123.4) v2(223,126.6) v2(223.04,125.84) v2(223,121.8) v2(223.8,125.8) v2(224.8,133.4) v2(224.8,131.8) v2(224.8,130.2) v2(224.8,126.2) v2(224.8,125.4) v2(224.8,123.8) v2(224.8,122.2) v2(225.4,133.4) v2(225.4,131.8) v2(225.4,130.2) v2(225.4,126.2) v2(225.4,125.39) v2(225.4,123.8) v2(225.4,122.2) v2(229.76,128.69) v2(232.75,136.42) v2(235.04,102.09) v2(235.04,94.89) v2(235.04,78.27) v2(235.04,70.27) v2(235.84,102.09) v2(235.84,94.89) v2(235.84,78.27) v2(235.84,70.27) v2(236.24,104.49) v2(236.24,103.89) v2(236.24,92.29) v2(236.24,91.69) v2(236.24,80.67) v2(236.24,80.07) v2(236.24,68.47) v2(236.64,100.49) v2(236.64,95.69) v2(236.64,94.09) v2(236.64,71.87) v2(237.44,102.09) v2(237.44,101.29) v2(237.44,78.27) v2(237.44,71.07) v2(237.84,104.49) v2(237.84,103.89) v2(237.84,92.29) v2(237.84,91.69) v2(237.84,80.67) v2(237.84,80.07) v2(237.84,68.47) v2(237.84,67.87) v2(238.24,100.49) v2(238.24,95.69) v2(238.24,94.09) v2(238.24,76.67) v2(238.24,71.87) v2(238.36,96.5) v2(238.46,75.81) v2(239.04,95.69) v2(239.04,78.27) v2(239.04,76.67) v2(239.44,104.49) v2(239.44,103.89) v2(239.42,92.29) v2(239.42,91.69) v2(239.44,68.47) v2(239.44,67.87) v2(239.85,102.88) v2(239.84,102.09) v2(239.84,101.29) v2(239.84,95.69) v2(239.84,94.89) v2(239.84,94.09) v2(239.84,93.29) v2(239.84,79.07) v2(239.84,77.47) v2(239.84,71.07) v2(239.84,70.27) v2(240.23,104.48) v2(240.24,103.89) v2(240.24,80.67) v2(240.24,80.07) v2(240.26,92.29) v2(240.26,91.69) v2(240.28,68.47) v2(240.28,67.87) v2(240.64,102.09) v2(240.64,94.09) v2(240.64,77.47) v2(240.64,70.27) v2(241.01,67.84) v2(241.44,77.47) v2(242.24,94.89) v2(242.24,77.47) v2(243.04,102.89) v2(243.04,102.09) v2(243.04,94.09) v2(243.04,77.47) v2(243.04,76.67) v2(243.04,70.27) v2(243.04,69.47) v2(243.44,103.89) v2(243.44,92.29) v2(243.44,91.69) v2(243.44,80.67) v2(243.44,80.07) v2(243.44,68.47) v2(243.53,104.55) v2(243.84,102.09) v2(243.84,101.29) v2(243.84,94.89) v2(243.84,93.29) v2(243.84,78.27) v2(243.84,77.47) v2(243.84,71.87) v2(243.84,71.07) v2(243.84,69.47) v2(244.24,104.49) v2(244.24,103.89) v2(244.24,92.29) v2(244.24,91.69) v2(244.24,80.66) v2(244.24,80.07) v2(244.24,68.47) v2(244.24,67.87) v2(244.64,99.69) v2(244.64,96.49) v2(244.64,94.09) v2(244.64,75.87) v2(244.61,72.7) v2(245.44,78.27) v2(245.44,71.87) v2(245.47,99.66) v2(245.48,74.27) v2(245.73,97) v2(245.84,104.49) v2(245.84,103.89) v2(245.84,92.29) v2(245.84,91.69) v2(245.84,80.67) v2(245.84,80.07) v2(245.84,68.47) v2(245.84,67.87) v2(246.24,101.29) v2(246.24,100.49) v2(246.24,96.49) v2(246.24,95.69) v2(246.24,94.09) v2(246.24,79.07) v2(246.24,76.67) v2(246.24,75.87) v2(246.24,71.07) v2(247.04,101.29) v2(247.04,99.69) v2(247.04,96.49) v2(247.04,94.89) v2(247.04,77.47) v2(247.04,76.67) v2(247.04,75.87) v2(247.04,72.67) v2(247.04,71.87) v2(247.04,71.07) v2(247.44,104.49) v2(247.44,103.89) v2(247.44,92.29) v2(247.44,91.69) v2(247.44,80.67) v2(247.44,80.07) v2(247.44,68.47) v2(247.44,67.87) v2(248.64,76.67) v2(249.04,104.49) v2(249.43,65.76) v2(249.84,66.21) v2(249.84,65.35) v2(250.27,66.63) v2(250.25,65.79) v2(250.26,64.93) v2(250.68,66.21) v2(250.66,65.38) v2(250.67,64.52) v2(250.76,67.01) v2(251.1,65.8) v2(251.08,64.97) v2(251.08,64.11) v2(251.16,67.46) v2(251.17,66.6) v2(251.51,65.39) v2(251.49,64.55) v2(251.58,67.04) v2(251.58,66.19) v2(251.92,64.97) v2(251.9,64.14) v2(251.99,66.63) v2(252.04,65.76) v2(252.34,64.56) v2(252.45,66.21) v2(252.45,65.35) v3(245.71,87.62)
