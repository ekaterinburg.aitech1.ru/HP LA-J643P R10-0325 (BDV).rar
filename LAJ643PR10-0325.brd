# Allegro board LAJ643PR10-0325.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on BOTTOM (solid shape): 122.13,91.84 122.13,89.69 122,89.56 120.48,89.56 119.94,89.02 119.78,89.02 119.57,88.81 119.57,86.18 117.99,84.61 114.74,84.61 114.39,84.95 114.39,88.55 117.94,92.1 121.87,92.1
GND on BOTTOM (solid shape): 137.52,104.44 137.54,104.41 137.6,104.35 137.6,104.12 137.19,103.72 137.19,103.15 137.06,103.02 136.88,103.02 136.75,103.15 136.75,103.71 136.81,103.77 136.81,103.99 137.32,104.5 137.45,104.5
GND on BOTTOM (solid shape): 210.21,73.22 210.21,73 212.04,71.18 212.04,71.14 211.83,70.94 211.69,70.94 211.5,70.75 211.5,70.35 211.41,70.26 210.28,70.26 210.22,70.32 210.22,72.21 209.69,72.74 209.69,73.26 209.71,73.27 210.16,73.27
GND on BOTTOM (solid shape): 148.54,104.44 148.58,104.39 148.62,104.36 148.9,104.08 148.9,103.93 149.01,103.83 149.01,103.15 148.87,103.02 148.69,103.02 148.56,103.15 148.56,103.78 148.18,104.16 148.18,104.35 148.31,104.48 148.5,104.48
GND on BOTTOM (solid shape): 213.8,41.22 213.8,40.84 213.81,40.83 213.81,40.81 214.01,40.61 214.03,40.61 214.12,40.52 214.12,40.36 214.03,40.27 212.67,40.27 212.65,40.28 212.37,40.28 212.3,40.36 212.3,40.47 212.39,40.56 212.59,40.56 213.42,41.39 213.63,41.39
GND on BOTTOM (solid shape): 285.09,25.08 285.09,23.8 286.35,22.55 288.56,22.55 289.17,21.93 289.17,17.7 288.99,17.52 286.59,17.52 281.59,22.52 281.59,25.12 281.67,25.19 284.98,25.19
GND on BOTTOM (solid shape): 169.37,109.39 169.37,107.47 169.07,107.16 168.74,107.16 168.33,106.75 167.74,106.75 167.59,106.9 167.59,107.85 167.34,108.1 166.45,108.1 166.32,108.23 166.32,108.61 166.45,108.74 167.47,108.74 168.23,109.5 168.24,109.5 168.38,109.64 169.12,109.64
GND on BOTTOM (solid shape): 225.83,121.31 226.57,121.31 226.82,121.06 226.82,120.13 226.77,120.08 226.19,120.08 225.67,120.61 224.57,120.61 224.44,120.74 224.44,121.2 224.39,121.26 224.11,121.26 224.06,121.31 224.06,121.5 224.1,121.55 224.6,121.55 224.71,121.65 225.49,121.65
GND on BOTTOM (solid shape): 143.82,104.44 143.85,104.39 143.9,104.36 143.92,104.34 143.95,104.33 144.01,104.27 144.01,104.16 144.28,103.88 144.28,103.15 144.15,103.02 143.96,103.02 143.84,103.15 143.84,103.78 143.46,104.16 143.46,104.35 143.58,104.48 143.77,104.48
GND on BOTTOM (solid shape): 213.92,121.51 213.92,121.3 213.88,121.26 213.56,121.26 213.43,121.12 213.43,120.61 212.9,120.08 212.49,120.08 211.68,119.27 211.03,119.27 210.78,119.53 210.78,120.72 210.86,120.8 212,120.8 212.39,121.19 212.39,121.51 212.43,121.56 213.87,121.56
GND on BOTTOM (solid shape): 240.19,11.5 240.19,9.5 240.14,9.45 239.81,9.45 239.48,9.12 239.27,9.12 238.99,9.4 237.49,9.4 237.42,9.32 237.42,9.24 237.29,9.12 237.06,9.12 236.86,9.32 236.86,10.89 236.63,11.12 236.38,11.12 236.25,11.25 236.25,11.73 236.3,11.78 239.91,11.78
GND on BOTTOM (solid shape): 7.5,122.1 0.2,122.1 0.2,127.9 0.44,128.46 1,128.7 7.5,128.7
GND on BOTTOM (solid shape): 108.92,95.53 112.98,95.53 113.11,95.4 113.11,94.64 113.24,94.51 114.25,94.51 114.51,94.77 115.65,94.77 115.91,94.51 115.91,94.13 115.78,94 114.51,94 114.25,93.75 114.25,93.11 114.13,92.99 109.3,92.99 109.05,92.73 109.05,92.1 108.92,91.97 108.03,91.97 107.9,92.1 107.9,95.53 108.03,95.65 108.79,95.65
GND on BOTTOM (solid shape): 219.6,60.16 219.6,59.33 219.71,59.22 220.56,59.22 221.01,59.68 222.55,59.68 222.6,59.62 222.6,59.29 222.5,59.19 222.13,59.19 221.2,58.27 218.71,58.27 218.57,58.4 218.57,58.68 218.77,58.89 218.95,58.89 219.36,59.31 219.36,60.13 219.44,60.2 219.55,60.2
GND on BOTTOM (solid shape): 32.09,53.36 33.1,53.36 33.85,52.61 33.85,48.9 33.67,48.71 30.2,48.71 30.19,48.72 29.16,48.72 29.06,48.81 29.06,49.24 29.1,49.29 29.66,49.29 29.74,49.36 29.74,51.74 29.94,51.94 29.98,51.98 31.36,53.36 31.45,53.36 31.45,53.37 32.09,53.37
GND on BOTTOM (solid shape): 256.87,14.54 257.46,14.54 257.54,14.45 257.54,13.73 257.47,13.65 256.48,13.65 256.48,13.65 254.86,13.65 254.62,13.41 254.6,13.41 254.6,11.85 254.44,11.68 254.14,11.68 253.95,11.73 253.77,11.68 252.07,11.68 252,11.76 252,13.65 252.19,13.84 253.34,13.84 254.23,14.73 254.28,14.77 256.63,14.77
GND on BOTTOM (solid shape): 189.44,103.15 189.44,99.59 189.45,99.58 189.45,99.29 189.61,99.13 190.49,99.13 190.66,98.96 190.66,98.11 190.52,97.97 188.58,97.97 188.57,98 188.35,98.22 188.05,98.19 188.02,98.17 187.97,98.23 187.97,100.17 188.17,100.37 188.17,103.35 188.23,103.41 189.17,103.41
GND on BOTTOM (solid shape): 264.73,22 264.91,22 265.06,21.85 265.06,21.72 264.73,21.39 264.73,20.22 265.01,19.93 265.64,19.93 266.73,18.83 267.57,18.83 267.77,18.64 267.77,17.99 267.75,17.97 265.76,17.97 265.64,18.09 265.64,18.9 265.55,18.99 264.87,18.99 264.6,19.25 264.6,19.27 264.59,19.27 264.53,19.32 264.17,19.32 263.84,19.65 263.84,21.16 263.8,21.2 262.86,21.2 262.78,21.28 262.78,21.9 262.89,22.01 264.72,22.01
GND on BOTTOM (solid shape): 184.73,106.1 184.74,106.1 184.82,106.02 184.82,105.47 184.84,105.46 184.84,105.18 184.74,105.08 184.74,103.93 185.2,103.48 185.2,101.79 185.22,101.77 185.22,99.16 184.82,98.75 183.16,98.75 183.09,98.83 183.09,100.58 183.34,100.84 184.38,100.84 184.49,100.94 184.49,101.9 184.08,102.31 184.08,103.58 184.49,103.99 184.49,105.01 184.01,105.48 183.27,105.48 183.22,105.53 183.22,106.11 183.26,106.16 184.68,106.16
GND on BOTTOM (solid shape): 80.55,10.64 80.55,9.37 80.81,9.11 81.57,9.11 81.82,8.86 81.82,6.55 81.6,6.32 80.08,6.32 80.07,6.33 79.01,6.33 78.65,6.69 78.65,6.83 78.65,6.83 78.65,7.33 78.01,7.97 73.7,7.97 73.57,8.1 73.57,8.99 73.7,9.11 73.95,9.11 74.33,8.73 78.64,8.73 78.93,9.02 79.26,9.02 79.41,9.17 79.41,10.81 79.48,10.88 80.31,10.88
GND on BOTTOM (solid shape): 252.21,34.5 252.21,32.74 252.11,32.64 250.04,32.64 250.02,32.61 249.85,32.61 249.57,32.32 249.57,31.02 249.88,30.71 249.88,29.37 249.57,29.07 249.57,27.97 249.66,27.88 249.66,27.53 249.58,27.45 249.34,27.45 249.26,27.53 249.23,27.59 249.23,27.75 249.25,27.8 249.26,27.82 249.26,27.92 249.33,27.99 249.33,29.01 248.93,29.41 248.93,31.17 248.88,31.21 248.88,32.43 248.65,32.67 248.65,33.7 248.08,34.26 248.08,34.81 248.12,34.84 251.86,34.84
GND on BOTTOM (solid shape): 135.16,104.44 135.18,104.41 135.23,104.35 135.23,104.12 134.83,103.72 134.83,103.15 134.7,103.02 134.52,103.02 134.39,103.15 134.39,103.72 133.97,104.14 133.97,104.31 134.13,104.48 134.32,104.48 134.37,104.44 134.4,104.39 134.45,104.36 134.47,104.34 134.5,104.33 134.6,104.31 134.7,104.33 134.74,104.34 134.8,104.39 134.9,104.5 135.09,104.5
GND on BOTTOM (solid shape): 156.42,104.44 156.44,104.41 156.49,104.35 156.49,104.12 156.09,103.72 156.09,103.15 155.96,103.02 155.78,103.02 155.65,103.15 155.65,103.7 155.23,104.12 155.23,104.32 155.39,104.48 155.58,104.48 155.63,104.44 155.66,104.39 155.71,104.36 155.73,104.34 155.76,104.33 155.86,104.31 155.96,104.33 156,104.34 156.06,104.39 156.16,104.5 156.35,104.5
GND on BOTTOM (solid shape): 242.93,28.36 242.93,27.52 242.83,27.43 242.83,26.84 242.71,26.72 241.92,26.72 241.41,26.21 240.41,26.21 240.29,26.09 240.07,26.09 239.98,26.17 239.98,26.91 239.87,27.02 238.88,27.02 238.49,26.63 237.27,26.63 237.19,26.7 237.19,26.98 237.15,27.02 235.63,27.02 235.5,26.89 235.32,26.89 235.19,27.02 235.19,27.22 235.3,27.33 235.54,27.33 235.61,27.26 236.54,27.26 236.54,27.26 237.04,27.26 237.25,27.47 237.25,27.62 237.34,27.7 240.15,27.7 240.42,27.98 240.42,28.41 240.54,28.52 242.76,28.52
GND on BOTTOM (solid shape): 244.11,43.93 244.11,43.15 244.25,43.01 245.32,43.01 245.52,43.21 247.61,43.21 247.76,43.06 247.76,41.85 247.59,41.68 246.05,41.68 245.63,42.1 242.68,42.1 242,41.43 240.45,41.43 240,40.98 240,40.97 239.97,40.94 239.97,40.16 240.14,40 240.24,39.9 240.25,39.9 240.52,39.9 240.61,39.81 240.61,39.01 240.53,38.92 239.79,38.92 239.62,39.09 239.62,41.86 239.3,42.18 239.3,42.85 239.66,43.21 242.2,43.21 242.4,43.01 243.69,43.01 243.93,43.25 243.93,43.91 243.99,43.97 244.07,43.97
GND on BOTTOM (solid shape): 202.27,62.39 202.27,58.91 202.39,58.79 205.83,58.79 205.95,58.67 205.95,57.75 206.03,57.67 207.76,57.67 208.04,57.95 208.04,58.79 208.19,58.94 210.19,58.94 210.39,58.75 213.74,58.75 213.85,58.63 213.85,57.8 213.97,57.68 215.17,57.68 215.4,57.9 215.4,58.19 215.72,58.52 217.47,58.52 217.86,58.13 217.86,56.6 217.73,56.47 215.14,56.47 214.9,56.23 210.38,56.23 210.07,56.54 207.68,56.54 207.55,56.41 207.16,56.41 207,56.25 202.43,56.25 202.05,56.64 199.69,56.64 199.24,56.19 193.7,56.19 193.55,56.33 193.55,58.15 193.55,58.15 193.55,58.61 193.67,58.72 197.82,58.72 197.91,58.64 197.91,57.77 198.01,57.67 199.67,57.67 199.88,57.87 199.88,62.55 200.02,62.7 201.97,62.7
GND on BOTTOM (solid shape): 176.04,101.23 176.25,101.16 176.46,101.23 176.63,101.23 178.07,99.79 178.07,99.51 177.92,99.35 177.61,99.35 177.02,99.95 176.35,99.95 176.31,99.91 176.23,99.88 176.16,99.91 175.58,99.82 175.88,99.31 175.92,99.3 175.93,99.26 175.93,98.69 175.51,98.27 175.41,98.27 174.97,98.7 174.49,98.7 173.96,99.23 173.96,99.46 175.73,101.23
GND on BOTTOM (solid shape): 169.82,40.96 169.93,40.98 170,40.89 170,40.82 170.27,40.54 170.28,40.53 170.39,40.38 170.58,40.32 171.42,40.32 171.57,40.17 171.57,39.13 171.29,38.85 171.22,38.81 171.14,38.84 170.82,39.15 170.79,39.24 170.85,39.31 170.96,39.87 170.39,39.83 170.18,39.83 169.72,40.29 169.7,40.31 169.57,40.44 169.57,40.71
GND on BOTTOM (solid shape): 191.92,41.04 191.93,41.04 192.4,40.57 192.61,40.57 192.61,40.28 192.57,40.24 192.54,40.25 192.25,40.19 192.12,39.92 192.1,39.86 192.05,39.82 192,39.8 191.96,39.77 191.6,39.77 191.47,39.65 191.47,39.58 191.4,39.46 191.42,39.32 191.42,39.25 191.37,39.19 191.2,38.88 191.43,38.6 191.47,38.59 191.47,38.38 191.34,38.25 191.09,38.25 190.96,38.38 190.96,39.65 190.84,39.77 190.8,39.77 190.79,39.78 190.69,39.8 190.58,39.78 190.57,39.77 186.52,39.77 186.39,39.9 186.39,40.92 186.8,41.33 186.81,41.33 186.92,41.36 187.01,41.42 191.54,41.42
GND on BOTTOM (solid shape): 1.92,59.05 6.3,59.05 8.04,57.3 8.21,57.3 8.46,57.05 8.46,56.8 8.03,56.37 7.9,56.37 7.89,56.38 7.19,56.4 6.94,55.74 6.94,55.74 6.94,55.52 6.56,55.14 6.3,55.14 5.8,55.65 5.15,55.65 5.07,55.72 5.07,55.87 5.07,55.87 5.07,57.25 4.46,57.89 3.71,57.43 3.7,57.39 0.65,57.39 0.65,58.37 0.65,58.37 0.65,58.64 0.82,59.12 1.23,59.4 1.38,59.45 1.52,59.45
GND on BOTTOM (solid shape): outline of 94 points within 127.21,121.5 156.8,129.94
GND on BOTTOM (solid shape): 14.94,83.08 14.94,82.07 14.36,81.48 14.33,81.5 13.85,81.23 14.2,80.81 14.27,80.78 14.31,80.71 14.31,80.52 14.26,80.43 14.16,80.43 13.9,80.45 13.69,80.29 2.73,80.29 2.73,81 2.97,81.56 3.53,81.8 11.23,81.8 12,81.3 12.6,82 12.6,83.46 14.56,83.46
GND on BOTTOM (solid shape): 6.94,49.43 6.94,49.2 6.92,49.13 6.92,49.05 6.92,48.93 6.99,48.65 7.17,48.44 7.19,48.41 7.21,48.41 7.53,48.32 7.85,48.41 8.34,48.41 8.59,48.16 8.59,43.13 8.69,43.03 9.42,43.03 9.43,43.03 13.84,43.03 13.84,45.03 26.14,45.03 28.14,43.03 33.56,43.03 33.56,41.79 33.1,41.79 33.1,42.57 25.1,42.57 25.1,44.57 15.88,44.57 14.29,44.57 14.29,42.57 4.3,42.57 4.15,42.57 4.15,43.07 1.45,43.07 0.88,43.31 0.65,43.87 0.65,44.72 0.65,44.72 0.65,44.87 0.65,44.87 0.65,47.49 3.7,47.49 4.44,46.99 5.07,47.63 5.07,48.61 5.07,48.61 5.07,49.05 5.53,49.05 5.54,49.04 6.3,49.81 6.56,49.81
GND on BOTTOM (solid shape): outline of 115 points within 209.4,30.85 212.97,31.99
GND on BOTTOM (solid shape): 15.7,105.56 15.7,95.27 14.69,94.26 12.6,94.26 12.6,95.2 12.6,95.2 12.6,95.65 12.03,96.34 11.24,95.9 1.75,95.9 1.19,96.14 0.95,96.7 0.95,100.95 1.19,101.51 1.75,101.75 2,101.75 2.5,101.95 2.7,102.45 2.7,102.9 2.94,103.46 3.5,103.7 9.75,103.7 10.45,104.3 9.95,105.07 9.96,105.1 9.96,106.18 10.11,106.18 10.11,106.2 10.37,106.45 14.81,106.45
GND on BOTTOM (solid shape): 143.13,109.65 143.13,109.35 143.02,109.14 143.13,108.94 143.13,108.7 143.02,108.49 143.13,108.29 143.13,108.05 143.02,107.84 143.13,107.64 143.13,107.4 143.03,107.13 143.25,106.95 143.27,106.95 143.85,106.37 143.85,106.07 143.66,105.89 143.64,105.89 143.43,105.79 143.34,105.58 143.34,105.56 143.26,105.49 143.24,105.48 143.09,105.41 143.02,105.26 143.02,105.24 142.7,104.93 142.7,102.59 142.45,102.33 141.66,102.33 141.48,102.51 141.48,103.94 141.98,104.44 141.98,104.67 141.87,104.78 141.87,105.03 141.99,105.15 142.15,105.15 142.18,105.17 142.18,105.17 142.28,105.27 142.29,105.3 142.32,105.36 142.37,105.4 142.41,105.43 142.41,105.71 142.37,105.73 142.28,105.89 142.37,106.05 142.41,106.08 142.41,106.36 142.37,106.38 142.28,106.54 142.37,106.7 142.41,106.73 142.41,107.01 142.37,107.03 142.28,107.19 142.37,107.35 142.41,107.38 142.41,107.66 142.37,107.68 142.28,107.84 142.37,108 142.41,108.03 142.41,108.31 142.37,108.34 142.28,108.49 142.37,108.65 142.41,108.68 142.41,108.96 142.37,108.99 142.28,109.14 142.37,109.3 142.41,109.33 142.41,109.72 142.39,109.74 142.38,109.8 142.43,109.83 142.96,109.83
GND on BOTTOM (solid shape): outline of 353 points within 56.1,33.68 90.62,46.3
GND on BOTTOM (solid shape): outline of 614 points within 198.16,25.26 206.81,31.58
GND on BOTTOM (solid shape): outline of 3035 points within 0.2,0.2 313.4,137.62
GND on BOTTOM (solid shape): outline of 17694 points within 100.08,27.5 172.39,55.59
GND on IN1 (solid shape): 14.94,83.08 14.94,82.07 14.43,81.56 13.92,81.56 13.54,81.18 13.54,80.64 2.95,80.64 2.93,80.66 2.73,80.66 2.73,81 2.97,81.56 3.53,81.8 11.23,81.8 12,81.3 12.6,82 12.6,83.36 13.06,83.36 13.16,83.46 14.56,83.46
GND on IN1 (solid shape): 6.99,49.68 6.99,49.34 6.98,49.33 6.94,49.19 6.92,49.05 6.92,48.93 7.23,48.39 7.85,48.41 7.87,48.42 8.43,48.42 8.59,48.26 8.59,43.38 8.94,43.03 13.84,43.03 13.84,45.03 25.56,45.03 25.56,44.22 27.06,44.22 27.83,43.44 27.84,43.44 27.84,43.03 33.56,43.03 33.56,41.79 33.1,41.79 33.1,42.57 25.1,42.57 25.1,44.57 17.15,44.57 14.29,44.57 14.29,42.57 4.67,42.57 4.15,42.57 4.15,43.07 1.45,43.07 0.88,43.31 0.65,43.87 0.65,44.46 0.65,44.46 0.65,44.9 0.65,44.9 0.65,47.49 3.7,47.49 3.71,47.45 4.46,46.99 5.07,47.63 5.07,49.02 5.54,49.02 5.54,49.03 6.32,49.81 6.86,49.81
GND on IN1 (solid shape): outline of 110 points within 0.65,55.04 8.67,59.45
GND on IN1 (solid shape): 14.43,106.07 14.43,98.58 14.49,98.52 14.49,98.48 15.7,97.26 15.7,95.27 14.69,94.26 13.06,94.26 13.06,94.12 12.6,94.12 12.6,95.27 12.6,95.27 12.6,95.65 12.03,96.34 11.24,95.9 1.75,95.9 1.19,96.14 0.95,96.7 0.95,100.95 1.19,101.51 1.75,101.75 2,101.75 2.5,101.95 2.7,102.45 2.7,102.9 2.94,103.46 3.5,103.7 9.75,103.7 10.45,104.3 9.95,105.07 9.95,106.03 10.37,106.45 14.05,106.45
GND on IN1 (solid shape): outline of 3019 points within 0.2,0.2 313.4,137.62
GND on IN2 (solid shape): 13.06,83.46 14.56,83.46 14.94,83.08 14.94,82.07 14.36,81.48 14.33,81.5 13.95,81.42 13.86,81.05 13.87,81.02 13.48,80.63 2.89,80.63 2.86,80.66 2.73,80.66 2.73,81 2.97,81.56 3.53,81.8 11.23,81.8 12,81.3 12.6,82 12.6,83.49 13.06,83.49
GND on IN2 (solid shape): outline of 113 points within 0.65,55.04 8.72,59.45
GND on IN2 (solid shape): outline of 139 points within 0.65,41.79 33.56,49.81
GND on IN2 (solid shape): 15.03,106.23 15.03,96.7 15.7,96.03 15.7,95.27 13.97,93.55 13.4,93.55 13.4,93.55 13.2,93.57 13,93.55 13,93.55 12.86,93.55 12.83,93.57 12.6,93.57 12.6,95.02 12.6,95.02 12.6,95.65 12.03,96.34 11.24,95.9 1.75,95.9 1.19,96.14 0.95,96.7 0.95,100.95 1.19,101.51 1.75,101.75 2,101.75 2.5,101.95 2.7,102.45 2.7,102.9 2.94,103.46 3.5,103.7 9.75,103.7 10.45,104.3 9.95,105.07 9.95,105.22 9.96,105.22 9.96,105.29 9.96,105.29 9.96,106.27 10.14,106.45 14.81,106.45
GND on IN2 (solid shape): outline of 3032 points within 0.2,0.2 313.4,137.62
GND on IN2 (solid shape): outline of 20802 points within 181.31,64.67 256.87,137.62
GND on IN3 (solid shape): 14.94,83.08 14.94,82.07 14.55,81.67 13.81,81.67 12.55,80.41 3.26,80.41 3.07,80.61 2.73,80.61 2.73,81 2.97,81.56 3.53,81.8 11.23,81.8 12,81.3 12.6,82 12.6,84.05 13.97,84.05
GND on IN3 (solid shape): outline of 111 points within 0.65,55.01 8.77,59.81
GND on IN3 (solid shape): outline of 133 points within 0.65,41.79 33.56,49.88
GND on IN3 (solid shape): 15.7,105.56 15.7,95.27 14.69,94.26 12.6,94.26 12.6,95.2 12.6,95.2 12.6,95.65 12.03,96.34 11.24,95.9 1.75,95.9 1.19,96.14 0.95,96.7 0.95,100.95 1.19,101.51 1.75,101.75 2,101.75 2.5,101.95 2.7,102.45 2.7,102.9 2.94,103.46 3.5,103.7 9.75,103.7 10.44,104.28 9.98,105.06 10.03,105.06 9.96,105.09 9.96,105.88 9.96,105.88 9.96,106.25 10.16,106.45 14.81,106.45
GND on IN3 (solid shape): outline of 2931 points within 0.2,0.2 313.4,137.62
GND on BOTTOM: 232.36,46.58 232.39,46.56 232.49,46.46 232.49,43.85 231.55,42.9 231.33,42.9 231.26,42.84 230.52,42.84 230.52,42.83 222.97,42.83 222.56,43.24 222.56,45.93 223,46.37 223.88,46.37 224.98,45.27 229.39,45.27 230.88,46.76 231.75,46.76 231.76,46.73 232,46.5 232.32,46.57
GND on GND1, GND2: outline of 231 points within 0.2,0.2 313.4,137.62 ; 9 cut-outs
GND on VCC: 170.82,35.35 170.73,35.11 170.82,34.87 170.82,34.39 169.3,32.88 169.3,31.93 166.96,29.59 132.16,29.59 131.5,30.25 98.97,30.25 98.63,30.58 98.63,46.94 98.2,47.37 74.48,47.37 74.27,47.58 74.27,49.19 82.69,52.75 90.04,58.17 96.68,66.38 100.85,76.08 102.61,76.08 103.23,75.46 110.58,75.46 111.46,76.34 111.46,82.34 114.61,85.49 117.41,85.49 118.06,86.15 118.06,89.83 118.3,90.07 162.66,90.07 163.81,88.92 167.36,88.92 167.74,88.54 168.5,88.54 170.03,87.02 171.43,87.02 174.58,83.86 174.58,83.36 176.25,81.68 177.9,81.68 181.82,77.77 181.82,68.96 177.75,64.9 177.75,51.82 173.46,47.52 173.46,43.94 172.82,43.3 172.82,37.39 170.82,35.39
GND on VCC: 185.98,54.5 185.78,54.7 185.78,58.54 187.76,60.52 188.09,60.52 189.3,59.31 224.31,59.31 228.26,55.36 228.26,54.81 227.96,54.5
GND on VCC: 157.29,119.53 156.4,120.42 132.94,120.42 132.56,120.04 132.01,120.04 131.65,120.4 131.65,121.79 128.61,124.84 128.61,126.49 127.34,127.76 127.34,129.2 127.95,129.82 155.68,129.82 156.31,129.18 156.57,129.18 156.67,129.08 156.67,127.3 157.33,126.64 162.03,126.64 162.26,126.41 162.26,123.87 162.51,123.62 162.51,119.76 162.28,119.53
GND on VCC: 284.67,3.6 284.67,4.93 284.68,4.93 284.69,25.15 283.27,26.57 276.92,26.57 276.59,26.9 276.59,29.2 275.6,30.19 265.05,30.19 264.55,30.68 264.55,41.25 264.86,41.56 312.26,41.56 312.26,41.56 313.4,41.56 313.4,4.4 313.16,3.84 312.6,3.6 ; 1 cut-out
GND on VCC: outline of 100 points within 0.2,50.87 28.43,128.7 ; 3 cut-outs
GND on VCC: 263.56,58.17 263.57,58.17 260.58,55.14 244.28,55.14 244.05,55.37 244.05,64.64 243.52,65.17 225.23,65.17 214.27,76.09 214.27,80.75 213.91,81.11 213.91,83.57 214.32,83.98 214.32,96.62 213.56,97.39 202.88,97.39 202.76,97.41 202.65,97.39 197.94,97.39 197.04,98.32 192.21,98.32 188.42,102.11 188.42,108.08 182.58,113.92 182.58,136.44 182.59,136.45 182.59,137.62 233.45,137.62 234.01,137.38 234.25,136.82 234.25,135 234.92,133.04 237.08,131.61 237.25,131.13 237.25,117.24 241.06,111.2 247.74,108.69 250.25,108.69 250.46,108.6 250.55,108.39 250.55,106.4 250.75,105.9 251.25,105.7 255.32,105.7 255.91,105.43 256.11,104.81 255.44,99 254.62,98.63 254.01,97.98 253.74,96.11 254.2,95.27 254.95,94.68 254.5,90.77 254.56,81.51 256.81,72.54 256.81,71.95 256.41,71.53 255.06,70.89 254.57,70.58 254.18,70.14 254.32,67.47 256.94,66.91 258.29,67.55 258.87,67.59 259.33,67.22 259.33,67.22 260.01,66.06 260.74,64.93 262.75,62.18 265,59.61
GNDA on GND1, GND2: 299.32,21.56 299.14,21.74 297.77,21.74 297.77,21.82 297.67,21.92 297.67,23.5 297.29,23.87 292.74,23.87 292.33,23.47 292.33,22.32 292.42,22.23 292.36,22.17 290.07,22.17 289.92,22.33 289.92,22.51 289.77,22.65 289.29,22.65 288.9,23.04 288.9,24.15 290.03,25.27 291.07,25.27 291.68,25.88 291.96,25.88 292.08,26.01 292.68,26.01 292.81,25.88 293.02,25.88 294.85,27.73 294.85,27.79 295.23,27.79 295.35,27.66 295.61,27.66 298.1,30.14 298.1,30.32 298.28,30.5 298.46,30.5 299.7,31.75 302.12,31.75 302.26,31.9 302.26,31.9 302.92,31.9 303.05,31.77 305.85,31.77 305.98,31.9 307.09,31.9 307.21,31.77 307.77,31.77 307.9,31.64 307.9,30.5 308.03,30.37 308.03,29.87 307.9,29.74 307.9,28.2 307.72,28.01 306.53,28.01 305.94,27.43 302.92,27.43 302.79,27.3 302.19,27.3 302.07,27.43 301.85,27.43 301.53,27.1 301.53,24.89 301.66,24.76 301.66,24.36 301.53,24.23 301.53,21.61 301.48,21.56
GNDA on VCC: 292.81,25.88 293.02,25.88 294.85,27.73 294.85,27.79 295.23,27.79 295.35,27.66 295.61,27.66 298.1,30.14 298.1,30.32 298.28,30.5 298.46,30.5 299.7,31.75 302.12,31.75 302.26,31.9 302.26,31.9 302.92,31.9 303.05,31.77 305.74,31.77 307.28,31.77 307.77,31.77 307.86,31.77 307.97,31.89 309.03,31.89 309.03,31.77 309.12,31.67 309.12,28.23 308.98,28.09 308.97,28.09 308.9,28.01 306.53,28.01 305.94,27.43 302.92,27.43 302.79,27.3 302.19,27.3 302.07,27.43 301.85,27.43 301.53,27.1 301.53,24.89 301.66,24.76 301.66,24.36 301.53,24.23 301.53,21.61 301.48,21.56 299.32,21.56 299.14,21.74 297.77,21.74 297.77,21.82 297.67,21.92 297.67,23.5 297.29,23.87 292.74,23.87 292.33,23.47 292.33,22.32 292.42,22.23 292.36,22.17 290.07,22.17 289.92,22.33 289.92,22.51 289.77,22.66 289.29,22.66 288.91,23.04 288.91,24.15 290.03,25.27 291.07,25.27 291.68,25.88 291.96,25.88 292.08,26.01 292.68,26.01
VCC_5V on BOTTOM (solid shape): 79.28,9.89 79.28,9.22 79.21,9.15 79.21,9.15 79.07,9.18 78.93,9.15 78.92,9.15 78.87,9.15 78.85,9.13 78.21,9.13 78.03,8.95 77.18,8.95 77.09,9.04 77.09,9.2 77.18,9.28 77.84,9.28 78.5,9.95 79.22,9.95
VIN_3V_LCDVDD on TOP (solid shape): 76.05,38.6 76.05,35.62 75.52,35.09 74.51,35.09 74.38,35.22 74.38,38.5 74.57,38.69 75.95,38.69
+2546PWR on TOP (solid shape): 22.62,80.14 22.62,79.74 23.93,78.43 23.93,76.1 23.79,75.96 20.25,75.96 20.13,76.08 20.11,76.08 19.99,76.2 19.99,78.62 20.21,78.83 20.21,80.17 22.6,80.17
+2546PWR on BOTTOM (solid shape): 22.04,78.01 23.1,78.01 23.75,77.36 23.75,76.77 23.68,76.7 20.38,76.7 20.34,76.74 20.34,77.26 20.41,77.33 20.41,79.01 20.47,79.07 20.97,79.07
+FB_PLLAVDD on TOP (solid shape): 211.57,97.87 211.57,97.61 211.84,97.33 211.84,96.54 211.79,96.49 211.54,96.49 211.33,96.7 211.33,96.8 211.39,96.86 211.39,97.22 211.12,97.5 211.12,97.86 211.18,97.92 211.52,97.92
+FB_PLLAVDD on BOTTOM (solid shape): 187.59,95.27 189.39,95.27 189.41,95.25 189.41,93.4 189.63,93.18 189.63,92.92 190.52,92.92 190.52,93.09 191.87,93.09 191.97,92.99 191.97,92.14 191.67,91.84 187.52,91.84 187.43,91.93 187.43,94.81 187.46,94.83 187.46,95.2 187.56,95.3
+FB_PLLAVDD on IN1 (solid shape): outline of 1604 points within 190.37,88.33 214.92,98.06
+GPU_PLLVDD on TOP (solid shape): 214.55,96.7 214.15,96.3 214.15,96.03 214.44,95.74 214.44,95.67 214.19,95.43 214.16,95.42 214.13,95.43 213.85,95.72 213.64,95.72 213.63,95.72 213.56,95.65 212.9,95.65 212.84,95.71 212.84,96.05 213.42,96.62 213.9,96.62 214.27,96.99
+GPU_PLLVDD on TOP (solid shape): 200.84,83.31 200.84,82.7 200.64,82.51 200.51,82.51 200.51,82.38 200.51,82.37 200.51,81.89 200.52,81.87 200.56,81.84 200.66,81.84 200.69,81.81 201.02,81.81 201.02,81.46 200.98,81.41 200.96,81.41 200.82,81.33 200.72,81.19 200.72,81.18 200.38,80.85 200.31,80.85 200.06,80.59 200.06,80.51 200.03,80.44 199.95,80.41 199.89,80.4 199.82,80.38 199.71,80.38 199.52,80.19 199.16,80.19 198.8,80.55 198.74,80.55 198.73,80.56 198.59,80.59 198.44,80.56 198.43,80.55 198.32,80.55 198.15,80.37 197.68,80.37 197.62,80.44 197.62,80.68 197.69,80.75 197.79,80.77 197.81,80.79 197.84,80.79 198.37,81.32 198.66,81.32 198.78,81.2 199.45,81.2 199.5,81.25 199.5,81.35 199.5,81.35 199.5,82.44 199.54,82.48 200.17,82.48 200.21,82.53 200.21,83.31 200.27,83.37 200.78,83.37
+GPU_PLLVDD on TOP (solid shape): outline of 229 points within 191.38,76.41 194.67,80.82
+GPU_PLLVDD on BOTTOM (solid shape): 202.51,81.6 202.51,81.29 202.43,81.21 202.18,81.21 202.05,81.35 201.87,81.39 201.81,81.41 201.77,81.47 201.52,81.73 201.21,81.55 201.2,81.54 201.18,81.52 201.05,81.4 201.03,81.4 200.72,81.08 201.01,80.74 201.03,80.74 201.2,80.56 201.21,80.53 201.2,80.43 201.11,80.39 200.13,80.39 200.08,80.44 200.08,80.5 200.09,80.51 199.83,80.93 199.57,80.51 199.58,80.5 199.58,80.45 199.52,80.39 198.88,80.39 198.81,80.47 198.73,80.53 198.72,80.54 198.26,80.99 198.26,81.17 198.42,81.33 198.71,81.33 198.72,81.3 199.16,81.21 199.17,81.66 199.17,82.1 199.29,82.23 201.88,82.23
+GPU_PLLVDD on IN1 (solid shape): outline of 716 points within 191.37,76.3 200.69,83.64
+LAN_REGOUT on BOTTOM (solid shape): 53.27,18.32 53.32,18.32 54,18.32 54.05,18.32 54.1,18.34 54.36,18.34 54.44,18.26 54.44,17.55 54.14,17.26 54.11,17.28 53.66,17.27 53.58,16.83 53.59,16.82 53.59,16.71 53.57,16.71 53.57,16.69 53.32,16.43 53.32,16 53.22,15.9 51.31,15.9 51.2,16.01 51.2,17.1 52.22,18.13 52.3,18.16 52.38,18.12 52.75,17.99 53.01,18.29 53.02,18.34 53.22,18.34
+LAN_VDD_1V0 on BOTTOM (solid shape): 55.25,18.29 55.25,17.5 55.34,17.4 55.34,16.76 55.41,16.7 55.41,16.67 55.41,16.55 55.45,16.44 55.45,16.43 55.45,16.33 55.43,16.33 55.43,14.1 55.27,13.95 55.26,13.94 55.09,13.8 55.03,13.59 55.03,13.57 54.18,12.72 52.69,12.72 52.69,12.82 52.5,13.01 52.02,13.01 51.97,12.96 51.31,12.96 51.18,13.09 51.14,13.14 51.09,13.18 51.01,13.26 51.01,15.39 51.26,15.64 53.04,15.64 53.29,15.39 53.29,14.37 53.42,14.25 54.69,14.25 54.95,14.5 54.95,18.29 55,18.34 55.2,18.34
+LAN_VDD_1V0 on IN2 (solid shape): outline of 180 points within 50.91,14.85 54.84,24.33
+LAN_VDD_3V3 on TOP (solid shape): outline of 198 points within 50.99,14.61 54.94,24.21
+LAN_VDD_3V3 on BOTTOM (solid shape): 54.82,18.29 54.82,15.16 54.74,15.09 53.5,15.09 53.42,15.16 53.42,15.92 53.45,15.95 53.57,16.08 54.18,16.08 54.23,16.13 54.23,16.91 54.25,16.99 54.24,17.07 54.24,17.09 54.59,17.45 54.59,18.29 54.64,18.34 54.77,18.34
+LAN_VDD_3V3 on IN2 (solid shape): 54.78,16.22 54.78,15.66 54.22,15.1 54.2,15.08 53.71,15.08 53.68,15.09 53.54,15.08 53.4,15.23 53.4,16.18 53.76,16.54 54.45,16.54
+LCDVDD on TOP (solid shape): 71.43,36.03 71.43,35.1 71.35,35.02 70.59,35.02 70.35,34.78 70.35,31.59 70.22,31.46 69.98,31.46 69.79,31.27 69.79,29.85 69.56,29.62 68.07,29.62 67.77,29.92 67.77,34.92 68.35,35.5 68.35,36.01 68.47,36.14 71.32,36.14
+LCDVDD on BOTTOM (solid shape): 69.94,33.72 69.94,31.49 69.64,31.19 67.91,31.19 67.72,31 67.72,29.84 67.6,29.72 66.01,29.72 65.9,29.82 65.87,29.86 65.87,31.2 65.95,31.28 66.11,31.47 66.11,31.72 66.1,31.73 66.1,31.94 66.44,32.27 66.84,32.27 67.05,32.48 67.05,33.75 67.39,34.1 69.56,34.1
+USB_VCC2 on TOP (solid shape): 22.56,92.1 22.56,91.16 22.52,91.15 22.26,90.89 22.37,90.54 22.4,90.48 22.39,90.41 22.35,90.17 22.48,89.95 22.51,89.88 22.48,89.8 22.35,89.5 22.52,89.22 22.56,89.16 22.56,89.09 22.6,88.72 22.95,88.59 23.03,88.57 23.06,88.49 23.06,87.53 23.2,87.4 23.2,86.96 23.15,86.96 22.85,86.61 23.15,86.25 23.2,86.25 23.2,85.24 22.81,84.86 21.42,84.86 21.31,84.97 21.31,86.29 21.43,86.41 21.66,86.41 22.05,86.57 22.01,87 21.99,87.07 22.01,87.13 22.09,87.4 21.96,87.64 21.93,87.72 21.96,87.8 22.09,88.04 22.01,88.3 21.99,88.37 22.01,88.43 22.01,88.88 21.58,88.98 21.57,88.98 21.46,88.98 21.32,89.11 21.3,89.15 21.26,89.2 21.26,89.35 19.66,90.96 14.76,90.96 14.11,91.61 14.11,93.17 14.31,93.37 21.29,93.37
+USB_VCC2 on BOTTOM (solid shape): 23.01,86.31 23.09,86.27 23.18,86.25 23.2,86.25 23.32,86.13 23.32,85.49 23.09,85.27 22.62,85.27 22.56,85.21 22.56,84.75 22.32,84.51 22.32,82.34 22.26,82.29 22.26,81.83 21.76,81.33 20.47,81.33 20.41,81.39 20.41,81.51 20.41,81.52 20.46,81.62 20.47,81.74 20.47,82.36 20.44,82.53 20.34,82.67 20.28,82.73 20.28,86.1 20.33,86.15 22.09,86.15 22.25,86.31
+USB_VCC2 on IN2 (solid shape): outline of 220 points within 19.89,84.99 23.32,92.34
+VGA_CORE on TOP (solid shape): 202.45,87.47 202.45,86.21 202.23,85.98 200.93,85.98 200.77,86.14 200.77,86.46 201.92,87.61 202.31,87.61
+VGA_CORE on TOP (solid shape): 203.08,90.91 203.08,90.09 202.98,89.99 201.24,89.99 201.02,90.21 201.02,90.55 201.15,90.68 202,90.68 202.31,90.99 203.01,90.99
+VGA_CORE on TOP (solid shape): 201.22,84.74 201.87,84.09 201.87,82.84 201.53,82.5 201.2,82.5 201.03,82.66 201.03,82.79 201.13,82.89 201.13,83.43 201.04,83.53 199.85,83.53 199.84,83.55 199.58,83.55 199.45,83.68 199.45,84.49 199.55,84.59 200.02,84.59 200.17,84.74 201.2,84.74
+VGA_CORE on TOP (solid shape): outline of 1458 points within 192.25,64.07 217.4,94.92
+VGA_CORE on BOTTOM (solid shape): outline of 3083 points within 189.45,64.58 215.57,96.5
+VGA_CORE on IN1 (solid shape): outline of 3778 points within 194.11,65.05 215.62,95.6
+VGA_CORE on IN2 (solid shape): outline of 3850 points within 193.17,65.12 216.59,96.37
+VGA_CORE on IN3 (solid shape): outline of 4042 points within 193.86,64.26 216.49,94.92
+VGA_CORE on VCC: 195.04,64.99 194.01,66.02 194.01,91.32 193.88,91.32 198.38,95.82 198.38,96.49 198.77,96.88 213.35,96.88 213.82,96.41 213.82,84.19 213.4,83.78 213.4,80.9 213.76,80.54 213.76,75.88 221.06,68.61 221.06,67.8 218.26,64.99
BST_1.35VSDGPUP on BOTTOM (solid shape): 240.56,52.56 240.56,51.8 239.5,50.74 239.5,50.25 239.35,50.09 238.49,50.09 238.44,50.15 238.44,50.75 240.31,52.62 240.49,52.62
BST_3V on BOTTOM (solid shape): 248.35,29.25 248.35,29.05 248.1,28.81 248.1,27.8 247.75,27.45 246.38,27.45 246.35,27.48 246.35,28.32 246.44,28.41 247.26,28.41 247.31,28.47 247.31,29.13 247.51,29.32 248.27,29.32
BST_3V_R on BOTTOM (solid shape): 245.96,28.25 245.96,27.54 245.93,27.5 244.67,27.5 244.61,27.56 244.61,28.29 244.7,28.38 245.84,28.38
BST_CHG on TOP (solid shape): 242.35,14.17 242.35,13.37 242.29,13.31 241.43,13.31 241.12,13.01 241.12,12.2 240.66,11.74 239.99,11.74 239.91,11.81 239.91,11.89 239.97,11.95 240.15,11.95 240.75,12.56 240.75,13.32 241.05,13.62 241.05,13.62 241.68,14.25 242.28,14.25
BST_DDR_R on BOTTOM (solid shape): 91.01,31.27 91.01,30.66 90.93,30.58 90.43,30.58 90.38,30.63 89.62,30.63 89.49,30.76 89.49,31.27 89.62,31.39 90.89,31.39
BST_GT on TOP (solid shape): 119.97,93.88 119.97,93.5 118.7,92.23 118.06,92.23 117.94,92.35 117.94,93.11 118.06,93.24 118.57,93.24 119.33,94 119.84,94
BST_PH1 on BOTTOM (solid shape): 151.85,136.1 151.85,135.15 151.78,135.09 151.53,135.09 151.08,135.53 150.13,135.53 150.07,135.6 150.07,136.36 150.13,136.42 151.53,136.42
BST_PH1_R on BOTTOM (solid shape): 151.08,135.02 151.08,133.63 150.83,133.37 150.2,133.37 150.07,133.5 150.07,135.02 150.15,135.1 151.01,135.1
BST_PH2 on BOTTOM (solid shape): 144.24,136.09 144.24,135.17 144.16,135.09 143.91,135.09 143.46,135.53 142.51,135.53 142.45,135.6 142.45,136.36 142.51,136.42 143.91,136.42
BST_PH2_R on BOTTOM (solid shape): 143.46,135.02 143.46,133.63 143.27,133.43 142.56,133.43 142.45,133.54 142.45,135.02 142.52,135.1 143.39,135.1
BST_PH3 on BOTTOM (solid shape): 136.61,136.1 136.61,135.15 136.54,135.09 136.29,135.09 135.84,135.53 134.89,135.53 134.83,135.6 134.83,136.36 134.89,136.42 136.29,136.42
BST_PH3_R on BOTTOM (solid shape): 135.84,135.02 135.84,133.63 135.62,133.41 134.97,133.41 134.83,133.55 134.83,135.02 134.91,135.1 135.77,135.1
BST_PH4 on BOTTOM (solid shape): 129.24,136.1 129.24,135.15 129.18,135.09 128.92,135.09 128.48,135.53 127.53,135.53 127.46,135.6 127.46,136.36 127.53,136.42 128.92,136.42
BST_PH4_R on BOTTOM (solid shape): 128.48,135.02 128.48,133.63 128.29,133.44 127.65,133.44 127.46,133.63 127.46,135.02 127.53,135.1 128.41,135.1
BST_VCCIOP on BOTTOM (solid shape): 187.7,104.36 187.7,103.79 187.65,103.74 185.77,103.74 185.72,103.79 185.72,104 186.11,104.39 187.67,104.39
BST_VCCSA on BOTTOM (solid shape): 159.47,133.75 159.47,132.99 159.4,132.93 159.28,132.93 158.45,133.75 157.56,133.75 157.43,133.88 157.43,134.39 157.56,134.52 158.7,134.52
CHG_DCIN on TOP (solid shape): 241.18,9.2 241.61,9.2 241.89,8.92 241.89,8.73 241.78,8.62 241.53,8.62 241.48,8.64 241.44,8.64 241.4,8.65 241.36,8.66 240.9,9.12 240.89,9.13 240.85,9.2 240.78,9.24 240.77,9.24 240.68,9.34 240.01,9.34 239.98,9.37 239.98,9.5 240.01,9.53 240.25,9.53 240.26,9.53 240.86,9.53
CHG_PHASE on TOP (solid shape): 254.72,10.03 254.72,8.47 254.61,8.37 253.84,8.37 253.55,8.66 251.18,8.66 251.15,8.69 251.15,9.61 251.2,9.66 253.59,9.66 253.72,9.8 253.72,10.03 253.83,10.14 254.61,10.14
CHG_PHASE on TOP (solid shape): 242.84,11.81 242.84,11.25 242.79,11.19 242.41,11.19 242.15,10.93 240,10.93 240,10.94 239.94,10.94 239.89,10.99 239.89,11.09 239.95,11.15 241.02,11.15 241.61,11.73 242.11,11.73 242.21,11.84 242.81,11.84
CHG_PHASE on BOTTOM (solid shape): 259.47,11.73 259.47,6.2 254.74,6.2 254.74,7.59 253.7,8.63 253.7,10.06 253.76,10.12 254.75,10.12 255.33,10.7 255.33,11.78 255.81,12.27 258.93,12.27
CHG_PHASE on IN3 (solid shape): 258.76,8.4 258.76,7.57 258.67,7.48 256.48,7.48 256.34,7.62 256.34,8.41 256.46,8.52 258.63,8.52
CHG_VDDP on TOP (solid shape): 241.21,10.38 241.53,10.09 241.86,10.35 241.88,10.36 242.07,10.36 242.4,10.03 243.55,10.03 243.81,10.29 244.63,10.29 244.78,10.13 245.84,10.13 245.84,10.02 245.85,10.01 245.85,9.31 245.82,9.28 244.66,9.28 244.46,9.49 242.28,9.49 242.07,9.7 241.77,9.7 241.77,9.7 241.33,9.7 240.97,10.06 240.84,10.06 240.76,10.14 239.94,10.14 239.9,10.18 239.9,10.28 239.95,10.33 240.25,10.33 240.26,10.33 240.78,10.33 240.87,10.41 241.21,10.41
DH_CHG on TOP (solid shape): 242.12,12.96 242.12,12.13 241.89,11.9 241.55,11.9 240.99,11.34 240,11.34 239.94,11.4 239.94,11.48 239.99,11.53 240.26,11.53 240.27,11.54 240.69,11.54 240.69,11.54 240.8,11.54 241.33,12.07 241.33,12.87 241.34,12.87 241.49,13.03 242.05,13.03
DH_CHG_R on TOP (solid shape): 254.54,11.73 254.54,10.87 254.45,10.78 253.26,10.78 253.15,10.89 253.15,11.67 253.28,11.8 254.48,11.8
DH_CHG_R on IN3 (solid shape): 254.5,11.67 254.5,10.88 254.38,10.76 252.47,10.76 252.09,11.15 252.09,11.66 252.19,11.77 254.4,11.77
DL_CHG on TOP (solid shape): 253.79,8.11 254.12,8.11 254.17,8.06 254.17,7.13 253.98,6.94 253.22,6.94 253.13,7.03 253.13,7.58 253.13,7.58 253.13,8.34 253.17,8.38 253.52,8.38
DL_CHG on IN3 (solid shape): 254.16,7.3 254.16,6.88 253.78,6.5 251.82,6.5 251.77,6.55 251.77,7.08 251.84,7.16 253,7.16 253.24,7.4 254.06,7.4
FB_CAL_PU_GND on TOP (solid shape): 213.88,98.13 213.88,97.66 213.72,97.5 213.56,97.5 213.52,97.54 213.52,97.56 213.16,97.56 213.09,97.63 213.09,97.99 212.83,98.26 212.83,98.29 212.92,98.38 212.99,98.43 213.04,98.5 213.21,98.67 213.33,98.67
HGATE_1.35VSDGPUP on BOTTOM (solid shape): 257.39,53.76 257.39,53.04 257.29,52.94 256.21,52.94 256.14,53.01 256.14,53.89 256.31,54.06 257.08,54.06
HGATE_1.35VSDGPUP on BOTTOM (solid shape): 241.07,52.55 241.07,51.23 240.45,50.61 240.28,50.61 240.1,50.8 240.1,51 240.83,51.73 240.83,52.54 240.89,52.61 241.01,52.61
HGATE_1.35VSDGPUP on IN3 (solid shape): 257.42,53.91 257.42,53.07 257.16,52.81 255.79,52.81 255.71,52.89 255.71,53.74 256.04,54.07 257.26,54.07
HGATE_1.35VSDGPUP on IN3 (solid shape): 241.74,52.01 241.74,51.79 241.33,51.38 241.32,51.38 241.03,51.2 240.86,50.92 240.86,50.91 240.54,50.6 240.24,50.6 240.04,50.8 240.04,51.41 241.03,52.4 241.34,52.4
IN_2.5V on TOP (solid shape): 107.11,18.85 107.11,17.65 106.9,17.44 105.89,17.44 105.51,17.06 104.32,17.06 104.22,17.16 104.22,18.01 103.85,18.38 103.85,19.26 103.88,19.28 105.13,19.28 105.39,19.54 106.42,19.54
INVPWR_B+ on TOP (solid shape): 88.6,34.91 88.6,34.21 88.57,34.18 88.57,34.06 88.5,33.99 88.11,33.99 87.87,33.75 87.87,33.24 87.73,33.1 87.35,33.1 87.04,32.79 87.04,32.72 87.03,32.71 86.99,32.54 87.03,32.37 87.04,32.36 87.04,31.96 87.03,31.95 86.99,31.78 87.03,31.61 87.04,31.6 87.04,31.48 87.67,30.85 87.67,29.86 87.04,29.23 87.04,27.8 86.99,27.75 84.65,27.75 84.64,27.79 84.37,28.07 84.01,27.94 83.94,27.9 83.86,27.93 83.81,27.97 83.81,31 83.95,31.14 85.12,31.14 85.5,31.52 85.5,33.82 85.55,33.87 85.55,33.88 85.65,33.95 85.73,34.05 85.73,34.06 86.19,34.52 86.47,34.52 86.98,35.02 88.49,35.02
INVPWR_B+ on BOTTOM (solid shape): 88.47,35.58 88.47,33.29 88.35,33.16 87.32,33.16 86.96,32.8 86.96,31.51 87.71,30.76 87.71,29.61 87.58,29.49 85.43,29.49 84.66,30.25 84.66,32.92 86.19,34.44 86.19,35.58 86.27,35.66 88.39,35.66
INVPWR_B+_R on TOP (solid shape): 83.06,30.82 83.06,27.89 82.89,27.72 79.61,27.72 79.12,28.21 79.12,31.38 79.12,31.39 79.14,31.49 79.12,31.6 79.12,31.6 79.12,31.86 79.31,32.05 81.83,32.05
INVPWR_B+_R on BOTTOM (solid shape): 80.93,31.98 80.93,29.88 80.79,29.74 79.46,29.74 79.35,29.85 79.35,31.08 79.12,31.31 79.12,31.37 79.12,31.38 79.14,31.49 79.12,31.61 79.12,31.65 79.1,31.66 79.1,31.9 79.26,32.06 80.85,32.06
KBL_ON_GND on BOTTOM (solid shape): 219.16,11.96 219.16,11.71 218.87,11.42 218.85,11.41 218.66,11.31 218.55,11.12 218.55,11.1 218.04,10.59 216.14,10.59 215.68,11.05 215.68,11.9 215.83,12.04 219.08,12.04
LANGND on TOP (solid shape): 12.22,79.14 13.04,79.14 14.53,77.64 14.64,77.37 14.91,77.26 16.26,75.91 16.26,65.66 12.9,62.3 3.84,62.3 3.57,62.57 3.57,63.82 6.27,63.82 6.27,62.91 8.5,62.91 8.5,63.82 11.19,63.82 11.89,63.82 12.54,64.25 12.39,65.01 12.4,65.01 12.26,65.12 12.09,65.19 12.09,67.59 12.55,67.59 12.55,65.47 12.9,65.1 13.05,64.61 13.25,64.41 13.74,64.41 15.3,65.97 15.3,75.34 14.02,76.62 13.3,76.62 12.55,75.87 12.09,75.87 12.09,76.5 12.09,76.5 12.09,77.25 12.58,78.02 11.89,78.62 10.67,78.62 9.06,78.62 8.49,78.62 8.49,79.52 6.28,79.52 6.28,78.62 5.58,78.62 3.53,78.62 2.97,78.86 2.73,79.42 2.73,80.11 11.26,80.11
LANGND on BOTTOM (solid shape): 12.55,65.47 12.95,64.98 13.04,64.36 13.04,63.81 11.77,62.53 11.77,62.1 11.46,61.8 4.53,61.8 4.01,62.32 3.83,62.32 3.54,62.61 3.54,63.82 6.28,63.82 6.28,62.89 8.49,62.89 8.49,63.82 11.89,63.82 12.59,64.42 12.09,65.19 12.09,67.66 12.55,67.66
LANGND on BOTTOM (solid shape): 12.63,78.81 12.69,78.76 12.73,78.72 13.04,77.8 12.55,76.97 12.55,75.95 12.09,75.95 12.09,77.25 12.59,78.02 11.89,78.62 8.49,78.62 8.49,79.52 6.29,79.52 6.29,78.62 3.53,78.62 2.97,78.86 2.73,79.42 2.73,80.11 11.33,80.11
LANGND on IN1 (solid shape): 12.55,65.47 12.95,64.98 13.04,64.36 13.04,63.76 11.59,62.3 3.74,62.3 3.5,62.55 3.5,63.82 6.29,63.82 6.29,62.92 8.49,62.92 8.49,63.82 11.89,63.82 12.59,64.42 12.09,65.19 12.09,67.59 12.55,67.59
LANGND on IN1 (solid shape): 12.73,78.72 13.04,77.8 12.55,76.97 12.55,75.87 12.09,75.87 12.09,77.25 12.59,78.02 11.89,78.62 8.49,78.62 8.49,79.52 6.29,79.52 6.29,78.62 3.53,78.62 2.97,78.86 2.73,79.42 2.73,80.11 11.34,80.11
LANGND on IN2 (solid shape): 12.55,65.47 12.95,65 13.04,64.39 13.04,63.76 11.59,62.3 3.71,62.3 3.51,62.51 3.51,63.82 6.29,63.82 6.29,62.92 8.49,62.92 8.49,63.82 11.89,63.82 12.59,64.42 12.09,65.19 12.09,67.59 12.55,67.59
LANGND on IN2 (solid shape): 12.83,78.6 13.03,77.72 12.55,76.97 12.55,75.87 12.09,75.87 12.09,77.25 12.59,78.02 11.89,78.62 8.49,78.62 8.49,79.52 6.29,79.52 6.29,78.62 3.53,78.62 2.97,78.86 2.73,79.42 2.73,80.11 11.32,80.11
LANGND on IN3 (solid shape): 12.55,65.47 13.03,64.75 12.87,63.9 12.87,62.65 12.53,62.3 3.87,62.3 3.43,62.74 3.43,63.82 6.29,63.82 6.29,62.92 8.49,62.92 8.49,63.82 11.89,63.82 12.59,64.42 12.09,65.19 12.09,67.59 12.55,67.59
LANGND on IN3 (solid shape): 12.65,78.79 13.05,77.85 12.55,76.97 12.55,75.87 12.09,75.87 12.09,77.25 12.59,78.02 11.89,78.62 8.49,78.62 8.49,79.52 6.29,79.52 6.29,78.62 3.53,78.62 2.97,78.86 2.73,79.42 2.73,80.09 2.75,80.11 11.34,80.11
LDO_3V_VCCIOP on BOTTOM (solid shape): 183.02,106.2 183.02,105.48 183.16,105.34 183.98,105.34 184.28,105.04 184.28,105 184.28,104.14 184.18,104.04 183.67,104.04 183.62,104.09 183.62,104.15 183.57,104.2 183.57,104.25 182.31,105.51 182.31,106.16 182.45,106.3 182.92,106.3
LG_DDR on BOTTOM (solid shape): 90.54,28.05 90.54,27.69 90.48,27.63 89.72,27.63 89.36,27.99 89.36,28.55 89.54,28.73 89.87,28.73
LGATE_1.35VSDGPUP on BOTTOM (solid shape): 258.22,48.38 259.09,48.38 259.09,47.4 258.91,47.22 257.76,47.22 257.49,47.49 257.49,48.61 257.58,48.7 257.9,48.7
LGATE_1.35VSDGPUP on BOTTOM (solid shape): 243.27,52.23 243.27,51.32 242.94,50.99 242.45,50.99 242.34,51.1 242.34,51.38 242.33,51.38 242.33,52.52 242.44,52.63 242.86,52.63
LGATE_1.35VSDGPUP on IN3 (solid shape): 258.3,48.33 258.3,46.84 258.06,46.6 257.25,46.6 257.17,46.68 257.17,48.3 257.38,48.51 258.12,48.51
LGATE_1.35VSDGPUP on IN3 (solid shape): 243.46,51.46 243.46,49.92 243.3,49.76 243.01,49.76 242.4,50.37 242.4,50.93 242.27,51.05 242.27,51.41 242.5,51.64 242.51,51.64 242.68,51.8 243.12,51.8
LX_1.8V on BOTTOM (solid shape): 262.45,20.54 262.89,20.54 262.89,20.45 263.42,20.45 263.42,20.47 263.45,20.52 263.51,20.51 263.62,20.4 263.62,20.16 263.58,20.08 263.49,20.06 263.45,20.07 263.42,20.07 262.89,20.07 262.63,19.82 262.89,19.57 263.42,19.57 263.45,19.57 263.49,19.57 263.58,19.56 263.62,19.48 263.62,18.66 263.16,18.21 261.07,18.21 260.98,18.29 260.98,20.73 261.1,20.85 262.15,20.85
LX_1.35VSDGPUP on BOTTOM (solid shape): 241.57,52.56 241.57,51.04 241.78,50.83 241.78,48.87 241.73,48.82 241.04,48.82 240.99,48.88 240.99,50.88 241.33,51.22 241.33,52.54 241.4,52.62 241.51,52.62
LX_1.35VSDGPUP on BOTTOM (solid shape): 259.06,56.94 262.48,56.94 263.25,56.17 263.25,49.05 263.09,48.88 258.43,48.88 258.16,49.16 258.16,53.7 257.28,54.58 256.11,54.58 255.53,54.01 255.53,53.1 255.4,52.97 252.4,52.97 252.19,53.18 252.19,57.3 252.68,57.79 258.21,57.79
LX_1.35VSDGPUP on IN1 (solid shape): 253.7,54.79 253.7,54.23 253.6,54.13 246.54,54.13 245.7,53.28 245.42,53.03 245.17,52.75 244.61,52.19 244.61,51.71 244.45,50.85 244.52,49.98 243.86,49.31 241.75,49.31 241.13,49.93 241.13,50.71 241.28,50.81 241.4,50.95 241.64,50.95 241.76,50.82 241.76,50.32 241.96,50.12 243.25,50.12 243.74,50.62 243.74,52.65 244.78,53.69 244.9,53.78 244.99,53.9 246.19,55.1 253.38,55.1
LX_1V05 on TOP (solid shape): 240.28,28.81 240.28,27.94 240.14,27.8 235,27.8 234.78,27.59 234.78,26.84 234.5,26.55 233.59,26.55 233.19,26.96 231.58,26.96 231.51,27.02 231.51,28.79 231.63,28.91 240.18,28.91
LX_1V05 on BOTTOM (solid shape): 236,28.96 236,28.95 236.69,28.26 236.69,28.26 236.69,27.54 236.61,27.46 235.15,27.46 234.95,27.25 234.95,26.7 234.94,26.69 234.94,24.21 233.75,23.03 228.27,23.03 227.85,23.44 227.85,27.22 228.08,27.45 232.84,27.45 233.05,27.66 233.05,29.1 233.51,29.56 235.39,29.56
LX_2.5V on TOP (solid shape): 111.59,19.89 111.59,16.88 111.44,16.74 110.4,16.74 110.27,16.86 110.27,17.35 110.02,17.61 109.04,17.61 108.89,17.76 108.89,17.99 108.99,18.08 110.15,18.08 110.34,18.27 110.34,18.97 110.49,19.12 111.02,19.12 111.11,19.2 111.11,19.88 111.17,19.94 111.54,19.94
LX_3V on BOTTOM (solid shape): 248.7,31.98 248.7,31.21 248.8,31.11 248.8,29.24 249.13,28.91 249.13,27.82 249.09,27.67 249.13,27.52 249.13,25.35 249.51,24.96 251.54,24.96 251.58,24.92 251.58,23.65 251.24,23.3 243.93,23.3 243.47,23.77 243.47,28.29 243.55,28.37 244.32,28.37 244.38,28.32 244.38,27.51 244.77,27.12 248.06,27.12 248.41,27.46 248.41,28.92 248.49,29 248.49,31.08 248.41,31.16 248.41,31.99 248.52,32.1 248.57,32.1
LX_3V_LCDVDD on TOP (solid shape): 71.54,38.68 72.74,38.68 72.88,38.54 72.88,38.35 72.43,37.91 71.56,37.03 69.31,37.03 69.26,37.08 69.26,37.95 69.3,38 70.05,38 70.1,38.04 70.1,38.71 70.19,38.81 71.41,38.81
LX_5V on TOP (solid shape): 74.39,7.28 75.01,7.28 75.15,7.13 75.15,6.39 74.36,5.59 72.14,5.59 72.04,5.68 72.04,7.5 72.22,7.67 73.99,7.67
LX_5V on BOTTOM (solid shape): 73.19,7.97 73.44,7.72 73.95,7.72 73.97,7.7 77.11,7.7 77.34,7.47 77.11,7.24 74.24,7.24 73.95,6.95 73.95,6.7 73.7,6.45 70.9,6.45 70.65,6.7 70.65,10.89 70.77,11.02 73.19,11.02
LX_7237 on TOP (solid shape): 86.15,40.12 86.15,38.06 85.71,37.62 85.71,35.8 85.54,35.63 84.7,35.63 84.44,35.9 83.41,35.9 83.28,36.02 83.28,40.11 83.42,40.24 86.03,40.24
LX_7237 on BOTTOM (solid shape): 86.19,40.03 86.19,39.58 86.37,39.39 88.35,39.39 88.47,39.27 88.47,37.36 88.35,37.23 86.31,37.23 86.06,37.49 86.06,38.12 85.55,38.63 85.55,40.03 85.68,40.16 86.06,40.16
LX_+1.0VSDGP on BOTTOM (solid shape): 177.53,98.88 177.78,98.88 177.96,99.06 178.19,99.06 178.87,98.38 178.87,98.19 177.3,96.62 177.15,96.62 175.7,98.07 175.7,98.19 176.13,98.63 176.13,99.36 176.49,99.72 176.69,99.72
LX_DDR on TOP (solid shape): 92.51,36.73 92.51,35.86 92.38,35.74 92.13,35.74 91.98,35.58 91.98,32.84 92.16,32.66 92.54,32.66 92.66,32.54 92.66,31.65 91.39,30.38 90.89,30.38 90.76,30.25 90.76,29.23 90.63,29.11 90.38,29.11 90.12,29.36 90.12,32.15 90.96,32.99 90.96,35.51 90.89,35.58 90.89,37.11 91.01,37.23 92,37.23
LX_DDR on BOTTOM (solid shape): 94.44,35.33 94.44,33.04 94.32,32.92 92.79,32.92 92.66,32.79 92.66,31.65 92.54,31.52 92.28,31.52 92.16,31.65 91.52,31.65 91.14,32.03 90.51,32.03 90.38,32.15 90.38,36.09 90.89,36.6 90.89,37.11 91.27,37.49 92.28,37.49
LX_DDR on BOTTOM (solid shape): 90.25,30.25 90.63,30.25 90.76,30.12 90.76,29.2 90.95,29.01 90.95,28.11 90.89,28.05 90.81,28.05 90.75,28.11 90.75,28.92 90.69,28.98 90.51,28.98 89.74,29.74 89.62,29.74 89.49,29.87 89.49,30.31 89.53,30.34 90.16,30.34
LX_DDR on IN1 (solid shape): 92.66,37.11 92.66,32.28 92.54,32.15 92.16,32.15 92.03,32.03 92.03,31.77 91.9,31.65 91.65,31.65 90.76,30.76 90.76,29.23 90.63,29.11 90.38,29.11 90.25,29.23 90.25,29.61 90.12,29.74 90.12,31.77 90.38,32.03 90.38,32.41 90.89,32.92 90.89,37.11 91.01,37.23 92.54,37.23
LX_GT_R on BOTTOM (solid shape): 111.38,102.58 111.38,101.54 111.21,101.37 110.44,101.37 110.32,101.24 110.32,100.35 110.57,100.1 112.73,100.1 112.9,99.93 112.9,96.08 112.86,96.04 108.25,96.04 107.91,96.38 107.91,97.81 107.9,97.81 107.9,101.75 108.79,102.64 111.32,102.64
LX_PH1 on BOTTOM (solid shape): 152.35,133.63 152.35,132.36 151.85,131.85 151.85,131.15 151.78,131.09 151.15,131.09 151.08,131.15 151.08,131.66 150.26,132.48 150.26,133.06 150.32,133.12 150.83,133.12 151.27,132.67 151.91,132.67 152.1,132.87 152.1,133.63 152.16,133.69 152.29,133.69
LX_PH1_R on TOP (solid shape): 153.3,125.66 153.3,124.9 153.2,124.8 151.27,124.8 151.21,124.86 151.21,126.45 151.27,126.52 152.45,126.52
LX_PH1_R on BOTTOM (solid shape): 154.51,126.26 154.51,121.69 154.26,121.44 152.74,121.44 152.48,121.69 152.48,123.09 151.72,123.09 151.72,121.69 151.47,121.44 150.26,121.44 150.13,121.56 150.13,124.42 151.08,125.37 151.08,126.26 151.21,126.39 154.39,126.39
LX_PH2 on BOTTOM (solid shape): 144.73,133.63 144.73,132.36 144.23,131.85 144.23,131.15 144.16,131.09 143.53,131.09 143.46,131.15 143.46,131.66 142.64,132.48 142.64,133.06 142.7,133.12 143.21,133.12 143.65,132.67 144.29,132.67 144.48,132.87 144.48,133.63 144.54,133.69 144.67,133.69
LX_PH2_R on TOP (solid shape): 147.27,124.86 147.21,124.8 145.56,124.8 145.43,124.93 145.43,125.18 146.13,125.88 146.13,126.52 146.19,126.58 147.27,126.58
LX_PH2_R on BOTTOM (solid shape): 146.89,126.26 146.89,121.69 146.64,121.44 144.99,121.44 144.86,121.56 144.86,123.09 144.1,123.09 144.1,121.56 143.97,121.44 142.64,121.44 142.38,121.69 142.38,124.42 143.46,125.5 143.46,126.26 143.59,126.39 146.77,126.39
LX_PH3 on BOTTOM (solid shape): 137.11,133.63 137.11,132.36 136.61,131.85 136.61,131.15 136.54,131.09 135.91,131.09 135.84,131.15 135.84,131.66 135.02,132.48 135.02,133.06 135.08,133.12 135.59,133.12 136.03,132.67 136.67,132.67 136.86,132.87 136.86,133.63 136.92,133.69 137.05,133.69
LX_PH3_R on BOTTOM (solid shape): 140.04,125.37 141.5,125.37 141.56,125.31 141.56,124.29 141.5,124.23 139.4,124.23 139.27,124.1 139.27,121.69 139.02,121.44 137.5,121.44 137.24,121.69 137.24,123.09 136.48,123.09 136.48,121.69 136.23,121.44 134.96,121.44 134.7,121.69 134.7,124.36 135.84,125.5 135.84,126.26 135.97,126.39 139.02,126.39
LX_PH4 on BOTTOM (solid shape): 129.75,133.63 129.75,132.36 129.24,131.85 129.24,131.15 129.18,131.09 128.54,131.09 128.48,131.15 128.48,131.66 127.65,132.48 127.65,133.06 127.72,133.12 128.22,133.12 128.67,132.67 129.3,132.67 129.49,132.87 129.49,133.63 129.56,133.69 129.68,133.69
LX_PH4_R on TOP (solid shape): 127.08,126.01 126.95,125.88 126.95,124.86 127.08,124.74 128.1,124.74 128.73,125.37 128.99,125.37 129.11,125.25 129.11,124.86 128.35,124.1 126.19,124.1 125.43,124.86 125.43,127.02 127.08,127.02
LX_PH4_R on BOTTOM (solid shape): 131.91,126.26 131.91,121.69 131.65,121.44 129.75,121.44 129.62,121.56 129.62,123.09 128.86,123.09 128.86,121.56 128.73,121.44 127.34,121.44 127.08,121.69 127.08,124.1 128.48,125.5 128.48,126.26 128.61,126.39 131.78,126.39
LX_VCCIOP on TOP (solid shape): 187.07,109.07 187.07,108.16 185.4,106.5 184.47,106.5 182.47,108.5 182.47,109.05 184.21,110.79 185.35,110.79
LX_VCCIOP on BOTTOM (solid shape): 187.7,108.29 187.7,104.58 187.66,104.54 186.93,104.54 186.8,104.57 186.66,104.54 186.03,104.54 185.47,103.98 185.47,103.79 185.35,103.67 185.24,103.67 184.92,103.99 184.92,105.04 185,105.12 185,106.04 184.72,106.32 184.59,106.32 182.17,108.74 182.17,109.07 184.46,111.35 184.64,111.35
LX_VCCSA on BOTTOM (solid shape): 159.97,131.47 159.97,129.94 159.47,129.44 158.26,129.44 157.62,130.07 157.62,130.71 157.69,130.77 158.45,130.77 158.51,130.71 158.51,130.13 158.64,130.01 159.28,130.01 159.72,130.45 159.72,131.47 159.78,131.53 159.91,131.53
LX_VCCSA on BOTTOM (solid shape): 159.28,126.58 159.28,124.04 160.34,122.97 160.34,120.54 160.31,120.5 159.4,120.5 159.34,120.56 159.34,121.44 158.58,121.44 158.58,120.29 158.51,120.23 157.56,120.23 157.43,120.36 157.43,123.28 158.2,124.04 158.2,126.58 158.26,126.64 159.21,126.64
Net_38 on BOTTOM (solid shape): 232.78,27.66 222.78,27.66 222.78,29.66 232.78,29.66
Net_52 on BOTTOM (solid shape): 232.16,30.95 224.16,30.95 224.16,38.95 232.16,38.95
NVVDD_BST1 on BOTTOM (solid shape): 225.48,54.81 225.48,54.38 224.07,52.96 223.45,52.96 223.38,53.03 223.38,53.81 223.43,53.87 224.13,53.87 224.4,54.14 224.4,54.56 224.75,54.91 225.38,54.91
NVVDD_BST1_R on BOTTOM (solid shape): 222.79,53.81 222.79,53.13 223.12,52.8 224.22,52.8 224.84,52.17 225.39,52.17 225.51,52.05 225.51,51.48 225.47,51.43 224.56,51.43 223.87,52.12 222.32,52.12 221.93,52.5 221.93,53.84 221.99,53.9 222.7,53.9
NVVDD_BST2 on BOTTOM (solid shape): 229.62,54.81 230.85,54.81 231.19,54.47 231.43,54.32 231.71,54.4 232.57,54.4 232.7,54.27 232.7,53.69 232.66,53.64 231.65,53.64 231.65,53.64 231.35,53.64 230.71,54.28 229.01,54.28 228.78,54.51 228.78,54.86 228.83,54.91 229.52,54.91
NVVDD_BST2_R on BOTTOM (solid shape): 232.65,52.96 232.65,52.45 232.54,52.33 230.38,52.33 230.31,52.41 230.31,52.9 230.39,52.99 232.62,52.99
NVVDD_BST3 on BOTTOM (solid shape): 219.08,58.02 219.08,57.28 218.84,57.04 218.84,56.7 219.31,56.23 219.31,55.36 219.29,55.34 218.65,55.34 218.62,55.36 218.62,56.09 218.5,56.21 218.5,57.15 218.72,57.37 218.72,58 218.82,58.09 219.01,58.09
NVVDD_BST3_R on BOTTOM (solid shape): 220.72,56.21 220.72,56 220.86,55.86 221.58,55.86 221.62,55.82 221.62,55.28 221.57,55.24 220.16,55.24 220.05,55.35 220.05,56.2 220.09,56.25 220.69,56.25
NVVDD_LG1 on BOTTOM (solid shape): 207.76,59.96 207.76,58.05 207.61,57.9 206.45,57.9 206.4,57.95 206.4,60.06 206.52,60.18 207.53,60.18
NVVDD_LG1 on BOTTOM (solid shape): 226.5,54.32 226.5,53.46 226.69,53.28 226.69,52.59 226.47,52.38 226.06,52.38 225.92,52.52 225.92,52.77 226.14,52.99 226.14,53.45 226.27,53.57 226.27,54.34 226.33,54.41 226.42,54.41
