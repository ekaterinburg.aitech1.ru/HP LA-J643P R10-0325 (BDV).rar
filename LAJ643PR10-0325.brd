# Allegro board LAJ643PR10-0325.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DCC_EN_HDMI: length 2.4
  TOP w0.127: v2(21.96,59.85) 22.07,59.97 RV24.2
  BOTTOM w0.127: v1(21.68,59.24) 21.96,59.52 v2(21.96,59.85) 21.99,59.88 UV2.3
DCHG_I: length 13.4
  TOP w0.127: UK1.73 146.44,22.29 146.75,21.97 149.83,21.97 150.56,22.71 151.53,22.71 153.4,24.57 v1(153.59,24.57) PRB41.1 156.2,25.43 PCB31.1
DCHG_I_R: length 91.8
  TOP w0.127: PRB41.2 158.05,24.57 v1(158.48,24.15) 162.45,20.18 162.45,18.38 171.42,9.41 174.15,9.41 176.76,6.81 v2(176.76,6.67) ; v2(233.53,8.85) 234.07,9.39 235.52,9.39 235.56,9.43 PUB01.7
  IN3 w0.127: v2(222.99,6.6) 224.29,6.6 228.35,10.66 231.93,10.66 233.53,9.05 v2(233.53,8.85)
  BOTTOM w0.127: v2(222.99,6.6) 222.4,7.19 221.61,7.19 221.11,6.69 202.91,6.69 202.08,7.52 200.8,7.52 199.85,6.57 177.84,6.57 177.63,6.78 176.87,6.78 v2(176.76,6.67)
DDR_DRAMRST#_R: length 98
  TOP w0.127: v2(129.37,27.96) 129.37,28.69 CD10.2 ; v2(171.1,35.11) 171.75,35.11 172.18,34.68 172.18,34.47 173.31,33.33 173.31,31.55 169.32,27.56 169.32,26.76 v2(172.59,23.49)
  IN3 w0.127: v2(129.37,27.96) 128.94,28.39 128.94,37.6 131.59,40.26 v2(131.72,40.26) 132.74,40.26 134.99,38.01 166.89,38.01 167.04,38.15 167.04,40.54 167.77,41.27 168.33,41.27 168.97,40.64 168.97,37.7 170.46,36.21 170.46,35.75 v2(171.1,35.11)
  BOTTOM w0.127: v2(129.37,27.96) 129.28,28.05 JDIMM2.108 ; v2(131.72,40.26) 131.14,40.26 130.77,40.63 JDIMM1.108 ; RH40.2 183.5,16.34 180.13,19.71 176.37,19.71 v2(172.59,23.49)
DDR_M0_ACT#: length 48.9
  IN3 w0.216: v2(138.82,81.98) 138.89,81.98 140.87,80 140.87,75.96 140.42,75.51 140.42,73.89 138.67,72.15 138.67,66.67 130.94,58.94 130.94,49.96 131.68,49.22 131.68,45.27 132.16,44.79 v2(132.23,44.79)
  BOTTOM w0.076: UC1.AU3 140.01,83.24 140.01,82.41 139.58,81.98 v2(138.82,81.98)
  BOTTOM w0.196: v2(132.23,44.79) 131.74,44.3 131.74,43.54 132.27,43 JDIMM1.114
DDR_M0_ALERT#: length 50.6
  IN3 w0.254: v2(132.22,43.83) 130.61,44.41 130.15,44.64 128.61,46.19 127.68,47.66 127.68,60.29 135.36,67.97 135.36,73.45 137.16,75.24 137.16,77.47 137.19,77.73 137.77,81.54 138.06,82.42 v2(140.15,84.76)
  BOTTOM w0.089: v2(140.15,84.76) 140.45,84.98 UC1.AU5
  BOTTOM w0.196: JDIMM1.116 132.77,43.04 v2(132.22,43.83)
DDR_M0_BA0: length 48.9
  IN3 w0.216: v2(149.31,84.11) 149.32,84.1 149.79,84.1 150.29,83.59 150.29,76.05 149.57,75.33 149.57,73.81 150.72,72.67 150.72,61.74 145.47,56.49 145.47,52.1 145.04,51.67 145.04,50.8 144.87,50.64 144.87,47.28 v2(144.35,46.76)
  BOTTOM w0.076: v2(149.31,84.11) 148.76,84.11 148.67,84.01 148.53,84.01 148.43,84.12 148.43,84.98 148.29,85.12 UC1.AH5
  BOTTOM w0.196: v2(144.35,46.76) 144.23,46.76 143.46,46 143.46,43.58 143.28,43.4 JDIMM1.150
DDR_M0_BA1: length 43.9
  IN3 w0.216: v2(146.83,80.43) 147.52,80.43 148.21,79.73 148.21,79.14 147.99,78.92 147.55,78.92 147.33,78.7 147.33,78.16 147.55,77.95 148,77.95 148.21,77.73 148.21,77.3 148,77.09 147.62,77.09 147.4,76.87 147.4,73.04 148.63,71.81 148.63,63.38 143.39,58.13 143.39,53.02 142.04,51.68 142.04,50.25 142.64,49.65 v2(142.64,48.3)
  BOTTOM w0.196: v2(146.83,80.43) 148.13,81.72 UC1.AH1 ; v2(142.64,48.3) 142.51,48.17 142.08,48.17 141.81,48.44 141.81,48.98 142.02,49.19 JDIMM1.145
DDR_M0_BG0: length 43.4
  IN3 w0.216: v2(138.87,79.61) 139.09,79.61 139.83,78.87 139.83,76.39 139.38,75.94 139.38,74.32 137.63,72.58 137.63,67.1 129.9,59.37 129.9,49.35 130.64,48.61 v2(130.64,48.16)
  BOTTOM w0.076: 139.53,80.95 139.53,81.25 140.59,82.31 UC1.AU1
  BOTTOM w0.196: 139.53,80.95 139.53,80.26 v2(138.87,79.61) ; JDIMM1.115 132.53,49.15 131.53,48.16 v2(130.64,48.16)
DDR_M0_BG1: length 44.2
  IN3 w0.216: v2(131.47,52.93) 131.47,54.33 131.68,54.55 131.84,54.55 132.05,54.76 132.05,55.2 131.84,55.41 131.68,55.41 131.47,55.63 131.47,56.06 131.68,56.28 131.84,56.28 132.05,56.49 132.05,56.92 131.84,57.14 131.68,57.14 131.47,57.36 131.47,57.99 131.65,58.17 131.95,58.17 132.05,58.27 132.05,59.31 139.2,66.46 139.2,70.66 v2(139.49,70.95)
  BOTTOM w0.076: UC1.AU2 140.87,82.89 140.87,82.33 139.97,81.44 139.97,79.42 139.21,78.66 138.65,78.66 138.52,78.53
  BOTTOM w0.196: v2(139.49,70.95) 138.65,70.95 138.26,71.34 138.26,78.27 138.52,78.53 ; JDIMM1.113 132.02,51.36 133.69,53.03 133.69,53.26 133.39,53.56 133.16,53.56 132.12,52.51 131.89,52.51 v2(131.47,52.93)
DDR_M0_CKE0: length 52.8
  IN3 w0.216: v2(129.62,48.05) 129.22,48.05 129.05,48.22 129.05,59.72 136.78,67.46 136.78,72.93 138.53,74.67 138.53,76.65 v2(138.89,77.01)
  BOTTOM w0.076: 140.78,81.22 140.78,81.63 141.32,82.17 UC1.AT1
  BOTTOM w0.196: 140.78,81.22 140.78,79.08 140.6,78.9 140.6,72.64 140.38,72.42 139.84,72.42 139.66,72.6 139.66,76.9 139.5,77.06 138.94,77.06 v2(138.89,77.01) ; v2(129.62,48.05) 129.77,48.05 131.02,49.31 JDIMM1.109
DDR_M0_CKE1: length 48.2
  IN3 w0.216: v2(130.64,45.36) 129.28,46.72 128.53,47.91 128.53,59.94 136.26,67.67 136.26,73.15 138.01,74.89 138.01,76.86 138.11,76.95 138.11,78.09 138.41,78.4 138.72,78.4 v2(138.89,78.23)
  BOTTOM w0.076: UC1.AT2 141.04,82.89 141.04,82.19 140.38,81.52 140.38,81.28
  BOTTOM w0.196: 140.38,81.28 140.38,79.33 139.27,78.23 v2(138.89,78.23) ; JDIMM1.110 131.27,43.23 131.07,43.44 131.07,44.93 v2(130.64,45.36)
DDR_M0_CLK0: length 56.5
  IN3 w0.127: v2(139.69,46.76) 139.69,47.12 139.78,47.2 140.1,47.2 140.4,47.5 140.4,49.21 140.18,49.43 140.18,52.45 140.55,52.82 140.55,53.25 140.29,53.5 139.26,53.5 139.09,53.67 139.09,54.02 139.21,54.14 141.27,54.14 141.54,54.4 141.54,55.06 141.29,55.31 139.22,55.31 139.09,55.43 139.09,56.22 139.41,56.54 140.02,56.54 140.52,56.04 141.19,56.04 141.54,56.4 141.54,58.89 146.79,64.14 146.79,65.3 146.51,65.58 146.3,65.58 146.17,65.71 146.17,66.09 146.3,66.22 146.51,66.22 146.79,66.49 146.79,69.97 146.52,70.24 146.17,70.24 v2(145.98,70.43)
  BOTTOM w0.076: UC1.AG1 149,82.65 149.14,82.65 149.21,82.58 149.21,82.25 149.06,82.1 149.06,80.23 148.58,79.75 148.58,79.47 148.52,79.42 148.52,79.4
  BOTTOM w0.127: 148.52,79.4 148.52,78.49 147.42,77.39 147.42,73.3 147.29,73.17 146.87,73.17 146.58,72.88 146.58,72.27 146.87,71.98 147.21,71.98 147.39,71.79 147.39,70.7 147,70.31 146.1,70.31 v2(145.98,70.43) ; v2(139.69,46.76) 139.69,46.86 139.36,47.19 138.96,47.19 138.65,47.5 138.65,48.64 138.25,49.04 138.25,49.21 138.02,49.43 JDIMM1.137
DDR_M0_CLK1: length 54.6
  IN3 w0.127: v2(139.69,45.35) 139.48,45.14 139.16,45.14 138.76,44.75 138.76,43.06 138.41,42.7 137.65,42.7 137.5,42.85 137.5,43.22 137.95,43.68 137.95,44.96 138.92,45.93 138.92,52.85 138.39,53.38 138.39,56.74 145.48,63.82 145.48,67.93 145.65,68.1 145.83,68.1 v2(145.98,67.94)
  BOTTOM w0.076: 146,80.8 146,80.81 146.06,80.87 146.06,81.86 145.89,82.02 145.89,82.72 145.89,82.86 146.07,83.04 146.22,83.04 UC1.AK2
  BOTTOM w0.127: JDIMM1.138 138.28,42.89 138.4,43.02 138.4,44.07 138.51,44.19 138.51,44.35 139.2,45.03 139.53,45.03 139.7,45.19 139.7,45.35 v2(139.69,45.35) ; v2(145.98,67.94) 145.85,68.08 145.43,68.08 144.99,68.52 144.99,73.51 146,74.53 146,80.8
DDR_M0_CLK#0: length 56.5
  IN3 w0.127: v2(145.98,69.69) 145.98,69.85 146.11,69.97 146.41,69.97 146.52,69.86 146.52,66.6 146.4,66.48 146.19,66.48 145.91,66.2 145.91,65.6 146.19,65.31 146.4,65.31 146.52,65.19 146.52,64.25 141.27,59 141.27,56.51 141.07,56.31 140.63,56.31 140.13,56.81 139.3,56.81 138.82,56.33 138.82,55.32 139.1,55.04 141.17,55.04 141.27,54.95 141.27,54.52 141.16,54.41 139.1,54.41 138.82,54.13 138.82,53.56 139.15,53.24 140.18,53.24 140.28,53.14 140.28,52.93 139.91,52.56 139.91,49.32 140.14,49.1 140.14,47.61 139.99,47.47 139.77,47.47 139.69,47.55 v2(139.69,48.02)
  BOTTOM w0.076: 148.8,79.4 148.8,79.42 148.74,79.47 148.74,79.68 149.22,80.16 149.22,82.03 149.38,82.18 149.38,82.66 UC1.AG2
  BOTTOM w0.127: JDIMM1.139 138.52,49.16 138.93,48.76 138.93,47.62 139.08,47.47 139.48,47.47 139.69,47.68 v2(139.69,48.02) ; 148.8,79.4 148.8,78.37 147.7,77.27 147.7,73.18 147.41,72.89 146.99,72.89 146.86,72.76 146.86,72.38 146.99,72.26 147.32,72.26 147.67,71.91 147.67,70.58 147.12,70.03 146.13,70.03 145.98,69.89 v2(145.98,69.69)
DDR_M0_CLK#1: length 54.5
  IN3 w0.127: v2(145.98,68.52) 145.82,68.36 145.54,68.36 145.21,68.04 145.21,63.93 138.12,56.85 138.12,53.27 138.66,52.74 138.66,46.04 137.69,45.07 137.69,43.79 137.23,43.33 137.23,42.74 137.54,42.44 138.52,42.44 139.03,42.95 139.03,44.64 139.27,44.88 139.53,44.88 139.69,44.72 v2(139.69,44.56)
  BOTTOM w0.076: UC1.AK1 146.35,82.79 146.28,82.87 146.14,82.87 146.06,82.79 146.06,82.09 146.23,81.92 146.23,80.87 146.28,80.81 146.28,80.8
  BOTTOM w0.127: v2(145.98,68.52) 145.82,68.36 145.55,68.36 145.27,68.64 145.27,73.4 146.28,74.42 146.28,80.8 ; v2(139.69,44.56) 139.49,44.75 139.31,44.75 138.79,44.23 138.79,44.07 138.68,43.96 138.68,43.09 138.77,43 JDIMM1.140
DDR_M0_CS#0: length 53.3
  IN3 w0.216: v2(153.67,69.24) 153.7,69.21 153.7,60.57 148.58,55.46 148.58,54 147.9,53.31 147.9,49.78 147.75,49.63 147.75,46.95 147.53,46.73 147.15,46.73 146.87,47.01 v2(146.77,47.01)
  BOTTOM w0.076: 150.61,81.37 150.61,82.01 150.36,82.26 150.36,84.58 150.57,84.79 151.05,84.79 151.26,84.99 UC1.AD5
  BOTTOM w0.196: 150.61,81.37 150.61,81.16 149.74,80.28 149.74,76.05 149.18,75.49 149.18,70.55 150.5,69.24 v2(153.67,69.24) ; v2(146.77,47.01) 146.64,47.01 146.39,47.27 143.85,47.27 143.21,47.9 143.21,48.66 143.02,48.85 JDIMM1.149
DDR_M0_CS#1: length 56.2
  IN3 w0.216: v2(147.9,54.1) 147.9,55.51 153.13,60.74 153.13,70.2 153.34,70.41 v2(153.67,70.41)
  BOTTOM w0.076: UC1.AE2 150.92,82.89 150.92,80.9 150.56,80.54
  BOTTOM w0.196: 150.56,80.54 150.25,80.23 150.25,75.21 150.6,74.86 150.6,73.85 149.83,73.08 149.83,72.77 150.06,72.55 150.45,72.55 151.27,73.37 151.56,73.37 151.83,73.1 151.83,72.82 150.13,71.13 150.13,70.79 150.4,70.53 150.7,70.53 152.63,72.46 152.63,73.04 152.79,73.2 154.4,73.2 154.68,72.92 154.68,72.19 154.43,71.95 154.16,71.95 153.9,72.2 153.57,72.2 153.09,71.72 151.67,70.3 151.67,70.06 151.94,69.78 152.33,69.78 153.15,70.61 153.48,70.61 v2(153.67,70.41) ; v2(147.9,54.1) 147.9,53.35 147.68,53.13 146.14,53.13 145.89,53.37 145.27,53.37 145.02,53.13 JDIMM1.157
DDR_M0_D0: length 61.1
  IN3 w0.127: v2(124.6,85.59) 124.46,85.72 122.99,85.72 122.15,84.88 119.03,84.88 118.48,84.33 115.36,84.33 114.02,82.99 arc(113.05,81.54) 112.71,79.83 112.71,77.34 111,75.62 111,73.92 104.94,67.86 104.94,66.75 102.99,64.8 102.99,53.44 102.19,52.64 102.19,48.94 102.38,48.76 102.38,48.09 102.19,47.9 102.19,47.6 102.54,47.26 102.84,47.26 v2(103.06,47.47)
  BOTTOM w0.076: v2(124.6,85.59) 125.73,85.59 126.2,86.06 126.91,86.06 127.16,85.81 127.85,85.81 UC1.BR6
  BOTTOM w0.127: JDIMM1.7 105.53,49.04 103.95,47.47 v2(103.06,47.47)
DDR_M0_D1: length 60.7
  IN3 w0.127: v2(125.02,86) 125.28,85.74 125.28,85.5 124.45,84.67 123.02,84.67 121.91,83.57 115.68,83.57 114.56,82.45 arc(113.76,81.25) 113.48,79.83 113.48,77.02 111.86,75.41 111.86,73.52 105.8,67.46 105.8,66.39 103.85,64.45 103.85,50.19 103.51,49.85 103.51,47.22 104.5,46.23 104.5,45.75 v2(104.63,45.62)
  BOTTOM w0.076: v2(125.02,86) 125.51,86 125.75,86.24 127.16,86.24 UC1.BT6
  BOTTOM w0.127: JDIMM1.4 104.77,42.83 104.17,43.43 104.17,45.16 v2(104.63,45.62)
DDR_M0_D2: length 61.9
  IN3 w0.127: v2(107.9,44.85) 107.58,44.85 106.84,45.59 106.84,50.14 106.51,50.48 106.51,63.35 111.98,68.82 111.98,69.07 111.71,69.34 111.71,69.54 114.75,72.58 114.93,72.58 115.24,72.27 115.42,72.27 115.59,72.45 115.59,72.63 114.53,73.7 114.53,73.88 114.71,74.06 114.89,74.06 115.97,72.98 116.14,72.98 116.29,73.13 116.29,73.33 115.3,74.32 115.3,74.56 115.51,74.76 115.8,74.76 116.4,74.16 116.91,74.16 v2(117.1,73.97)
  BOTTOM w0.076: UC1.BP3 128.15,83.57 127.58,83.57 127.47,83.46 127.07,83.46 126.87,83.26 126.11,83.26
  BOTTOM w0.127: JDIMM1.20 108.77,44.11 108.03,44.85 v2(107.9,44.85) ; v2(117.1,73.97) 117.35,74.22 118.88,74.22 122.27,77.61 122.27,80.22 123.5,81.46 124.31,81.46 126.11,83.26
DDR_M0_D3: length 59.9
  IN3 w0.127: v2(105.67,45.8) 105.94,45.8 106.39,46.25 106.39,49.98 106.07,50.3 106.07,63.52 111.28,68.73 111.28,69.7 114.12,72.55 114.12,74.29 115.24,75.4 118.96,75.4 121.59,78.04 121.59,79.66 122.22,80.29 122.22,80.42 121.66,80.98 121.66,81.13 121.91,81.37 122.04,81.37 122.61,80.81 122.75,80.81 123.35,81.41 v2(123.35,81.92)
  BOTTOM w0.076: 126.01,83.61 126.04,83.64 126.04,83.82 126.44,84.22 126.94,84.22 127.01,84.15 127.47,84.15 127.71,83.9 UC1.BR3
  BOTTOM w0.127: v2(105.67,45.8) 105.88,45.8 107.73,47.65 108.29,47.65 109.02,48.39 JDIMM1.21 ; 126.01,83.61 124.31,81.92 v2(123.35,81.92)
DDR_M0_D4: length 61.3
  IN3 w0.127: v2(123.63,85.11) 123.57,85.17 122.97,85.17 122.31,84.5 119.19,84.5 118.64,83.95 115.52,83.95 114.29,82.72 arc(113.41,81.4) 113.09,79.83 113.09,77.18 111.43,75.51 111.43,73.72 105.37,67.66 105.37,66.57 103.42,64.62 103.42,52.78 103.29,52.65 102.9,52.65 102.76,52.51 102.76,52.27 102.88,52.15 103.29,52.15 103.42,52.02 103.42,51.77 103.29,51.64 102.75,51.64 102.62,51.51 102.62,51.26 102.75,51.13 103.29,51.13 103.42,51 103.42,50.75 103.29,50.62 102.75,50.62 102.62,50.5 102.62,49.12 v2(103.01,48.74)
  BOTTOM w0.076: v2(123.63,85.11) 123.63,85.32 124.73,86.41 127.67,86.41 127.94,86.14 128.78,86.14 129.12,85.8 UC1.BN5
  BOTTOM w0.127: JDIMM1.3 104.53,49.51 103.76,48.74 v2(103.01,48.74)
DDR_M0_D5: length 61.4
  IN3 w0.127: v2(126.08,85.1) 124.52,84.24 123.36,84.24 122.96,84.08 122.07,83.19 116.86,83.19 arc(115.91,83) 115.11,82.46 114.83,82.18 arc(114.11,81.1) 113.86,79.83 113.86,76.86 112.29,75.3 112.29,73.32 106.23,67.26 106.23,66.22 104.28,64.27 104.28,50.01 103.97,49.7 103.97,47.37 105.05,46.29 105.05,44.72 v2(104.63,44.3)
  BOTTOM w0.076: UC1.BP6 128.07,85.43 127.77,85.43 127.55,85.64 127.07,85.64 126.84,85.87 126.37,85.87 126.08,85.57 v2(126.08,85.1)
  BOTTOM w0.127: JDIMM1.8 105.77,43.5 104.98,44.3 v2(104.63,44.3)
DDR_M0_D6: length 61.1
  IN3 w0.127: v2(107.9,46.51) 107.83,46.51 107.29,47.04 107.29,49.66 107.52,49.89 107.98,49.89 108.08,49.99 108.08,50.37 107.94,50.51 107.09,50.51 106.95,50.64 106.95,60.75 107.08,60.88 107.95,60.88 108.08,61 108.08,61.26 107.95,61.38 107.08,61.38 106.95,61.51 106.95,61.77 107.08,61.89 107.95,61.89 108.08,62.02 108.08,62.27 107.95,62.4 107.33,62.4 107.2,62.53 107.2,62.93 107.33,63.06 107.86,63.06 108.08,63.28 108.08,64.31 112.71,68.94 112.71,69.12 112.48,69.36 112.48,69.57 112.64,69.72 112.83,69.72 113.07,69.48 113.25,69.48 113.43,69.66 113.43,69.84 113.13,70.15 113.13,70.33 113.31,70.51 113.49,70.51 113.79,70.2 113.97,70.2 114.15,70.38 114.15,70.56 113.85,70.87 113.85,71.05 114.03,71.23 114.21,71.23 114.51,70.92 114.69,70.92 117.5,73.73 v2(118.21,73.73)
  BOTTOM w0.076: UC1.BP2 128.23,82.93 128.23,82.4 127.92,82.1 126.6,82.1 126.5,82
  BOTTOM w0.127: 126.5,82 123.85,79.35 123.85,78.65 118.93,73.73 v2(118.21,73.73) ; v2(107.9,46.51) 107.4,46 107.4,43.33 107.77,42.95 JDIMM1.16
DDR_M0_D7: length 61.1
  IN3 w0.127: v2(117.3,72.86) 117.3,72.86 108.51,64.08 108.51,59.36 108.39,59.24 107.64,59.24 107.51,59.11 107.51,58.86 107.64,58.73 108.39,58.73 108.51,58.6 108.51,58.35 108.39,58.22 107.53,58.22 107.4,58.09 107.4,57.84 107.53,57.71 108.39,57.71 108.51,57.59 108.51,57.33 108.39,57.2 107.53,57.2 107.4,57.08 107.4,56.82 107.53,56.7 108.39,56.7 108.51,56.57 108.51,56.32 108.39,56.19 107.53,56.19 107.4,56.06 107.4,55.81 107.53,55.68 108.39,55.68 108.51,55.55 108.51,55.3 108.39,55.17 107.53,55.17 107.4,55.05 107.4,54.79 107.53,54.66 108.39,54.66 108.51,54.54 108.51,54.28 108.39,54.16 107.53,54.16 107.4,54.03 107.4,53.78 107.53,53.65 108.39,53.65 108.51,53.52 108.51,53.27 108.39,53.14 107.53,53.14 107.4,53.01 107.4,51.18 107.65,50.94 108.39,50.94 108.51,50.81 108.51,48.92 108.39,48.79 v2(107.9,48.79)
  BOTTOM w0.076: 128.13,81.62 128.31,81.62 128.95,82.25 128.95,83.21 128.95,83.21 128.95,83.56 UC1.BN3
  BOTTOM w0.127: v2(107.9,48.79) 108.02,48.91 JDIMM1.17 ; 128.13,81.62 126.96,81.62 124.59,79.25 124.59,77.66 119.8,72.86 v2(117.3,72.86)
DDR_M0_D8: length 57.9
  IN3 w0.127: v2(109.38,44.78) 109.62,44.54 109.92,44.54 109.98,44.6 109.98,48.74 109.76,48.96 109.76,49.69 109.98,49.92 109.98,63.32 122.3,75.63 122.3,77.13 122.74,77.57 122.74,79 123.08,79.34 123.09,79.34 125.62,81.88 125.87,81.88 126,82.01 126,82.27 126.11,82.38 126.41,82.38 126.5,82.28 126.5,81.92 126.61,81.81 126.9,81.81 127.04,81.96 127.04,82.37 127.18,82.5 127.41,82.5 127.59,82.31 127.79,82.31 128.05,82.56 128.05,82.74 127.82,82.97 127.82,83.15 128,83.33 128.18,83.33 128.4,83.1 128.58,83.1 128.76,83.28 128.76,83.46 128.54,83.69 128.54,83.87 128.72,84.05 128.9,84.05 129.12,83.82 129.37,83.82 129.43,83.88 130.63,83.88 v2(130.9,84.14)
  BOTTOM w0.076: UC1.BL4 130.85,84.14 v2(130.9,84.14)
  BOTTOM w0.127: v2(109.38,44.78) 109.77,44.78 110.77,43.77 JDIMM1.28
DDR_M0_D9: length 58
  IN3 w0.127: v2(109.4,43.56) 109.4,42.47 109.59,42.28 110.57,42.28 110.79,42.5 110.79,44.18 110.42,44.56 110.42,63.21 122.68,75.47 122.68,76.97 123.13,77.42 123.13,78.76 125.81,81.43 127.56,81.43 129.55,83.42 131.03,83.42 131.32,83.72 131.32,84.41 v2(130.94,84.79)
  BOTTOM w0.076: UC1.BL5 130.85,84.79 v2(130.94,84.79)
  BOTTOM w0.127: v2(109.4,43.56) 109.77,43.19 JDIMM1.24
DDR_M0_D10: length 56.9
  IN3 w0.076: v2(129.8,82.93) 128.02,81.15 128.02,80.77 126.12,78.87 126.12,78.17 125.66,77.71 125.66,76.82
  IN3 w0.127: 125.66,76.82 125.66,76.33 125.23,75.91 125.23,72.75 113.94,61.46 113.94,59.66 113.26,58.98 113.26,54.29 113.94,53.62 113.94,50.86 113.19,50.11 113.19,47.07 113.55,46.71 113.55,43.67 113.42,43.53 113.16,43.53 113,43.7 113,46.25 112.87,46.38 112.22,46.38 v2(112.22,46.38)
  BOTTOM w0.076: UC1.BL2 130.24,82.93 v2(129.8,82.93)
  BOTTOM w0.127: JDIMM1.38 113.27,43.09 113.67,43.48 113.67,45.11 112.41,46.38 v2(112.22,46.38)
DDR_M0_D11: length 55.1
  IN3 w0.076: 125.99,77.3 125.99,77.62 126.49,78.12 126.49,78.78 v2(129.8,82.09)
  IN3 w0.127: 125.99,77.3 125.99,76.12 125.61,75.75 125.61,72.59 114.37,61.35 114.37,59.48 113.7,58.81 113.7,54.47 114.37,53.79 114.37,50.68 113.64,49.95 113.64,47.26 113.98,46.91 113.98,41.53 114.11,41.41 114.35,41.41 114.5,41.56 114.5,44.2 114.68,44.38 115,44.38 v2(115.16,44.21)
  BOTTOM w0.089: v2(129.8,82.09) 130.1,82.39 UC1.BM1
  BOTTOM w0.127: JDIMM1.42 114.27,42.87 114.58,43.18 114.58,43.63 v2(115.16,44.21)
DDR_M0_D12: length 59.1
  IN3 w0.127: v2(131.74,84.12) 132.14,84.52 132.14,85.6 131.88,85.86 129.26,85.86 126.6,83.2 125.67,83.2 121.98,79.5 121.98,77.88 118.8,74.7 118.8,73.72 108.95,63.87 108.95,46.48 109.35,46.07 v2(109.38,46.07)
  BOTTOM w0.076: v2(131.74,84.12) 131.66,84.12 UC1.BK4
  BOTTOM w0.127: JDIMM1.29 111.02,47.47 109.63,46.07 v2(109.38,46.07)
DDR_M0_D13: length 58.6
  IN3 w0.127: v2(131.71,84.79) 131.71,84.85 131.13,85.43 130.5,85.43 130.34,85.27 130.34,85.16 130.21,85.04 129.96,85.04 129.83,85.16 129.83,85.27 129.67,85.43 129.48,85.43 129.23,85.18 129.23,85.04 129.53,84.74 129.53,84.56 129.37,84.4 129.19,84.4 128.91,84.68 128.73,84.68 127.39,83.34 127.39,83.06 127.26,82.94 126.97,82.94 126.85,82.81 125.92,82.81 122.36,79.25 122.36,77.73 121.91,77.28 121.91,76.83 121.49,76.41 121.35,76.41 121.21,76.28 121.21,76.1 121.63,75.68 121.63,75.5 121.46,75.33 121.26,75.33 120.77,75.82 120.58,75.82 120.44,75.68 120.44,75.45 120.84,75.06 120.84,74.85 120.67,74.69 120.49,74.69 120.01,75.17 119.83,75.17 119.52,74.86 119.52,74.58 119.7,74.4 119.92,74.4 119.95,74.37 119.95,73.82 109.38,63.25 109.38,48.8 109.55,48.63 109.55,47.49 v2(109.38,47.32)
  BOTTOM w0.076: v2(131.71,84.79) 131.64,84.79 UC1.BK5
  BOTTOM w0.127: v2(109.38,47.32) 110.02,47.97 JDIMM1.25
DDR_M0_D14: length 56.7
  IN3 w0.076: v2(125.68,79.12) 125.68,78.27 125.27,77.86 125.27,77.53
  IN3 w0.127: v2(112.22,47.65) 112.25,47.65 112.75,48.14 112.75,50.3 113.04,50.6 113.04,50.86 112.92,50.98 112.82,50.98 112.68,51.12 112.68,51.39 112.84,51.54 113.28,51.54 113.51,51.77 113.51,53.44 112.83,54.11 112.83,59.16 113.51,59.84 113.51,61.57 120.79,68.85 120.79,69.03 120.33,69.48 120.33,69.66 120.51,69.84 120.69,69.84 121.15,69.39 121.33,69.39 121.51,69.57 121.51,69.75 121.05,70.2 121.05,70.38 121.23,70.56 121.41,70.56 121.87,70.11 122.05,70.11 122.23,70.28 122.23,70.46 121.77,70.92 121.77,71.1 121.95,71.28 122.13,71.28 122.59,70.82 122.77,70.82 122.94,71 122.94,71.18 122.49,71.64 122.49,71.82 122.67,72 122.85,72 123.3,71.54 123.48,71.54 123.66,71.72 123.66,71.9 123.21,72.36 123.21,72.54 123.39,72.72 123.57,72.72 124.02,72.26 124.2,72.26 124.54,72.6 124.54,72.83 124.29,73.08 124.29,73.44 124.85,74 124.85,76.06 125.27,76.48 125.27,77.53
  BOTTOM w0.076: UC1.BK1 130.88,82 128.93,80.04 128.74,80.04 128.73,80.05
  BOTTOM w0.127: v2(125.68,79.12) 127.45,79.12 128.39,80.05 128.73,80.05 ; JDIMM1.41 114.02,48.64 113.03,47.65 v2(112.22,47.65)
DDR_M0_D15: length 57.5
  IN3 w0.076: v2(125.28,78.66) 125.28,78.39 124.92,78.03
  IN3 w0.127: v2(112.22,48.92) 112.22,51.83 112.4,52.01 112.4,59.36 113.08,60.04 113.08,60.89 112.46,61.51 112.46,61.81 112.7,62.05 112.92,62.05 113.13,61.84 113.24,61.84 113.56,62.16 113.56,62.34 112.95,62.95 112.95,63.16 113.13,63.34 113.29,63.34 113.92,62.7 114.1,62.7 117.21,65.81 117.21,65.99 116.57,66.62 116.57,66.8 116.75,66.98 116.93,66.98 117.57,66.35 117.75,66.35 117.93,66.53 117.93,66.71 117.29,67.34 117.29,67.52 117.47,67.7 117.65,67.7 118.29,67.07 118.47,67.07 118.65,67.24 118.65,67.42 118.01,68.06 118.01,68.24 118.19,68.42 118.37,68.42 119.01,67.78 119.19,67.78 119.37,67.96 119.37,68.14 118.73,68.78 118.73,68.96 118.91,69.14 119.09,69.14 119.72,68.5 119.9,68.5 120.08,68.68 120.08,68.86 119.45,69.5 119.45,69.68 120.09,70.33 120.46,70.33 124.47,74.34 124.47,76.22 124.92,76.67 124.92,78.03
  BOTTOM w0.076: 128.56,79.6 128.86,79.6 130.11,80.86 130.11,80.96 131.31,82.17 UC1.BK2
  BOTTOM w0.127: v2(112.22,48.92) 112.55,48.92 113.02,49.39 JDIMM1.37 ; 128.56,79.6 127.62,78.66 v2(125.28,78.66)
DDR_M0_D16: length 54.7
  IN3 w0.076: 127.53,77.58 127.39,77.72 127.39,78.26 128.81,79.68 129.24,79.68 129.52,79.4 129.88,79.4 131.39,80.91 v2(131.39,81.58)
  IN3 w0.127: 127.53,77.58 127.55,77.56 127.55,72.31 116.54,61.29 116.54,53.3 116.41,53.17 116.18,53.17 116.05,53.05 116.05,52.79 116.18,52.67 116.41,52.67 116.54,52.54 116.54,52.29 116.41,52.16 116.18,52.16 116.05,52.03 116.05,51.78 116.18,51.65 116.41,51.65 116.54,51.52 116.54,51.27 116.41,51.14 116.23,51.14 116.1,51.02 116.1,50.76 116.23,50.63 116.41,50.63 116.54,50.51 116.54,50.25 116.41,50.13 116.23,50.13 116.1,50 116.1,49.75 116.23,49.62 116.41,49.62 116.54,49.49 116.54,48.47 115.67,47.6 115.67,46.4 115.54,46.27 v2(115.15,46.27)
  BOTTOM w0.076: v2(131.39,81.58) 131.94,81.58 132.32,81.96 132.32,82.86 132.47,83.01 132.47,83.9 UC1.BG4
  BOTTOM w0.127: JDIMM1.46 115.27,43.33 115.78,43.84 115.78,46 115.5,46.27 v2(115.15,46.27)
DDR_M0_D17: length 55.8
  IN3 w0.076: 126.48,77.48 126.72,77.72 126.72,78.63 128.7,80.61 130.48,81.02 v2(130.98,81.09)
  IN3 w0.127: 126.48,77.48 126.37,77.37 126.37,75.97 125.99,75.59 125.99,72.43 114.8,61.25 114.8,59.35 114.08,58.28 114.08,54.7 114.8,53.97 114.8,50.5 114.18,49.88 114.18,47.91 114.53,46.88 114.53,45.61 114.91,45.23 115.34,45.23 v2(117.48,43.97)
  BOTTOM w0.076: UC1.BG5 133.36,84.8 133.36,84.37 133.14,84.15 132.98,84.15 132.64,83.81 132.64,82.94 132.52,82.83 132.52,81.57 132.04,81.09 v2(130.98,81.09)
  BOTTOM w0.127: JDIMM1.50 116.27,42.94 117.3,43.97 v2(117.48,43.97)
DDR_M0_D18: length 54.5
  IN3 w0.076: v2(134.17,84.15) 132.88,82.85 132.88,81.54 131.24,79.9 131.24,79.49 130.96,79.22
  IN3 w0.127: 130.96,79.22 130.13,78.38 130.13,75.83 129.73,75.42 129.73,71.41 118.78,60.46 118.78,57.51 118.91,57.38 119.65,57.38 119.78,57.25 119.78,57 119.65,56.88 118.91,56.88 118.78,56.75 118.78,56.5 118.91,56.37 119.65,56.37 119.78,56.24 119.78,55.99 119.65,55.86 118.91,55.86 118.78,55.73 118.78,55.32 118.91,55.19 119.08,55.19 119.2,55.07 119.2,54.71 119.08,54.59 118.91,54.59 118.78,54.46 118.78,54.2 118.91,54.08 119.08,54.08 119.2,53.95 119.2,53.7 119.08,53.57 118.91,53.57 118.78,53.44 118.78,53.19 118.91,53.06 119.08,53.06 119.2,52.93 119.2,52.68 119.08,52.55 118.91,52.55 118.78,52.43 118.78,52.17 118.91,52.05 119.08,52.05 119.2,51.92 119.2,51.66 119.08,51.54 118.91,51.54 118.78,51.41 118.78,51.16 118.91,51.03 119.08,51.03 119.2,50.9 119.2,49.41 118.78,48.99 118.78,46.86 118.91,46.73 v2(119.21,46.73)
  BOTTOM w0.089: v2(134.17,84.15) 134.1,84.15 UC1.BF4
  BOTTOM w0.127: JDIMM1.63 119.53,49.24 119.69,49.07 119.69,47.11 119.36,46.78 119.26,46.78 v2(119.21,46.73)
DDR_M0_D19: length 55.1
  IN3 w0.076: 130.71,79.53 130.93,79.74 130.93,80.07 132.4,81.54 132.4,83.02 v2(134.17,84.8)
  IN3 w0.127: v2(119.21,45.44) 119.21,45.33 118.58,44.69 118.58,43.54 118.39,43.36 118.23,43.36 118.05,43.53 118.05,44.97 118.35,45.27 118.35,60.57 129.34,71.56 129.34,75.92 129.74,76.32 129.74,78.55 130.71,79.53
  BOTTOM w0.089: v2(134.17,84.8) UC1.BF5
  BOTTOM w0.127: v2(119.21,45.44) 118.27,44.5 JDIMM1.58
DDR_M0_D20: length 53.2
  IN3 w0.076: 126.75,77.12 126.94,77.31 126.94,78.37 128.88,80.31 129.98,80.31 v2(130.1,80.19)
  IN3 w0.127: v2(115.16,47.47) 114.61,48.02 114.61,49.7 115.24,50.33 115.24,54.51 115.11,54.64 114.79,54.64 114.64,54.79 114.64,55.02 114.77,55.15 115.11,55.15 115.24,55.27 115.24,55.53 115.11,55.65 114.58,55.65 114.46,55.78 114.46,56.03 114.58,56.16 115.11,56.16 115.24,56.29 115.24,56.54 115.11,56.67 114.58,56.67 114.46,56.8 114.46,57.05 114.58,57.18 115.11,57.18 115.24,57.3 115.24,57.56 115.11,57.69 114.58,57.69 114.46,57.81 114.46,58.05 114.6,58.19 115.11,58.19 115.24,58.32 115.24,61.14 126.37,72.28 126.37,75.31 126.75,75.69 126.75,77.12
  BOTTOM w0.076: UC1.BG2 133.04,82.97 132.72,82.65 132.72,81.25 131.66,80.19 v2(130.1,80.19)
  BOTTOM w0.127: JDIMM1.49 116.02,48.33 v2(115.16,47.47)
DDR_M0_D21: length 52.3
  IN3 w0.076: 127.17,77.09 127.21,77.13 127.21,78.39 128.88,80.06 129.39,80.06 v2(129.62,79.83)
  IN3 w0.127: v2(115.16,48.7) 115.55,48.31 115.76,48.31 116.1,48.65 116.1,49.02 115.94,49.18 115.25,49.18 115.07,49.36 115.07,49.54 115.67,50.15 115.67,53.7 115.8,53.83 115.98,53.83 116.1,53.96 116.1,54.21 115.98,54.34 115.8,54.34 115.67,54.47 115.67,54.72 115.8,54.85 115.98,54.85 116.1,54.97 116.1,55.23 115.98,55.36 115.8,55.36 115.67,55.48 115.67,55.74 115.8,55.86 115.98,55.86 116.1,55.99 116.1,56.24 115.98,56.37 115.8,56.37 115.67,56.5 115.67,56.75 115.8,56.88 115.98,56.88 116.1,57.01 116.1,57.26 115.98,57.39 115.8,57.39 115.67,57.51 115.67,57.77 115.8,57.9 115.98,57.9 116.1,58.02 116.1,58.28 115.98,58.4 115.8,58.4 115.67,58.53 115.67,58.78 115.8,58.91 115.98,58.91 116.1,59.04 116.1,59.29 115.98,59.42 115.8,59.42 115.67,59.55 115.67,59.8 115.8,59.93 115.98,59.93 116.1,60.05 116.1,60.31 115.98,60.44 115.8,60.44 115.67,60.56 115.67,60.91 115.78,61.02 115.98,61.02 116.1,61.15 116.1,61.47 126.81,72.17 126.81,72.99 126.93,73.12 127.06,73.12 127.17,73.23 127.17,73.53 127.05,73.65 126.88,73.65 126.76,73.78 126.76,74.04 126.88,74.16 127.05,74.16 127.17,74.29 127.17,74.54 127.05,74.67 126.88,74.67 126.76,74.79 126.76,75.05 126.89,75.18 127.05,75.18 127.17,75.31 127.17,77.09
  BOTTOM w0.076: UC1.BG1 133.04,81.18 131.59,79.73 129.72,79.73 v2(129.62,79.83)
  BOTTOM w0.127: JDIMM1.45 115.02,48.83 v2(115.16,48.7)
DDR_M0_D22: length 52.7
  IN3 w0.076: 131.8,79.76 131.8,80.03 133.28,81.51 133.28,81.71 133.76,82.19 v2(134.17,82.19)
  IN3 w0.127: v2(119.22,48.23) 119.42,48.23 119.64,48.45 119.64,54.69 120.21,55.27 120.21,57.82 120.08,57.94 119.29,57.94 119.17,58.07 119.17,58.32 119.29,58.45 120.08,58.45 120.21,58.58 120.21,58.83 120.08,58.96 119.29,58.96 119.17,59.09 119.17,59.34 119.29,59.47 120.08,59.47 120.21,59.59 120.21,59.85 120.08,59.98 119.34,59.98 119.22,60.1 119.22,60.36 119.34,60.48 120.08,60.48 120.21,60.61 120.21,61.09 130.16,71.04 130.16,75.14 130.58,75.57 130.58,76.43 130.71,76.56 131.58,76.56 131.78,76.76 131.78,76.96 131.65,77.1 130.73,77.1 130.61,77.22 130.61,77.45 130.73,77.57 131.63,77.57 131.8,77.74 131.8,77.97 131.67,78.09 131.01,78.09 130.88,78.23 130.88,78.46 131.02,78.6 131.67,78.6 131.8,78.73 131.8,79.76
  BOTTOM w0.089: v2(134.17,82.19) UC1.BF1
  BOTTOM w0.127: JDIMM1.59 118.53,48.82 119.06,48.28 119.17,48.28 v2(119.22,48.23)
DDR_M0_D23: length 53.4
  IN3 w0.076: v2(134.17,82.84) 134.57,82.44 134.57,82.36 134.58,82.36 134.58,82.03 134.34,81.79 133.94,81.79 133.71,81.56 133.71,81.23 133.64,81.16
  IN3 w0.127: v2(119.21,43.86) 119.14,43.79 119.14,41.83 119.26,41.71 119.97,41.71 120.1,41.83 120.1,42.07 119.97,42.19 119.82,42.19 119.69,42.32 119.69,42.57 119.82,42.7 119.94,42.7 120.07,42.83 120.07,54.51 120.64,55.09 120.64,60.99 130.59,70.93 130.59,74.9 132.25,76.56 132.25,79.77 133.64,81.16
  BOTTOM w0.089: v2(134.17,82.84) UC1.BF2
  BOTTOM w0.127: JDIMM1.62 119.27,43.8 v2(119.21,43.86)
DDR_M0_D24: length 49.6
  IN3 w0.127: v2(134.19,79) 134.14,79 133.75,78.6 133.75,76.22 131.88,74.36 131.88,70.61 122.74,61.46 122.74,56.63 121.95,55.84 121.95,46.05 121.83,45.92 121.04,45.92 120.92,45.79 120.92,45.54 121.04,45.41 121.83,45.41 121.95,45.29 121.95,44.9 121.78,44.73 v2(121.12,44.73)
  BOTTOM w0.076: UC1.BD2 135.28,82.89 135.28,81.8 134.92,81.44 134.92,79.73 v2(134.19,79)
  BOTTOM w0.127: v2(121.12,44.73) 120.27,43.89 JDIMM1.66
DDR_M0_D25: length 48.8
  IN3 w0.127: v2(134.19,77.83) 134.19,76.06 132.32,74.18 132.32,70.5 123.17,61.36 123.17,56.45 122.38,55.67 122.38,44.71 122.55,44.55 123.16,44.55 123.34,44.36 123.34,43.69 123.02,43.36 v2(121.09,43.36)
  BOTTOM w0.076: v2(134.19,77.83) 134.19,77.88 135.1,78.79 135.1,81.37 135.56,81.83 UC1.BD1
  BOTTOM w0.127: v2(121.09,43.36) 121.27,43.17 121.27,43.16 JDIMM1.70
DDR_M0_D26: length 53.2
  IN3 w0.127: v2(125.96,44.9) 126.16,44.9 126.44,44.63 126.44,44.42 126.57,44.29 126.95,44.29 127.07,44.42 127.07,45.49 126.86,45.7 125.72,45.7 125.52,45.9 125.52,48.3 125.44,48.39 125.44,48.89 125.57,49.02 125.87,49.02 126,49.15 126,49.4 125.87,49.52 125.57,49.52 125.44,49.65 125.44,60.43 132.9,67.89 v2(132.9,67.9)
  BOTTOM w0.076: 137.22,81.85 136.74,82.33 136.74,82.95 136.61,83.08 136.61,83.21 136.61,83.94 136.29,84.26 UC1.BC4
  BOTTOM w0.127: JDIMM1.80 123.77,43.2 125.48,44.9 v2(125.96,44.9) ; v2(132.9,67.9) 132.91,67.91 132.91,70.15 137.02,74.27 137.02,77.47 137.44,77.88 137.44,81.63 137.22,81.85
DDR_M0_D27: length 53.5
  IN3 w0.127: v2(124.32,47.29) 124.73,47.29 125.01,47.57 125.01,49.18 124.88,49.31 124.3,49.31 124.18,49.43 124.18,49.69 124.3,49.81 124.88,49.81 125.01,49.94 125.01,50.19 124.88,50.32 124.3,50.32 124.18,50.45 124.18,50.7 124.3,50.83 124.88,50.83 125.01,50.96 125.01,53.4 124.88,53.53 124.3,53.53 124.18,53.65 124.18,53.91 124.3,54.03 124.88,54.03 125.01,54.16 125.01,54.42 124.88,54.54 124.3,54.54 124.18,54.67 124.18,54.92 124.3,55.05 124.88,55.05 125.01,55.18 125.01,60.66 133.07,68.72 v2(133.74,68.72)
  BOTTOM w0.076: UC1.BC5 136.57,84.84 136.57,84.21 136.78,84.01 136.78,83.15 136.9,83.02 136.9,82.4 137.12,82.19 137.35,82.19 137.58,81.95
  BOTTOM w0.127: v2(124.32,47.29) 123.53,48.09 123.53,50.25 ; 137.58,81.95 137.75,81.79 137.75,77.69 137.46,77.4 137.46,74.02 133.74,70.3 v2(133.74,68.72)
DDR_M0_D28: length 51.8
  IN3 w0.127: v2(121.05,48.19) 120.84,48.19 120.54,48.49 120.54,48.87 121.05,49.38 121.05,49.71 120.87,49.89 120.63,49.89 120.5,50.01 120.5,50.27 120.63,50.4 120.95,50.4 121.07,50.52 121.07,50.78 120.95,50.9 120.63,50.9 120.5,51.03 120.5,51.28 120.63,51.41 120.95,51.41 121.07,51.54 121.07,51.79 120.95,51.92 120.63,51.92 120.5,52.05 120.5,52.3 120.63,52.43 120.95,52.43 121.07,52.55 121.07,52.81 120.95,52.94 120.63,52.94 120.5,53.06 120.5,53.32 120.63,53.44 120.95,53.44 121.07,53.57 121.07,53.82 120.95,53.95 120.63,53.95 120.5,54.08 120.5,54.33 120.63,54.46 120.95,54.46 121.07,54.59 121.07,59.52 121.2,59.64 121.74,59.64 121.87,59.77 121.87,60.03 121.74,60.15 121.2,60.15 121.07,60.28 121.07,60.64 121.17,60.74 121.71,60.74 121.87,60.9 121.87,61.68 131.02,70.83 131.02,74.72 132.85,76.55 132.85,79.59 134.05,80.8 v2(134.19,80.8)
  BOTTOM w0.076: UC1.BD5 134.95,84.51 134.95,81.97 134.57,81.59 134.57,81.17 v2(134.19,80.8)
  BOTTOM w0.127: v2(121.05,48.19) 121.4,48.19 121.53,48.32 JDIMM1.71
DDR_M0_D29: length 51.2
  IN3 w0.127: v2(134.19,80.19) 133.98,80.19 133.3,79.5 133.3,76.39 131.45,74.54 131.45,70.72 122.3,61.57 122.3,59.34 122.18,59.21 121.63,59.21 121.51,59.09 121.51,58.83 121.63,58.7 122.18,58.7 122.3,58.58 122.3,58.32 122.18,58.2 121.63,58.2 121.51,58.07 121.51,57.82 121.63,57.69 122.18,57.69 122.3,57.56 122.3,57.31 122.18,57.18 121.63,57.18 121.51,57.05 121.51,56.87 121.81,56.56 121.81,56.32 121.51,56.01 121.51,46.72 121.4,46.62 121.15,46.62 v2(121.06,46.71)
  BOTTOM w0.076: v2(134.19,80.19) 134.75,80.74 134.75,81.52 135.11,81.88 135.11,84.02 UC1.BD4
  BOTTOM w0.127: v2(121.06,46.71) 120.55,47.22 120.55,49.27 120.53,49.3 JDIMM1.67
DDR_M0_D30: length 50.1
  IN3 w0.127: v2(136.25,79.09) 136.09,78.94 136.07,78.94 135.82,78.68 135.82,75.69 134.16,74.03 134.16,68.53 126.95,61.32 126.44,60.81 126.44,60.25 126.31,60.12 126,60.12 125.87,60 125.87,59.74 126,59.62 126.31,59.62 126.44,59.49 126.44,59.23 126.31,59.11 126,59.11 125.87,58.98 125.87,58.73 126,58.6 126.31,58.6 126.44,58.47 126.44,58.22 126.31,58.09 126,58.09 125.87,57.96 125.87,57.71 126,57.58 126.31,57.58 126.44,57.46 126.44,57.13 126.34,57.03 126.01,57.03 125.87,56.89 125.87,54.24 125.95,54.17 126.34,54.17 126.43,54.08 126.43,53.7 126.31,53.58 126,53.58 125.87,53.45 125.87,53.2 126,53.07 126.31,53.07 126.43,52.94 126.43,52.69 126.31,52.56 126,52.56 125.87,52.43 125.87,52.18 126,52.05 126.31,52.05 126.43,51.93 126.43,51.67 126.31,51.55 126,51.55 125.87,51.42 125.87,51.16 126,51.04 126.31,51.04 126.43,50.91 126.43,50.66 126.31,50.53 126,50.53 125.87,50.4 125.87,50.15 126,50.02 126.31,50.02 126.43,49.89 126.43,47.87 v2(125.96,47.39)
  BOTTOM w0.127: v2(136.25,79.09) 136.26,79.1 136.41,79.1 136.82,79.51 136.82,81.47 136.29,82 UC1.BC1 ; v2(125.96,47.39) 124.53,48.83 JDIMM1.83
DDR_M0_D31: length 50.5
  IN3 w0.127: v2(125.97,43.67) 125.97,42.84 126.22,42.59 127.28,42.59 127.51,42.82 127.51,46.15 126.86,46.79 126.86,54.26 126.53,54.59 126.53,56.24 126.87,56.58 126.87,60.63 134.55,68.31 134.55,73.78 136.34,75.57 136.34,77.83 v2(136.25,77.92)
  BOTTOM w0.076: UC1.BC2 136.29,83.16 136.57,82.88 136.57,82.1 136.74,81.93
  BOTTOM w0.127: v2(125.97,43.67) 125.62,43.67 124.77,42.82 JDIMM1.84 ; v2(136.25,77.92) 136.33,77.92 137.1,78.7 137.1,81.57 136.74,81.93
DDR_M0_D32: length 48.1
  IN3 w0.127: v2(154.28,74.93) 154.5,74.71 154.5,72.08 155.5,71.07 155.5,59.96 150.29,54.75 150.29,52.38 149.13,51.23 149.13,49.18 148.99,49.03 148.99,46.16 149.27,45.88 150.08,45.88 150.5,45.46 150.5,44.44 150.71,44.23 151.52,44.23 151.67,44.07 151.67,43.64 151.53,43.5 v2(149.96,43.5)
  BOTTOM w0.076: 153.61,80.27 153.18,80.7 153.18,82.5 UC1.AB1
  BOTTOM w0.127: 153.61,80.27 153.96,79.92 153.96,77.05 154.29,76.72 154.29,74.93 v2(154.28,74.93) ; v2(149.96,43.5) 149.28,42.81 JDIMM1.174
DDR_M0_D33: length 49
  IN3 w0.127: v2(149.94,46.51) 149.83,46.4 149.54,46.4 149.42,46.52 149.42,48.74 149.54,48.87 149.8,48.87 149.93,49 149.93,49.31 149.8,49.44 149.69,49.44 149.57,49.57 149.57,49.87 149.7,50.01 150.49,50.01 150.62,50.14 150.62,50.47 150.49,50.6 149.69,50.6 149.57,50.73 149.57,50.98 149.69,51.11 150.49,51.11 150.67,51.29 150.67,54.59 155.88,59.8 155.88,71.3 154.88,72.31 154.88,75.03 154.22,75.69 v2(153.85,75.69)
  BOTTOM w0.076: UC1.AB2 153.06,83.17 152.88,82.99 152.88,82.4 153.01,82.27 153.01,80.46 153.19,80.28
  BOTTOM w0.127: 153.19,80.28 153.54,79.93 153.54,76.74 153.85,76.43 v2(153.85,75.69) ; v2(149.94,46.51) 149.8,46.51 148.02,48.28 JDIMM1.169
DDR_M0_D34: length 49.2
  IN3 w0.127: v2(152.75,47.26) 153.24,47.26 153.35,47.37 153.35,53.66 158.43,58.74 158.43,73.31 154.89,76.85 154.89,77.93 153.47,79.35 153.47,80.96 153.35,81.09 152.8,81.09 152.68,81.21 152.68,81.47 152.8,81.59 153.35,81.59 153.47,81.72 153.47,81.97 153.35,82.1 152.8,82.1 152.68,82.23 152.68,82.48 152.8,82.61 153.35,82.61 153.47,82.74 153.47,84.09 153.66,84.27 154.21,84.27 v2(154.34,84.14)
  BOTTOM w0.089: v2(154.34,84.14) UC1.AA4
  BOTTOM w0.127: v2(152.75,47.26) 152.32,47.68 152.32,48.36 151.52,49.16 JDIMM1.183
DDR_M0_D35: length 49.7
  IN3 w0.127: v2(152.75,48.43) 152.92,48.6 152.92,53.77 158.05,58.9 158.05,73.08 154.46,76.67 154.46,77.75 152.76,79.45 152.76,80.26 152.24,80.78 152.24,81.69 152.12,81.82 151.63,81.82 151.5,81.94 151.5,82.2 151.63,82.32 152.12,82.32 152.24,82.45 152.24,82.71 152.12,82.83 151.44,82.83 151.31,82.96 151.31,83.21 151.44,83.34 152.88,83.34 153.04,83.5 153.04,83.92 152.92,84.04 152.44,84.04 152.24,84.25 152.24,84.68 152.4,84.85 154.23,84.85 v2(154.33,84.75)
  BOTTOM w0.089: v2(154.33,84.75) UC1.AA5
  BOTTOM w0.127: v2(152.75,48.43) 152.75,48.55 152.52,48.77 JDIMM1.187
DDR_M0_D36: length 50.2
  IN3 w0.127: v2(152.56,76.88) 152.4,76.72 152.4,76.2 154.12,74.48 154.12,71.85 155.12,70.84 155.12,60.12 149.91,54.91 149.91,52.61 148.7,51.41 148.7,49.38 148.55,49.23 148.55,44.52 148.73,44.34 149.08,44.34 149.22,44.49 149.22,44.67 149.41,44.86 v2(149.94,44.86)
  BOTTOM w0.076: 152.63,79.81 152.63,82.13 152.55,82.21 152.55,84.25 152.75,84.45 152.75,84.71 UC1.AB5
  BOTTOM w0.127: JDIMM1.170 148.28,43.35 149.78,44.86 v2(149.94,44.86) ; v2(152.56,76.88) 152.56,77.78 152.63,77.84 152.63,79.81
DDR_M0_D37: length 49.6
  IN3 w0.127: v2(153,76.49) 153.26,76.49 153.46,76.69 153.46,77.07 152.76,77.77 152.76,78.48 152.87,78.58 153.02,78.58 154.03,77.57 154.03,76.49 155.9,74.62 155.9,74.43 155.77,74.3 155.41,74.3 155.26,74.15 155.26,72.54 156.26,71.53 156.26,59.64 151.05,54.43 151.05,49.87 150.36,49.18 150.36,48.19 v2(149.94,47.78)
  BOTTOM w0.076: 152.86,80.08 152.79,80.15 152.79,82.22 152.71,82.29 152.71,84.02 UC1.AB4
  BOTTOM w0.127: v2(149.94,47.78) 149.02,48.69 JDIMM1.173 ; v2(153,76.49) 153,77.35 153.09,77.44 153.09,79.85 152.86,80.08
DDR_M0_D38: length 47.6
  IN3 w0.127: v2(152.77,44.72) 153.53,44.72 153.78,44.98 153.78,53.55 158.82,58.58 158.82,73.54 155.99,76.36 155.32,77.03 155.32,78.11 153.91,79.53 153.91,82.77 154.05,82.91 v2(154.34,82.91)
  BOTTOM w0.089: v2(154.34,82.91) UC1.AA2
  BOTTOM w0.127: JDIMM1.182 151.28,43.78 152.22,44.72 v2(152.77,44.72)
DDR_M0_D39: length 46.9
  IN3 w0.127: v2(154.34,82.26) 154.68,82.26 154.81,82.13 154.81,79.24 155.75,78.29 155.75,77.21 159.05,73.92 159.13,73.83 159.2,73.77 159.2,58.43 154.21,53.44 154.21,43.44 154.09,43.32 152.99,43.32 v2(152.75,43.56)
  BOTTOM w0.089: v2(154.34,82.26) UC1.AA1
  BOTTOM w0.127: v2(152.75,43.56) 152.28,43.08 JDIMM1.186
DDR_M0_D40: length 53.5
  IN3 w0.127: v2(154.65,44.55) 154.94,44.84 155.28,44.84 155.43,44.68 155.43,42.88 155.54,42.78 155.75,42.78 155.86,42.89 155.86,50.18 156.26,50.58 156.26,52.64 160.77,57.14 v2(160.77,69.57)
  BOTTOM w0.076: UC1.V5 155.28,84.73 155.28,84.17 155.06,83.95 155.06,81.65 154.95,81.53 154.95,77.79 155.47,77.26
  BOTTOM w0.127: v2(154.65,44.55) 153.28,43.17 JDIMM1.190 ; v2(160.77,69.57) 160.5,69.57 157.75,72.33 157.75,74.99 155.47,77.26
DDR_M0_D41: length 51.5
  IN3 w0.127: v2(160.76,70.84) 160.34,70.43 160.34,57.25 155.88,52.79 155.88,50.81 155.46,50.39 155.46,46.04 155.13,45.71 v2(154.65,45.71)
  BOTTOM w0.076: UC1.V2 155.39,82.89 155.39,82.09 155.47,82.01 155.47,78.51 155.59,78.39
  BOTTOM w0.127: v2(160.76,70.84) 161.5,71.58 161.5,72.55 161.37,72.68 160.74,72.68 160.61,72.8 160.61,73.06 160.74,73.18 161.17,73.18 161.29,73.3 161.29,73.56 161.15,73.69 160.74,73.69 160.61,73.82 160.61,74.07 160.74,74.2 161.03,74.2 161.22,74.39 161.22,74.71 161.01,74.92 159.06,74.92 155.59,78.39 ; JDIMM1.191 153.52,49.4 153.62,49.3 153.62,47.66 154.18,47.1 154.18,46.18 v2(154.65,45.71)
DDR_M0_D42: length 48.8
  IN3 w0.127: v2(157.03,81.56) 157.08,81.51 157.08,80.35 156.85,80.12 156.68,80.12 156.39,80.41 156.39,82.69 156.27,82.81 156,82.81 155.89,82.7 155.89,80.24 157.29,78.85 158.48,78.85 162.09,75.24 162.09,73.83 162.94,72.98 162.94,56.24 158.69,52 158.69,49.8 158.17,49.28 v2(158.17,48.13)
  BOTTOM w0.076: UC1.U1 156.41,82.09 156.93,81.56 v2(157.03,81.56)
  BOTTOM w0.127: v2(158.17,48.13) 157.52,48.77 JDIMM1.207
DDR_M0_D43: length 49.3
  IN3 w0.127: v2(158.25,45.62) 158.69,45.62 158.77,45.7 158.77,49.04 159.23,49.49 159.23,51.99 163.32,56.09 163.32,73.14 162.47,73.98 162.47,75.4 158.62,79.25 158.54,79.25 158.46,79.33 158.46,79.6 158.37,79.69 158.06,79.69 157.99,79.61 157.99,79.33 157.91,79.25 157.51,79.25 157.27,79.48 157.27,79.95 157.54,80.22 157.54,83.01 157.44,83.12 157.15,83.12 v2(156.86,82.83)
  BOTTOM w0.076: v2(156.86,82.83) 156.75,82.83 UC1.U2
  BOTTOM w0.127: JDIMM1.208 157.77,42.86 158.71,43.8 158.71,45.16 v2(158.25,45.62)
DDR_M0_D44: length 49
  IN3 w0.127: v2(156.35,78.27) 156.19,78.11 156.19,77.39 157.91,75.67 158.09,75.67 158.25,75.83 158.43,75.83 158.61,75.65 158.61,75.47 158.45,75.31 158.45,75.13 158.63,74.95 158.81,74.95 158.97,75.11 159.15,75.11 159.33,74.93 159.33,74.75 159.17,74.59 159.17,74.41 159.31,74.26 159.75,74.26 159.89,74.12 159.89,73.87 159.58,73.56 159.58,72.95 159.73,72.8 160.04,72.8 160.15,72.69 160.15,72.21 160.01,72.07 159.74,72.07 159.58,71.92 159.58,58.26 159.4,58.08 159.4,57.9 159.54,57.75 159.54,57.57 159.36,57.39 159.18,57.39 159.04,57.54 158.86,57.54 158.68,57.36 158.68,57.18 158.83,57.03 158.83,56.85 158.65,56.67 158.47,56.67 158.32,56.82 158.14,56.82 157.96,56.64 157.96,56.46 158.11,56.31 158.11,56.13 157.93,55.95 157.75,55.95 157.6,56.1 157.42,56.1 157.24,55.92 157.24,55.74 157.39,55.6 157.39,55.42 157.21,55.24 157.03,55.24 156.88,55.38 156.7,55.38 156.52,55.21 156.52,55.03 156.67,54.88 156.67,54.7 156.49,54.52 156.31,54.52 156.16,54.67 155.98,54.67 155.8,54.49 155.8,54.31 155.95,54.16 155.95,53.98 155.77,53.8 155.59,53.8 155.44,53.95 155.26,53.95 155.05,53.74 155.05,51.2 154.65,50.8 v2(154.65,48.15)
  BOTTOM w0.076: UC1.V1 155.67,80.7 156.01,80.36
  BOTTOM w0.127: 156.01,80.36 156.35,80.03 156.35,79.83 155.93,79.41 155.93,79.23 156.13,79.04 156.32,79.04 156.74,79.46 156.92,79.46 157.01,79.36 157.01,78.42 156.87,78.27 v2(156.35,78.27) ; v2(154.65,48.15) 154.52,48.28 JDIMM1.195
DDR_M0_D45: length 52.5
  IN3 w0.127: v2(154.65,46.9) 154.99,46.9 155.08,46.99 155.08,50.62 155.5,51.04 155.5,52.95 159.96,57.41 159.96,71.35 160.65,72.05 v2(160.75,72.05)
  BOTTOM w0.076: UC1.V4 155.53,84.32 155.53,84.18 155.23,83.88 155.23,78.05 155.42,77.86
  BOTTOM w0.127: JDIMM1.194 154.28,43.42 155.28,44.43 155.28,46.27 v2(154.65,46.9) ; 155.42,77.86 155.46,77.86 158.71,74.61 158.71,72.3 159,72.01 159.19,72.01 159.32,72.14 159.32,73.55 159.46,73.7 159.72,73.7 159.83,73.59 159.83,72.18 159.96,72.05 v2(160.75,72.05)
DDR_M0_D46: length 51.3
  IN3 w0.127: v2(158.25,46.83) 158.18,46.83 157.75,47.26 157.75,49.52 158.26,50.03 158.26,52.1 162.56,56.4 162.56,72.82 161.71,73.67 161.71,75.08 158.37,78.43 157.05,78.43 155.5,79.97 155.5,83.48 155.88,83.86 155.88,84.49 155.5,84.88 155.5,85.38 155.68,85.57 156.08,85.57 v2(156.86,84.79)
  BOTTOM w0.076: UC1.U5 156.74,84.79 v2(156.86,84.79)
  BOTTOM w0.127: JDIMM1.203 156.52,48.56 v2(158.25,46.83)
DDR_M0_D47: length 50.5
  IN3 w0.127: v2(158.25,44.35) 158.75,44.35 159.2,44.8 159.2,48.85 159.61,49.25 159.61,51.83 163.7,55.93 163.7,73.29 162.86,74.14 162.86,75.56 160.29,78.12 160.29,78.48 157.92,80.85 157.92,84.49 157.82,84.6 157.53,84.6 157.45,84.52 157.45,83.93 157.35,83.83 157.13,83.83 v2(156.81,84.15)
  BOTTOM w0.076: UC1.U4 156.73,84.15 v2(156.81,84.15)
  BOTTOM w0.127: v2(158.25,44.35) 156.77,42.87 JDIMM1.204
DDR_M0_D48: length 49.4
  IN3 w0.076: 164.47,73.22 164.47,73.54 163.65,74.36 163.65,75.64 160.94,78.36 160.94,78.85 160.36,79.43 160.36,79.67 159.53,80.51 159.31,80.51 v2(159.16,80.36)
  IN3 w0.127: v2(160.39,46.68) 160.65,46.42 160.88,46.42 160.94,46.48 160.94,48.38 160.81,48.51 160.81,48.82 160.94,48.95 160.94,49.11 160.81,49.24 160.5,49.24 160.37,49.37 160.37,49.62 160.5,49.75 160.85,49.75 160.99,49.88 160.99,50.14 160.87,50.26 160.5,50.26 160.37,50.39 160.37,50.64 160.49,50.77 160.81,50.77 160.94,50.89 160.94,51.19 161.24,51.49 161.24,52.38 164.47,55.61 164.47,73.22
  BOTTOM w0.076: UC1.R2 157.91,82.89 157.91,82.09 158.1,81.89 158.21,81.89 159.07,81.03 159.07,80.46 159.16,80.38 v2(159.16,80.36)
  BOTTOM w0.127: v2(160.39,46.68) 160.92,46.14 160.92,44.02 159.77,42.87 JDIMM1.216
DDR_M0_D49: length 50.1
  IN3 w0.076: v2(158.32,81.2) 158.35,81.23 159.04,81.23 161.27,79 161.27,78.44 164.11,75.6 164.11,74.37 164.85,73.63 164.85,73.37
  IN3 w0.127: 164.85,73.37 164.85,55.45 161.67,52.27 161.67,51.31 161.37,51.01 161.37,45.72 160.82,45.17 v2(160.39,45.17)
  BOTTOM w0.076: UC1.P5 158.8,85.12 158.46,84.78 158.08,84.78 157.74,84.44 157.74,82.02 158.36,81.4 158.36,81.24 v2(158.32,81.2)
  BOTTOM w0.127: JDIMM1.212 158.77,42.77 160.36,44.35 160.36,45.14 v2(160.39,45.17)
DDR_M0_D50: length 51
  IN3 w0.076: 166.7,74.61 166.21,75.09 166.21,75.81 160.39,81.63 159.22,81.63 158.45,82.4 158.45,84.01 159.19,84.75 v2(159.37,84.75)
  IN3 w0.127: 166.7,74.61 167.02,74.28 167.02,71.21 167.4,70.83 167.4,70.42 167.27,70.3 167.15,70.3 167.02,70.17 167.02,69.92 167.15,69.79 167.27,69.79 167.4,69.66 167.4,69.41 167.27,69.28 167.15,69.28 167.06,69.19 167.02,69.15 167.02,68.9 167.15,68.77 167.27,68.77 167.4,68.65 167.4,68.39 167.27,68.26 167.15,68.26 167.02,68.14 167.02,67.88 167.15,67.76 167.27,67.76 167.4,67.63 167.4,67.38 167.27,67.25 167.15,67.25 167.02,67.12 167.02,66.87 167.15,66.74 167.27,66.74 167.4,66.61 167.4,66.36 167.27,66.23 167.15,66.23 167.02,66.11 167.02,65.85 167.15,65.72 167.27,65.72 167.4,65.6 167.4,65.34 167.27,65.22 167.15,65.22 167.02,65.09 167.02,64.84 167.15,64.71 167.27,64.71 167.4,64.58 167.4,64.33 167.27,64.2 167.15,64.2 167.02,64.07 167.02,63.82 167.15,63.69 167.27,63.69 167.4,63.57 167.4,63.31 167.27,63.18 167.15,63.18 167.02,63.06 167.02,62.8 167.15,62.68 167.27,62.68 167.4,62.55 167.4,62.3 167.27,62.17 167.15,62.17 167.02,62.04 167.02,61.79 167.15,61.66 167.27,61.66 167.4,61.53 167.4,61.28 167.27,61.15 167.15,61.15 167.02,61.03 167.02,60.77 167.15,60.64 167.27,60.64 167.4,60.52 167.4,60.26 167.27,60.14 167.15,60.14 167.02,60.01 167.02,54.55 165.51,53.05 v2(165.51,52.98)
  BOTTOM w0.076: UC1.R4 158.46,84.47 158.79,84.8 159.32,84.8 v2(159.37,84.75)
  BOTTOM w0.127: v2(165.51,52.98) 163.58,52.98 162.02,51.41 159.9,51.41 159.52,51.03 JDIMM1.215
DDR_M0_D51: length 50
  IN3 w0.076: 167.03,75.39 166.74,75.68 166.74,76.16 160.37,82.52 159.21,82.52 158.89,82.84 158.89,83.65 v2(159.38,84.14)
  IN3 w0.127: 167.03,75.39 167.78,74.64 167.78,71.52 168.64,70.67 168.64,61.06 168.16,60.58 168.16,54.4 166.29,52.53 166.29,51.43 165.01,50.15 164.54,50.15 164.41,50.28 164.41,50.77 164.22,50.96 164.02,50.96 163.9,50.83 163.9,50.2 163.64,49.95 163.64,49.13 163.7,49.08 163.97,49.08 164.1,48.95 164.1,48.06 163.97,47.93 v2(163.69,47.93)
  BOTTOM w0.076: v2(159.38,84.14) 159.05,84.47 UC1.P4
  BOTTOM w0.127: v2(163.69,47.93) 162.87,47.93 162.66,48.14 162.66,48.78 162.02,49.41 JDIMM1.225
DDR_M0_D52: length 52.2
  IN3 w0.076: 164.08,73.13 164.08,73.46 163.3,74.24 163.3,75.62 160.66,78.26 160.66,78.56 160.01,79.21 v2(160.01,79.51)
  IN3 w0.127: v2(160.39,47.86) 160.13,47.6 159.69,47.6 159.61,47.69 159.61,48.61 159.99,48.99 159.99,50.89 160.86,51.76 160.86,52.54 164.08,55.77 164.08,73.13
  BOTTOM w0.076: UC1.R5 157.58,84.51 157.58,81.95 157.7,81.83 157.7,81.22
  BOTTOM w0.127: v2(160.39,47.86) 159.74,47.86 159.52,47.63 159.52,47.04 159.39,46.92 159.17,46.92 159.01,47.08 159.01,48.73 158.52,49.21 JDIMM1.211 ; 157.7,81.22 157.7,81.09 158.86,79.93 158.86,78.09 159.04,77.91 159.49,77.91 159.68,78.1 159.68,79.18 v2(160.01,79.51)
DDR_M0_D53: length 48.6
  IN3 w0.076: 167.29,75.75 167.09,75.94 167.09,76.16 160.34,82.9 v2(159.35,82.9)
  IN3 w0.127: 167.29,75.75 168.16,74.87 168.16,71.68 169.02,70.83 169.02,60.9 168.54,60.42 168.54,54.17 166.72,52.35 166.72,51.33 164.48,49.09 164.48,45.55 164.05,43.95 v2(163.68,43.58)
  BOTTOM w0.076: UC1.P2 159.19,82.9 v2(159.35,82.9)
  BOTTOM w0.127: v2(163.68,43.58) 163.48,43.58 162.77,42.88 JDIMM1.228
DDR_M0_D54: length 49.2
  IN3 w0.076: v2(161.89,78.32) 162.76,77.46 164.45,75.77 164.45,74.49 165.23,73.71 165.23,73.42
  IN3 w0.127: v2(163.68,44.8) 163.52,44.97 162.91,44.97 162.61,44.67 162.61,44.23 162.42,44.04 161.98,44.04 161.8,44.22 161.8,50.83 162.1,51.13 162.1,52.17 165.23,55.29 165.23,73.42
  BOTTOM w0.076: 160.33,79.88 160.16,79.88 159.24,80.8 159.24,81.09 158.19,82.15 UC1.R1
  BOTTOM w0.127: 160.33,79.88 v2(161.89,78.32) ; JDIMM1.224 161.77,43.35 163.2,44.78 163.66,44.78 v2(163.68,44.8)
DDR_M0_D55: length 48.3
  IN3 w0.076: v2(159.36,82.14) 160.34,82.14 166.5,75.98 166.5,75.38 166.84,75.04
  IN3 w0.127: v2(164.9,52.22) 164.75,52.22 164.51,51.98 164.51,51.28 164.82,50.97 164.99,50.97 165.38,51.35 165.38,52.24 167.78,54.63 167.78,60.74 168.12,61.08 168.12,61.3 168.03,61.39 167.91,61.39 167.78,61.52 167.78,61.78 167.91,61.9 168.13,61.9 168.25,62.03 168.25,62.28 168.13,62.41 167.91,62.41 167.78,62.54 167.78,62.79 167.91,62.92 168.13,62.92 168.25,63.05 168.25,63.3 168.13,63.43 167.91,63.43 167.78,63.55 167.78,63.81 167.91,63.93 168.13,63.93 168.25,64.06 168.25,64.32 168.13,64.44 167.91,64.44 167.78,64.57 167.78,64.82 167.91,64.95 168.13,64.95 168.25,65.08 168.25,65.33 168.13,65.46 167.91,65.46 167.78,65.59 167.78,65.84 167.91,65.97 168.13,65.97 168.25,66.09 168.25,66.35 168.13,66.47 167.91,66.47 167.78,66.6 167.78,66.86 167.91,66.98 168.13,66.98 168.25,67.11 168.25,67.36 168.13,67.49 167.91,67.49 167.78,67.62 167.78,67.87 167.91,68 168.13,68 168.19,68.06 168.25,68.13 168.25,68.38 168.13,68.51 167.91,68.51 167.78,68.63 167.78,68.89 167.91,69.01 168.13,69.01 168.25,69.14 168.25,69.4 168.13,69.52 167.91,69.52 167.78,69.65 167.78,69.9 167.91,70.03 168.13,70.03 168.25,70.16 168.25,70.51 168.1,70.66 167.91,70.66 167.8,70.77 167.8,70.97 167.4,71.36 167.4,74.48 166.84,75.04
  BOTTOM w0.076: v2(159.36,82.14) 159.31,82.14 UC1.P1
  BOTTOM w0.127: v2(164.9,52.22) 164.55,51.87 163.57,51.87 163.02,51.32 JDIMM1.229
DDR_M0_D56: length 54.3
  IN3 w0.076: 165.41,79.91 164.9,80.41 163.52,80.41 160.59,83.34 160.59,83.79 v2(160.28,84.11)
  IN3 w0.127: v2(165.87,46.25) 165.87,46.37 166.68,47.19 166.68,49.67 166.79,49.78 166.97,49.78 167.29,49.45 167.44,49.45 167.62,49.63 167.62,49.84 167.33,50.14 167.33,50.32 167.5,50.5 167.68,50.5 168.01,50.17 168.16,50.17 168.34,50.35 168.34,50.56 168.04,50.85 168.04,51.03 168.42,51.41 168.42,52.29 168.53,52.4 169.44,52.4 169.63,52.59 169.63,52.86 170.71,53.93 170.71,59.39 170.56,59.54 170.28,59.54 170.16,59.66 170.16,60.02 170.29,60.15 170.58,60.15 170.71,60.28 170.71,60.53 170.58,60.66 170.29,60.66 170.16,60.79 170.16,71.3 169.3,72.15 169.3,75.42 165.41,79.32 165.41,79.91
  BOTTOM w0.089: v2(160.28,84.11) UC1.M4
  BOTTOM w0.127: JDIMM1.232 163.77,42.79 164.11,43.13 164.11,44.5 v2(165.87,46.25)
