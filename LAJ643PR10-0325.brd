# Allegro board LAJ643PR10-0325.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCIE_PTX_DRX_N12: length 216.4
  TOP w0.127: v2(124.18,6.79) 124.3,6.79 124.48,6.61 124.48,6.46 124.28,6.26 123.18,6.26 123.04,6.4 122.63,6.4 122.49,6.26 122.09,6.26 121.94,6.4 121.54,6.4 121.39,6.26 102.09,6.26 98.96,9.38 98.96,13.72 95.65,17.03 87.6,17.03 83.03,21.61 75.47,21.61 69.94,16.08 66.58,16.08 62.76,12.26 61.67,12.26 58.99,9.59 53.3,9.59 52.65,10.24 47.48,10.24 46.92,9.68 46.56,9.68 41.64,4.75 37.48,4.75 37.05,5.18 36.14,5.18 34.9,3.94 25.3,3.94 24.19,5.05 24.19,6.07 24.25,6.14 24.52,6.14 C375.1
  IN1 w0.135: v2(194.83,38.32) 194.77,38.26 193.81,38.26 193.35,37.81 193.35,37.3 191.72,35.66 191.72,29.63 190.13,28.04 190.13,26.23 187.8,23.9 187.8,20.72 187.44,20.36 187.44,19.45 187.76,19.13 187.76,18.36 187.34,17.94 187.34,17.52 185.6,15.78 185.6,15.5 185.07,14.97 179.69,14.97 177.07,12.36 175.66,12.36 174.42,11.11 169.91,11.11 168.52,12.5 155.99,12.5 152.16,8.67 140.7,8.67 139.91,7.87 136.04,7.87 135.24,7.07 130.4,7.07 129.87,7.6 124.7,7.6 124.42,7.32 124.42,7.03 v2(124.18,6.79)
  BOTTOM w0.089: v2(194.83,38.32) 194.9,38.24 195.27,38.24 195.33,38.3 195.33,38.31 195.44,38.42 195.92,38.42 196.29,38.78 UH1.D38
PCIE_PTX_DRX_N14: length 5.8
  BOTTOM w0.089: UH1.C39 195.74,39.06 195.8,39 195.9,39 195.97,39.07 195.97,39.44 195.79,39.62 195.79,40.11 195.38,40.52 195.38,40.94 195.11,41.21 195.11,41.61 195.14,41.65 195.14,41.67
  BOTTOM w0.127: CH76.2 194.52,43.16 194.52,42.76 v4(194.8,42.49) 195.14,42.14 195.14,41.67
PCIE_PTX_DRX_N15: length 5.7
  BOTTOM w0.089: 194.44,41.5 194.45,41.49 194.45,41.44 194.67,41.22 194.67,41.1 195.01,40.76 195.01,40.13 195.15,39.99 195.15,39.62 195.2,39.58 195.25,39.58 UH1.B40
  BOTTOM w0.127: 194.44,41.5 192.68,43.27 192.68,43.48 192.8,43.6 CH78.2
PCIE_PTX_DRX_N16: length 7.5
  BOTTOM w0.089: UH1.B41 194.72,39.62 194.67,39.58 194.53,39.58 194.47,39.64 194.47,40.02 194.64,40.19 194.64,40.6 194.26,40.99 193.76,40.99 193.73,41.02 193.71,41.02
  BOTTOM w0.127: CH60.2 190.83,43.59 190.76,43.52 190.76,42.84 192.59,41.02 193.71,41.02
PCIE_PTX_DRX_P9: length 203.2
  TOP w0.127: C370.1 35.67,7.34 37.69,7.34 38.43,6.59 40.85,6.59 45.79,11.53 46.11,11.53 46.79,12.22 53.24,12.22 54.05,11.4 58.23,11.4 60.9,14.07 61.55,14.07 65.85,18.37 69.4,18.37 74.63,23.6 84.17,23.6 88.76,19.01 96.33,19.01 100.8,14.54 100.8,13.68 102.39,12.09 103.94,12.09 106.03,10 111.14,10 112.9,8.24 115.76,8.24 116.03,8.52 116.03,8.72 v2(116.4,9.08)
  IN1 w0.135: v2(196.14,43.42) 196.14,43.49 196.04,43.6 194.97,43.6 194.13,42.76 191.1,42.76 186.83,38.49 186.83,35.74 186.45,35.35 186.45,34.26 186.91,33.81 186.91,31.21 180.7,25 180.7,23.92 177.09,20.31 176.61,20.31 173.54,17.25 172.81,17.25 172.09,16.53 154.19,16.53 152.31,14.64 151.08,14.64 150.92,14.49 143.47,14.49 142.5,13.52 139.85,13.52 138.39,12.06 125.17,12.06 124.75,11.63 121.1,11.63 119.81,10.34 116.84,10.34 115.9,9.4 115.9,9.22 116.03,9.08 v2(116.4,9.08)
  BOTTOM w0.089: UH1.D34 197.69,39.03 197.69,39.34 197.88,39.53 197.88,42.32 196.64,43.57 196.29,43.57 v2(196.14,43.42)
PCIE_PTX_DRX_P10: length 209.9
  TOP w0.127: v2(118.66,9.07) 118.73,9.07 119.02,9.36 119.02,9.47 118.89,9.6 118.01,9.6 117.66,9.25 117.66,8.7 116.51,7.55 102.56,7.55 100.08,10.02 100.08,14.22 96,18.3 88.22,18.3 83.61,22.91 75.07,22.91 69.78,17.61 66.27,17.61 62.04,13.38 61.2,13.38 58.53,10.71 53.77,10.71 52.98,11.5 47.1,11.5 46.43,10.83 46.06,10.83 41.11,5.87 38.16,5.87 37.72,6.31 35.67,6.31 34.49,5.13 30.25,5.13 29.99,5.39 29.99,5.68 C372.1
  IN1 w0.135: v2(196.12,42.83) 196.02,42.73 195.03,42.73 194.36,42.06 191.02,42.06 187.35,38.38 187.35,31.01 181.55,25.21 181.55,24.05 177.37,19.87 176.79,19.87 173.73,16.81 172.99,16.81 172.27,16.09 154.37,16.09 152.49,14.2 151.48,14.2 150.63,13.35 142.96,13.35 142.69,13.08 140.03,13.08 138.57,11.62 125.36,11.62 124.93,11.19 121.28,11.19 119.99,9.9 119.23,9.9 118.83,9.5 118.83,9.24 v2(118.66,9.07)
  BOTTOM w0.089: v2(196.12,42.83) 196.05,42.75 196.05,42.67 196.1,42.61 196.97,42.61 197.67,41.91 197.67,40.1 197.53,39.96 197.53,39.75 UH1.B35
PCIE_PTX_DRX_P11: length 211.6
  TOP w0.127: v2(121.25,9.07) 121.09,8.91 121.09,8.48 119.32,6.72 102.42,6.72 99.39,9.74 99.39,13.9 95.71,17.59 87.8,17.59 83.22,22.16 75.34,22.16 69.78,16.61 66.28,16.61 62.36,12.69 61.49,12.69 58.81,10.02 53.48,10.02 52.71,10.79 47.4,10.79 46.73,10.13 46.34,10.13 41.39,5.18 37.76,5.18 37.32,5.62 35.96,5.62 34.73,4.39 27.58,4.39 26.93,5.05 26.93,5.64 C374.1
  IN1 w0.135: v2(196.17,41.07) 195.99,41.07 195.88,41.18 195.88,41.29 195.8,41.37 195.58,41.37 194.87,40.66 191.66,40.66 189.5,38.51 189.03,38.51 188.37,37.84 188.37,29.95 186.92,28.5 186.25,28.5 185.1,27.34 185.1,26.5 183.81,25.21 183.43,25.21 182.63,24.41 182.63,23.62 177.89,18.87 177.21,18.87 174.14,15.81 173.4,15.81 172.69,15.09 154.89,15.09 153,13.21 152.09,13.21 151.24,12.36 143.37,12.36 143.1,12.08 140.44,12.08 138.98,10.62 125.77,10.62 125.34,10.2 121.7,10.2 121.25,9.75 v2(121.25,9.07)
  BOTTOM w0.089: UH1.C36 196.67,39.53 196.67,39.93 196.83,40.1 196.83,40.26 196.9,40.33 196.9,40.33 197,40.43 197.11,40.54 197.11,41.05 196.86,41.3 196.4,41.3 v2(196.17,41.07)
PCIE_PTX_DRX_P12: length 216.3
  TOP w0.127: C376.1 23.93,5.77 23.93,4.95 25.19,3.69 35.01,3.69 36.25,4.93 36.95,4.93 37.38,4.49 41.75,4.49 46.67,9.42 47.03,9.42 47.59,9.98 52.54,9.98 53.2,9.33 59.1,9.33 61.77,12 62.87,12 66.68,15.82 70.04,15.82 75.57,21.35 82.92,21.35 87.49,16.78 95.55,16.78 98.71,13.62 98.71,9.28 101.98,6 124.39,6 124.74,6.35 124.74,6.64 v2(124.89,6.79)
  IN1 w0.135: v2(124.89,6.79) 124.69,6.99 124.69,7.2 124.81,7.32 129.75,7.32 130.28,6.79 135.36,6.79 136.16,7.59 140.02,7.59 140.82,8.39 152.27,8.39 156.1,12.22 168.41,12.22 169.79,10.83 174.53,10.83 175.78,12.08 177.19,12.08 179.81,14.69 185.19,14.69 185.88,15.39 185.88,15.66 187.62,17.41 187.62,17.83 188.04,18.25 188.04,19.25 187.72,19.57 187.72,20.24 188.08,20.6 188.08,23.79 190.41,26.12 190.41,27.92 192,29.51 192,35.55 193.63,37.18 193.63,37.69 193.92,37.98 194.36,37.98 194.53,37.81 194.53,37.67 194.65,37.55 194.85,37.55 v2(195.02,37.72)
  BOTTOM w0.089: v2(195.02,37.72) 195.02,37.79 195.28,38.05 195.35,38.05 195.52,38.22 196,38.22 196.23,38.46 UH1.E37
PCIE_PTX_DRX_P14: length 5.7
  BOTTOM w0.089: UH1.D39 195.52,39.01 195.52,39.39 195.6,39.47 195.6,40.04 195.19,40.44 195.19,40.86 194.92,41.13 194.92,41.61 194.89,41.65 194.89,41.67
  BOTTOM w0.127: CH75.2 194.27,43.38 194.27,42.66 194.89,42.04 194.89,41.67
PCIE_PTX_DRX_P15: length 5.7
  BOTTOM w0.089: 194.26,41.32 194.3,41.32 194.48,41.14 194.48,41.02 194.82,40.68 194.82,40.05 194.96,39.92 194.96,39.42 UH1.C40
  BOTTOM w0.127: CH77.2 192.42,43.37 192.42,43.16 194.26,41.32
PCIE_PTX_DRX_P16: length 7.4
  BOTTOM w0.089: 193.71,40.76 193.73,40.76 193.76,40.8 194.18,40.8 194.45,40.52 194.45,40.27 194.28,40.09 194.28,39.57 194.46,39.38 194.62,39.38 UH1.C41
  BOTTOM w0.127: 193.71,40.76 192.48,40.76 190.51,42.74 190.51,43.36 CH61.2
PCIE_RCOMPN: length 5.4
  BOTTOM w0.203: UH1.B12 208.77,40.08 208.92,40.23 208.92,40.62 208.68,40.85 208.54,40.85
  BOTTOM w0.305: 208.54,40.85 208.19,41.21 208.19,42.74 207.75,43.18 206.51,43.18 RH21.1
PCIE_RCOMPP: length 5.4
  BOTTOM w0.305: UH1.A13 208.42,40.41 207.67,41.17 207.67,42.55 207.52,42.7 v1(207.45,42.7) 207.16,42.7 207,42.54 207,41.91 206.81,41.73 206.52,41.73 206.33,41.92 RH21.2
PD_EE_CLK: length 35
  TOP w0.127: RU62.2 53.61,46.11 54.1,46.59 54.73,46.59 CU68.1 54.88,47.38 v2(54.89,47.39) ; v2(59.3,31.45) 59.3,30.61 v1(59.54,30.36)
  IN3 w0.127: v2(54.89,47.39) 54.89,46.09 56.29,44.69 62.27,44.69 63.08,43.87 63.08,40.63 62.54,40.09 62.54,33.71 62.26,33.42 61.19,33.42 59.3,31.53 v2(59.3,31.45)
  BOTTOM w0.127: UU5.6 61.44,27.14 61.23,27.35 61.23,28.01 60.35,28.9 60.35,30.4 v2(59.3,31.45)
PD_EE_CLK_R: length 2.7
  TOP w0.127: RU62.1 52.49,45.23 52.16,45.23 51.71,44.78 v1(51.57,44.78) 51.25,44.46 UU4.38
PD_EE_CS_N: length 33.3
  TOP w0.127: UU4.39 51.05,44.86 51.49,45.3 51.75,45.3 52.36,45.91 52.82,45.91 v2(52.98,46.07) ; v1(57.55,32.29) 58.01,31.83 v2(58.01,31.61)
  IN3 w0.127: v2(52.98,46.07) 52.98,46.03 53.52,45.49 54.64,45.49 56.41,43.72 56.41,42.59 56.69,42.31 56.69,37.08 57.89,35.88 57.89,31.73 v2(58.01,31.61)
  BOTTOM w0.127: RU70.2 55.86,25.91 55.86,25.19 56.45,24.6 UU5.1 57.93,24.6 58.11,24.78 58.11,25.7 59.18,26.76 59.18,28.31 58.38,29.11 58.38,30.42 58.01,30.78 v2(58.01,31.61)
PD_EE_DI: length 36.5
  TOP w0.127: v2(59.92,31.56) 60.21,31.56 v1(60.49,31.28) ; v2(55.54,46.96) 55.57,46.94 55.57,45.59 55.26,45.28 54.46,45.28 54.14,44.97 52.27,44.97 51.36,44.06 UU4.37
  IN3 w0.127: v2(55.54,46.96) 55.54,45.86 56.45,44.96 62.39,44.96 63.35,43.99 63.35,40.52 62.81,39.98 62.81,33.59 62.37,33.15 61.51,33.15 v2(59.92,31.56)
  BOTTOM w0.127: v2(59.92,31.56) 60.61,30.87 60.61,29 61.2,28.41 UU5.5
PD_EE_DO: length 47.3
  TOP w0.127: UU4.36 51.33,43.66 52.37,44.7 54.25,44.7 54.57,45.02 55.39,45.02 55.94,45.57 v1(55.94,46) 56.13,46.19 v2(56.13,46.95)
  IN3 w0.127: v2(63.1,32.16) 63.08,32.18 63.08,39.87 63.62,40.41 63.62,44.1 62.5,45.22 56.56,45.22 56.13,45.66 v2(56.13,46.95)
  BOTTOM w0.127: v2(63.1,32.16) 63.1,32.72 62.31,33.51 58.64,33.51 57.59,32.47 57.59,30.79 58.12,30.27 58.12,29 58.91,28.2 58.91,26.87 57.91,25.87 UU5.2 56.71,25.87 RU69.2
PD_EE_WP_N: length 3.5
  BOTTOM w0.127: v1(55.05,29.36) RU68.2 55.22,28.32 56.4,27.14 UU5.3
PD_HOLD_N: length 5.1
  BOTTOM w0.127: UU5.7 61.48,25.87 60.76,26.59 v2(60.76,27.48) 60.76,28.1 59.75,29.12 RU71.2
PDB: length 7.1
  TOP w0.135: UA1.2 293.22,17.75 v1(292.58,17.11) 291.98,16.51 CA94.2 291.98,15.69 RA15.1 291.93,15.06 RA26.2 291.98,14.7 292.51,14.17 DA3.2 292.51,13.87 QA2.1
PEDET: length 5.6
  TOP w0.127: v2(19.11,8.16) 19.52,7.76 Q79.2 19.04,7.28 18.9,7.42 EC11.1 18.08,7.42 17.93,7.26 R5220.2 v1(16.32,7.26)
  BOTTOM w0.127: JSSD1.61 18.85,8.43 v2(19.11,8.16)
PEG_CRX_C_GTX_N0: length 18.9
  TOP w0.076: 192.57,85.07 192.58,85.07 192.62,85.11 193.64,85.11 194.12,85.6 196.21,85.6 196.6,85.98 v2(196.66,85.98)
  TOP w0.127: CG532.2 179.32,85.07 187.76,85.07 187.96,85.28 190.37,85.28 190.57,85.07 192.57,85.07
  BOTTOM w0.076: UG1.AJ14 196.66,86.31 v2(196.66,85.98)
PEG_CRX_C_GTX_N1: length 22.5
  TOP w0.076: v2(197.68,86.14) 197.37,86.46 194.83,86.46 194.63,86.66 193.88,86.66 193.46,86.24 192.56,86.24 192.51,86.19 192.49,86.19
  TOP w0.127: 192.49,86.19 176.57,86.19 CG534.2
  BOTTOM w0.076: UG1.AG14 v2(197.68,86.14)
PEG_CRX_C_GTX_N2: length 17.8
  TOP w0.076: 192.37,87.56 192.38,87.56 192.37,87.55 192.43,87.5 193.73,87.5 193.79,87.44 195.74,87.44 v2(196.02,87.72)
  TOP w0.127: CG536.2 179.35,87.56 192.37,87.56
  BOTTOM w0.076: UG1.AJ15 v2(196.02,87.72)
PEG_CRX_C_GTX_N3: length 20
  TOP w0.076: 192.36,88.37 192.4,88.42 192.88,88.42 193.17,88.13 195.11,88.13 195.2,88.04 v2(195.2,87.81)
  TOP w0.127: 192.36,88.37 176.6,88.37 CG538.2
  BOTTOM w0.076: UG1.AK16 v2(195.2,87.81)
PEG_CRX_C_GTX_N4: length 19
  TOP w0.076: 192.39,89.67 192.41,89.67 192.46,89.62 192.83,89.62 193.25,89.2 196.39,89.2 196.58,89.02 196.58,88.89 v2(196.83,88.64)
  TOP w0.127: 192.39,89.67 179.39,89.67 CG540.2
  BOTTOM w0.076: UG1.AJ17 v2(196.83,88.64)
PEG_CRX_C_GTX_N5: length 23.1
  TOP w0.076: v2(197.67,88.63) 197.67,88.86 197.57,88.96 197.51,88.96 197.37,88.96 196.82,89.51 193.45,89.51 192.66,90.29 192.41,90.29 192.36,90.24 192.35,90.24 192.35,90.24
  TOP w0.127: 192.35,90.24 183.57,90.24 183.29,90.52 176.58,90.52 CG542.2
  BOTTOM w0.076: UG1.AG17 v2(197.67,88.63)
PEG_CRX_C_GTX_N6: length 19.5
  TOP w0.076: 192.26,91.29 192.28,91.29 192.33,91.23 192.77,91.23 193.76,90.24 195.41,90.24 195.41,90.24 195.81,90.65 196.17,90.65 196.57,90.26 v2(196.85,90.26)
  TOP w0.127: CG544.2 179.37,91.86 183.51,91.86 184.08,91.29 192.26,91.29
  BOTTOM w0.076: UG1.AJ18 v2(196.85,90.26)
PEG_CRX_C_GTX_N7: length 21.6
  TOP w0.076: v2(196,91.11) 195.96,91.11 195.38,90.52 194,90.52 192.63,91.89 192.33,91.89 192.28,91.84 192.26,91.84
  TOP w0.127: 192.26,91.84 184.49,91.84 183.67,92.67 176.57,92.67 CG546.2
  BOTTOM w0.076: UG1.AK19 v2(196,91.11)
PEG_CRX_C_GTX_P0: length 18.9
  TOP w0.076: 192.57,85.33 192.58,85.33 192.57,85.32 192.63,85.26 193.58,85.26 194.06,85.75 196.05,85.75 196.12,85.82 196.12,85.93 v2(196.06,85.99)
  TOP w0.127: 192.57,85.33 190.68,85.33 190.48,85.53 187.85,85.53 187.65,85.33 179.19,85.33 179.05,85.47 CG531.2
  BOTTOM w0.076: v2(196.06,85.99) 196.06,86.37 195.89,86.54 UG1.AK14
PEG_CRX_C_GTX_P1: length 22.5
  TOP w0.076: v2(197.67,86.93) 197.36,86.62 194.89,86.62 194.7,86.81 193.82,86.81 193.4,86.4 192.55,86.4 192.5,86.44 192.51,86.45 192.49,86.45
  TOP w0.127: 192.49,86.45 176.57,86.45 CG533.2
  BOTTOM w0.076: UG1.AH14 v2(197.67,86.93)
PEG_CRX_C_GTX_P2: length 17.8
  TOP w0.076: v2(196.02,87.02) 196.02,87.08 195.81,87.29 193.73,87.29 193.67,87.35 192.42,87.35 192.38,87.3 192.37,87.3
  TOP w0.127: CG535.2 179.39,87.3 192.37,87.3
  BOTTOM w0.076: UG1.AK15 v2(196.02,87.02)
PEG_CRX_C_GTX_P3: length 20
  TOP w0.076: 192.37,88.63 192.39,88.63 192.38,88.62 192.43,88.57 192.94,88.57 193.23,88.28 195.05,88.28 195.19,88.42 v2(195.19,88.6)
  TOP w0.127: CG537.2 176.55,88.63 192.37,88.63
  BOTTOM w0.076: UG1.AL16 v2(195.19,88.6)
PEG_CRX_C_GTX_P4: length 19
  TOP w0.076: v2(195.98,88.64) 196.32,88.64 196.43,88.75 196.43,88.95 196.33,89.05 193.19,89.05 192.77,89.47 192.46,89.47 192.41,89.42 192.4,89.42 192.4,89.42
  TOP w0.127: CG539.2 179.34,89.42 192.4,89.42
  BOTTOM w0.076: v2(195.98,88.64) 195.73,88.89 UG1.AK17
PEG_CRX_C_GTX_P5: length 23.1
  TOP w0.076: 192.34,90.5 192.36,90.5 192.41,90.45 192.73,90.45 193.51,89.66 196.88,89.66 197.43,89.11 197.51,89.11 197.6,89.11 197.67,89.19 v2(197.67,89.43)
  TOP w0.127: 192.34,90.5 183.68,90.5 183.4,90.78 176.56,90.78 CG541.2
  BOTTOM w0.076: UG1.AH17 v2(197.67,89.43)
PEG_CRX_C_GTX_P6: length 19.5
  TOP w0.076: 192.28,91.03 192.33,91.08 192.7,91.08 193.69,90.09 195.52,90.09 195.73,89.88 196.21,89.88 196.38,90.06 196.38,90.22 196.27,90.34 196.08,90.34 v2(196,90.26)
  TOP w0.127: CG543.2 179.36,91.6 183.4,91.6 183.97,91.03 192.28,91.03
  BOTTOM w0.076: UG1.AK18 v2(196,90.26)
PEG_CRX_C_GTX_P7: length 21.6
  TOP w0.076: 192.26,92.1 192.28,92.1 192.33,92.05 192.69,92.05 194.06,90.68 195.32,90.68 195.6,90.96 195.6,91.05 195.54,91.11 v2(195.2,91.11)
  TOP w0.127: 192.26,92.1 184.6,92.1 183.77,92.92 176.57,92.92 CG545.2
  BOTTOM w0.076: UG1.AL19 v2(195.2,91.11)
PEG_CRX_GTX_N0: length 15.3
  TOP w0.076: 169.27,87.21 169.26,87.21 169.21,87.27 167.65,87.27 167.19,87.73 166.59,87.73 166.29,88.03 166.1,88.03 166.02,87.96 166.02,87.73 165.94,87.65 165.5,87.65 165.43,87.73 165.43,87.84 v2(165.62,88.03)
  TOP w0.127: 169.27,87.21 169.63,87.21 169.69,87.28 171.86,87.28 174.01,85.13 177.82,85.13 CG532.1
  BOTTOM w0.076: UC1.E10 v2(165.62,88.03)
PEG_CRX_GTX_N1: length 11.6
  TOP w0.076: 169.45,87.99 169.43,87.99 169.38,88.04 169,88.04 168.81,87.85 167.86,87.85 167.48,88.24 166.7,88.24 166.52,88.42 166.02,88.42 v2(165.62,88.82)
  TOP w0.127: CG534.1 175.11,86.11 174.37,86.11 172.48,87.99 169.45,87.99
  BOTTOM w0.076: UC1.E11 v2(165.62,88.82)
PEG_CRX_GTX_N2: length 15.7
  TOP w0.076: v2(164.97,89.61) 164.76,89.61 164.69,89.54 164.69,89.29 164.8,89.18 165.15,89.18 165.44,89.46 167.39,89.46 167.85,89 169.36,89 169.4,89.04
  TOP w0.127: CG536.1 178.14,87.71 177.95,87.52 174.4,87.52 172.89,89.04 169.4,89.04
  BOTTOM w0.076: UC1.E12 v2(164.97,89.61)
PEG_CRX_GTX_N3: length 11.4
  TOP w0.076: 169.42,89.55 169.4,89.55 169.35,89.61 168.96,89.61 168.79,89.43 168,89.43 167.62,89.81 166.04,89.81 165.84,90.01 165.84,90.18 v2(165.62,90.4)
  TOP w0.127: CG538.1 175.05,88.33 174.46,88.33 173.23,89.55 169.42,89.55
  BOTTOM w0.076: UC1.E13 v2(165.62,90.4)
PEG_CRX_GTX_N4: length 14.5
  TOP w0.076: 169.29,90.62 169.25,90.57 167.8,90.57 167.42,90.96 165.61,90.96 165.56,91.01 165.56,91.12 v2(165.62,91.18)
  TOP w0.127: CG540.1 178.14,89.7 178.05,89.61 177.06,89.61 176.96,89.71 174.52,89.71 173.61,90.62 169.29,90.62
  BOTTOM w0.076: UC1.E14 165.38,91.63 165.51,91.63 165.67,91.46 165.67,91.23 v2(165.62,91.18)
PEG_CRX_GTX_N5: length 11.2
  TOP w0.076: 169.32,91.12 169.31,91.12 169.25,91.18 169.04,91.18 168.84,90.98 168,90.98 167.6,91.39 166.04,91.39 165.84,91.58 165.84,91.75 v2(165.62,91.97)
  TOP w0.127: 169.32,91.12 173.94,91.12 174.63,90.43 175.11,90.43 CG542.1
  BOTTOM w0.076: UC1.E15 v2(165.62,91.97)
PEG_CRX_GTX_N6: length 14.3
  TOP w0.076: v2(165.62,92.76) 165.53,92.66 165.53,92.58 165.62,92.49 167.49,92.49 167.84,92.15 169.25,92.15 169.29,92.19 169.32,92.19
  TOP w0.127: 169.32,92.19 174.42,92.19 174.75,91.86 176.87,91.86 176.93,91.79 178.06,91.79 178.14,91.87 CG544.1
  BOTTOM w0.076: v2(165.62,92.76) 165.53,92.67 165.44,92.67 165.35,92.76 165.35,92.87 165.31,92.91 UC1.E16
PEG_CRX_GTX_N7: length 10.9
  TOP w0.076: 169.34,92.67 169.32,92.67 169.27,92.72 168.9,92.72 168.74,92.56 168.06,92.56 167.66,92.96 166.04,92.96 165.84,93.16 165.84,93.33 v2(165.62,93.55)
  TOP w0.127: CG546.1 175.02,92.67 169.34,92.67
  BOTTOM w0.076: UC1.E17 v2(165.62,93.55)
PEG_CRX_GTX_P0: length 15.3
  TOP w0.076: 169.27,87.47 169.27,87.47 169.22,87.42 167.71,87.42 167.25,87.88 166.65,87.88 166.35,88.19 165.99,88.19 165.77,88.42 165.35,88.42 v2(164.97,88.03)
  TOP w0.127: CG531.1 177.82,85.38 174.11,85.38 172.96,86.54 171.96,87.53 169.59,87.53 169.53,87.47 169.27,87.47
  BOTTOM w0.076: UC1.F10 v2(164.97,88.03)
PEG_CRX_GTX_P1: length 11.6
  TOP w0.076: v2(166.27,88.82) 166.27,88.63 166.33,88.57 166.58,88.57 166.76,88.39 167.55,88.39 167.93,88.01 168.75,88.01 168.94,88.2 169.4,88.2 169.46,88.25
  TOP w0.127: 169.46,88.25 172.59,88.25 174.47,86.37 175.28,86.37 175.34,86.43 CG533.1
  BOTTOM w0.076: v2(166.27,88.82) 166.32,88.86 166.35,89.1 166.21,89.27 166.07,89.29 UC1.D11
PEG_CRX_GTX_P2: length 15.7
  TOP w0.076: v2(164.32,89.61) 164.54,89.39 164.54,89.22 164.74,89.02 165.22,89.02 165.5,89.3 167.33,89.3 167.79,88.85 169.33,88.85 169.39,88.79
  TOP w0.127: CG535.1 177.83,87.27 174.3,87.27 173.56,88.01 172.78,88.79 169.39,88.79
  BOTTOM w0.076: UC1.F12 v2(164.32,89.61)
PEG_CRX_GTX_P3: length 11.4
  TOP w0.076: v2(166.27,90.4) 166.05,90.4 165.99,90.34 165.99,90.07 166.1,89.96 167.68,89.96 168.06,89.58 168.72,89.58 168.9,89.76 169.37,89.76 169.42,89.81
  TOP w0.127: 169.42,89.81 173.34,89.81 174.56,88.59 175.14,88.59 175.34,88.78 CG537.1
  BOTTOM w0.076: UC1.D13 v2(166.27,90.4)
PEG_CRX_GTX_P4: length 14.5
  TOP w0.076: v2(164.97,91.18) 165.09,91.18 165.47,90.8 167.35,90.8 167.73,90.42 169.22,90.42 169.27,90.37 169.28,90.37 169.29,90.36
  TOP w0.127: CG539.1 177.91,89.35 176.95,89.35 176.85,89.45 174.41,89.45 173.78,90.08 173.5,90.36 169.29,90.36 169.29,90.36
  BOTTOM w0.076: UC1.F14 v2(164.97,91.18)
PEG_CRX_GTX_P5: length 11.2
  TOP w0.076: v2(166.27,91.97) 166.14,91.97 165.99,91.82 165.99,91.65 166.1,91.54 167.66,91.54 168.06,91.13 168.78,91.13 168.98,91.34 169.26,91.34 169.31,91.38 169.32,91.38
  TOP w0.127: CG541.1 175.34,90.94 175.09,90.69 174.74,90.69 174.04,91.38 169.32,91.38
  BOTTOM w0.076: UC1.D15 v2(166.27,91.97)
PEG_CRX_GTX_P6: length 14.3
  TOP w0.076: 169.31,91.94 169.31,91.95 169.3,91.95 169.25,92 167.77,92 167.43,92.34 165.51,92.34 165.09,92.76 v2(164.97,92.76)
  TOP w0.127: CG543.1 177.88,91.54 176.83,91.54 176.76,91.61 174.65,91.61 174.32,91.94 169.32,91.94 169.31,91.94
  BOTTOM w0.076: UC1.F16 v2(164.97,92.76)
PEG_CRX_GTX_P7: length 10.9
  TOP w0.076: v2(166.27,93.55) 166.05,93.55 165.99,93.49 165.99,93.22 166.1,93.11 167.72,93.11 168.13,92.71 168.67,92.71 168.84,92.87 169.28,92.87 169.33,92.93
  TOP w0.127: CG545.1 175.34,93.11 175.15,92.93 169.33,92.93
  BOTTOM w0.076: UC1.D17 v2(166.27,93.55)
PEG_CTX_C_GRX_N0: length 17.7
  BOTTOM w0.076: 191.34,85.61 191.35,85.6 191.36,85.6 191.41,85.54 192.64,85.54 192.84,85.34 193.47,85.34 193.68,85.12 193.68,84.9 193.74,84.84 UG1.AM12
  BOTTOM w0.127: 191.34,85.61 191.34,85.61 179.47,85.61 178.22,86.85 177.56,86.85 CC16.2
PEG_CTX_C_GRX_N1: length 20.9
  BOTTOM w0.076: 191.34,86.09 191.35,86.09 191.36,86.09 191.41,86.15 192.02,86.15 192.13,86.04 193.48,86.04 193.72,86.27 193.72,86.47 193.79,86.54 UG1.AM14
  BOTTOM w0.127: CC14.2 174.53,87.58 178.58,87.58 180.08,86.08 191.34,86.08 191.34,86.09
PEG_CTX_C_GRX_N2: length 16.3
  BOTTOM w0.076: UG1.AP15 192.38,87.09 192.3,87.02 191.41,87.02 191.36,87.07 191.35,87.07 191.34,87.08
  BOTTOM w0.127: 191.34,87.08 191.34,87.08 180.71,87.08 178.86,88.93 177.64,88.93 CC12.2
PEG_CTX_C_GRX_N3: length 21.5
  BOTTOM w0.076: UG1.AM15 193.92,87.28 193.63,86.99 193.04,86.99 192.84,87.19 192.84,87.62 192.73,87.74 191.42,87.74 191.38,87.69 191.34,87.69
  BOTTOM w0.127: 191.34,87.69 181.07,87.69 179.01,89.75 174.54,89.75 CC10.2
PEG_CTX_C_GRX_N4: length 18.5
  BOTTOM w0.076: UG1.AM17 193.62,89.4 193.07,89.4 192.84,89.17 192.84,88.76 192.74,88.66 191.41,88.66 191.36,88.71 191.34,88.71
  BOTTOM w0.127: 191.34,88.71 181.54,88.71 179.16,91.09 177.65,91.09 CC8.2
PEG_CTX_C_GRX_N5: length 21.2
  BOTTOM w0.076: UG1.AP18 192.54,89.84 192.61,89.76 192.61,89.49 192.5,89.38 192.13,89.38 192.03,89.28 191.92,89.28 191.82,89.39 191.82,89.47 192.05,89.7 192.05,89.81 191.97,89.89 191.74,89.89 191.36,89.52 191.09,89.52 191.05,89.47
  BOTTOM w0.127: 191.05,89.47 181.66,89.47 179.22,91.91 174.54,91.91 CC6.2
PEG_CTX_C_GRX_N6: length 18.4
  BOTTOM w0.076: 191.09,90.48 191.1,90.47 191.11,90.47 191.16,90.42 191.36,90.42 191.64,90.7 192.69,90.7 193.04,90.35 193.48,90.35 UG1.AM18
  BOTTOM w0.127: 191.09,90.48 182.16,90.48 179.37,93.27 177.62,93.27 CC4.2
PEG_CTX_C_GRX_N7: length 21.4
  BOTTOM w0.076: 191.34,90.98 191.36,90.98 191.41,91.04 193.48,91.04 UG1.AM20
  BOTTOM w0.127: 191.34,90.98 182.6,90.98 179.51,94.07 174.54,94.07 CC2.2
PEG_CTX_C_GRX_P0: length 17.7
  BOTTOM w0.076: 191.34,85.35 191.38,85.39 192.58,85.39 192.78,85.19 193.4,85.19 193.53,85.06 193.53,84.9 193.47,84.84 UG1.AN12
  BOTTOM w0.127: 191.34,85.35 179.36,85.35 178.12,86.6 177.47,86.6 177.32,86.45 CC15.2
PEG_CTX_C_GRX_P1: length 20.9
  BOTTOM w0.076: UG1.AN14 193.5,86.54 193.56,86.48 193.56,86.34 193.42,86.19 192.19,86.19 192.08,86.3 191.41,86.3 191.36,86.34 191.34,86.34
  BOTTOM w0.127: CC13.2 174.22,87.96 174.35,87.84 178.69,87.84 180.18,86.34 191.01,86.34 191.01,86.34 191.34,86.34
PEG_CTX_C_GRX_P2: length 16.3
  BOTTOM w0.076: 191.34,86.82 191.35,86.82 191.4,86.86 192.3,86.86 192.38,86.79 UG1.AP14
  BOTTOM w0.127: 191.34,86.82 180.61,86.82 178.75,88.68 177.63,88.68 CC11.2
PEG_CTX_C_GRX_P3: length 21.5
  BOTTOM w0.076: UG1.AN15 193.38,87.14 193.55,87.14 193.63,87.21 193.63,87.57 193.5,87.7 192.98,87.7 192.79,87.89 191.41,87.89 191.36,87.94 191.35,87.94 191.34,87.95
  BOTTOM w0.127: 191.34,87.95 181.17,87.95 179.12,90 174.54,90 CC9.2
PEG_CTX_C_GRX_P4: length 18.5
  BOTTOM w0.076: 191.33,88.46 191.39,88.51 192.8,88.51 192.98,88.69 193.5,88.69 193.63,88.81 193.63,89.18 193.56,89.25 193.39,89.25 UG1.AN17
  BOTTOM w0.127: CC7.2 177.63,90.83 179.06,90.83 181.43,88.46 191.33,88.46
PEG_CTX_C_GRX_P5: length 21.1
  BOTTOM w0.076: 191.04,89.73 191.05,89.73 191.11,89.67 191.3,89.67 191.67,90.04 192.03,90.04 192.21,90.22 192.54,90.22 192.77,89.99 192.77,89.43 UG1.AP17
  BOTTOM w0.127: 191.04,89.73 181.77,89.73 179.33,92.17 174.53,92.17 CC5.2
PEG_CTX_C_GRX_P6: length 18.4
  BOTTOM w0.076: UG1.AN18 193.51,89.84 193.57,89.9 193.57,90.04 193.41,90.19 192.98,90.19 192.63,90.55 191.7,90.55 191.42,90.27 191.12,90.27 191.08,90.23
  BOTTOM w0.127: CC3.2 177.66,93.02 179.26,93.02 182.05,90.23 191.08,90.23
PEG_CTX_C_GRX_P7: length 21.4
  BOTTOM w0.076: UG1.AN20 193.51,91.54 193.58,91.46 193.58,91.36 193.41,91.19 191.41,91.19 191.35,91.24 191.34,91.24
  BOTTOM w0.127: CC1.2 174.54,94.33 179.62,94.33 182.7,91.24 191.34,91.24
PEG_CTX_GRX_N0: length 10.9
  BOTTOM w0.076: 169.35,88.23 169.3,88.19 168.85,88.19 168.67,88.01 168.26,88.01 168.17,88.11 167.13,88.11 167.05,88.19 166.96,88.27 166.96,88.39 167.04,88.47 167.21,88.47 UC1.B10
  BOTTOM w0.127: CC16.1 176.07,86.75 172.78,86.75 171.3,88.23 169.35,88.23
PEG_CTX_GRX_N1: length 6.9
  BOTTOM w0.076: UC1.B11 167.73,88.73 168.24,88.73 168.31,88.8 169.22,88.8 169.27,88.75 169.28,88.75
  BOTTOM w0.127: CC14.1 173.01,87.57 172.64,87.57 172.64,87.57 172.63,87.57 172.48,87.73 171.46,88.75 169.29,88.75 169.29,88.75 169.28,88.75
PEG_CTX_GRX_N2: length 10.6
  BOTTOM w0.076: 169.34,89.81 169.32,89.81 169.27,89.76 168.85,89.76 168.67,89.58 168.26,89.58 168.17,89.68 167.13,89.68 167.05,89.77 166.96,89.85 166.96,89.94 167.05,90.03 167.22,90.03 UC1.B12
  BOTTOM w0.127: CC12.1 176.06,88.91 172.92,88.91 172.02,89.81 169.34,89.81
PEG_CTX_GRX_N3: length 6.7
  BOTTOM w0.076: UC1.B13 167.73,90.3 168.24,90.3 168.34,90.4 169.25,90.4 169.3,90.35 169.31,90.35 169.31,90.34
  BOTTOM w0.127: CC10.1 172.99,89.75 172.76,89.75 172.17,90.34 169.32,90.34 169.31,90.34
PEG_CTX_GRX_N4: length 10.4
  BOTTOM w0.076: 169.37,91.37 169.36,91.37 169.31,91.32 168.84,91.32 168.67,91.16 168.26,91.16 168.17,91.26 167.13,91.26 167.05,91.34 166.96,91.42 166.96,91.51 167.07,91.61 167.21,91.61 UC1.B14
  BOTTOM w0.127: CC8.1 176.06,91.06 173.01,91.06 172.7,91.37 169.37,91.37
PEG_CTX_GRX_N5: length 6.4
  BOTTOM w0.076: 169.34,91.92 169.32,91.92 169.27,91.97 168.34,91.97 168.24,91.88 167.73,91.88 UC1.B15
  BOTTOM w0.127: CC6.1 172.98,91.92 169.34,91.92
PEG_CTX_GRX_N6: length 10.4
  BOTTOM w0.076: UC1.B16 167.21,93.19 167.04,93.19 166.96,93.11 166.96,93 167.05,92.92 167.13,92.83 168.17,92.83 168.26,92.73 168.67,92.73 168.85,92.91 169.29,92.91 169.33,92.95 169.34,92.95
  BOTTOM w0.127: CC4.1 176.08,93.25 170.21,93.25 169.91,92.95 169.34,92.95
PEG_CTX_GRX_N7: length 6.7
  BOTTOM w0.076: UC1.B17 167.73,93.45 168.24,93.45 168.34,93.55 169.26,93.55 169.31,93.5
  BOTTOM w0.127: 169.31,93.5 169.73,93.5 170.3,94.07 172.99,94.07 CC2.1
PEG_CTX_GRX_P0: length 10.9
  BOTTOM w0.076: 169.34,87.97 169.33,87.98 169.32,87.98 169.27,88.03 168.91,88.03 168.74,87.86 168.2,87.86 168.1,87.95 167.07,87.95 UC1.C10
  BOTTOM w0.127: CC15.1 176.12,86.5 172.68,86.5 172.68,86.5 172.67,86.5 172.51,86.66 171.2,87.97 169.34,87.97 169.34,87.97
PEG_CTX_GRX_P1: length 6.9
  BOTTOM w0.076: 169.29,89 169.27,89 169.22,88.95 168.25,88.95 168.18,88.88 167.8,88.88 167.61,89.06 167.61,89.15 167.71,89.25 167.86,89.25 UC1.A11
  BOTTOM w0.127: 169.29,89 171.57,89 172.74,87.83 172.74,87.83 172.75,87.82 172.97,87.82 CC13.1
PEG_CTX_GRX_P2: length 10.6
  BOTTOM w0.076: UC1.C12 167.07,89.53 168.1,89.53 168.2,89.43 168.74,89.43 168.91,89.6 169.27,89.6 169.32,89.56
  BOTTOM w0.127: CC11.1 176.12,88.65 172.81,88.65 172.26,89.21 171.91,89.56 169.32,89.56 169.32,89.56
PEG_CTX_GRX_P3: length 6.7
  BOTTOM w0.076: UC1.A13 167.86,90.83 167.69,90.83 167.61,90.75 167.61,90.64 167.7,90.55 167.8,90.45 168.18,90.45 168.27,90.55 169.28,90.55 169.32,90.59
  BOTTOM w0.127: 169.32,90.59 172.28,90.59 172.87,90 172.99,90 CC9.1
PEG_CTX_GRX_P4: length 10.4
  BOTTOM w0.076: UC1.C14 167.07,91.1 168.1,91.1 168.2,91.01 168.74,91.01 168.9,91.17 169.3,91.17 169.36,91.11 169.37,91.11
  BOTTOM w0.127: CC7.1 176.13,90.8 172.91,90.8 172.6,91.11 169.37,91.11
PEG_CTX_GRX_P5: length 6.4
  BOTTOM w0.076: 169.34,92.18 169.33,92.18 169.28,92.12 168.27,92.12 168.18,92.03 167.8,92.03 167.7,92.13 167.61,92.21 167.61,92.33 167.69,92.4 167.86,92.4 UC1.A15
  BOTTOM w0.127: CC5.1 173.01,92.18 169.34,92.18
PEG_CTX_GRX_P6: length 10.4
  BOTTOM w0.076: UC1.C16 167.07,92.68 168.1,92.68 168.2,92.58 168.74,92.58 168.91,92.76 169.27,92.76 169.32,92.71 169.33,92.71 169.34,92.7
  BOTTOM w0.127: CC3.1 176.1,92.99 170.31,92.99 170.02,92.7 169.34,92.7 169.34,92.7
PEG_CTX_GRX_P7: length 6.7
  BOTTOM w0.076: 169.31,93.75 169.26,93.7 168.27,93.7 168.18,93.6 167.8,93.6 167.7,93.7 167.61,93.79 167.61,93.9 167.69,93.98 167.86,93.98 UC1.A17
  BOTTOM w0.127: 169.31,93.75 169.63,93.75 170.2,94.32 172.99,94.32 CC1.1
PEG_RCOMP: length 8.6
  BOTTOM w0.127: v1(169.2,77.82) 168.46,78.56 RC9.2
  BOTTOM w0.203: 167.72,80.92 167.47,81.18 165.9,81.18 164.72,82.35 164.72,82.67 164.23,83.17 UC1.G2
  BOTTOM w0.381: RC9.2 168.46,80.19 167.72,80.92
PEX_TREMP: length 2.8
  BOTTOM w0.254: RG10.2 191.02,99.59 191.77,98.84 192.18,98.84 UG1.AP29
PG_+2.5V: length 28.7
  TOP w0.127: v2(99.47,24.2) 99.61,24.2 v1(100.79,23.02) 102.65,21.16 106.68,21.16 107.5,20.34 107.5,17.5 106.91,16.91 PU2501.5 106.21,16.91 105.87,16.57 PR2504.2
  BOTTOM w0.127: PDM2.1 90.13,19.76 95.66,19.76 98.7,22.8 98.7,23.98 98.92,24.2 v2(99.47,24.2)
PIRQA#: length 3.1
  TOP w0.127: RH169.1 198.18,21.78 v2(198.4,21.99) 198.92,21.99 v1(199.09,21.83)
  BOTTOM w0.127: UH1.BA36 197.37,20.97 v2(198.4,21.99)
PLT_RST#: length 485.1
  TOP w0.102: UH3.4 216.62,8.63 RH7.2 CH79.2 215.19,7.33 215.35,7.18 220.37,7.18 v2(223.43,10.24) ; v2(103.23,13.79) 102.96,13.79 101.75,13.79 101.55,13.99 101.55,14.85 96.66,19.74 96.66,19.94 ; R28.1 128.81,14.34 v2(128.04,13.57) ; 143.29,4.85 143.52,4.62 152.74,4.62 152.91,4.8 152.91,5.49 155.68,8.26 155.68,8.9 156.8,10.02 166.87,10.02 168.12,8.77 168.12,7.06 v2(167.7,6.63) ; 143.29,4.85 143.29,6.35 143.08,6.55 RK31.2 CK4.1 141.84,6.93 142.04,7.13 UK1.13 ; 143.29,4.85 143.06,4.62 139.37,4.62 v2(138.26,5.73) ; v2(58.28,16.04) 58.5,16.04 60.1,17.64 v1(61.02,17.64) 61.12,17.64 63.3,19.82 63.3,21.67 64.95,23.32 72.69,23.32 74.24,24.87 75.02,24.87 75.54,24.35 86.72,24.35 91.14,19.94 96.66,19.94 ; 96.66,19.94 97.71,20.98 97.71,25.6 v2(97.5,25.8)
  IN1 w0.127: v2(97.5,25.8) 97.08,26.22 96.06,26.22 94.81,24.97 90.87,24.97 89.54,26.31 86.93,26.31 85.1,28.14 70.3,28.14 67.35,31.09 67.35,41.59 65.03,43.91 58,43.91 56.22,42.13 54.38,42.13 52.76,43.75 52.76,45.42 50.6,47.58 49.28,47.58 46.31,50.56 43.95,51.77 41.58,53.24 40.29,54.15 37.25,56.41 35.99,56.41 34.37,58.03 34.37,58.8 33.53,59.64 33.3,59.64 32.83,60.11 32.83,60.67 v2(32.86,60.7) ; v2(35.69,13.66) 43.48,13.66 v2(43.88,14.07) 44,14.07 44.38,14.45 45.43,14.45 45.98,15.01 49.48,15.01 50.31,14.18 56.75,14.18 58.28,15.72 v2(58.28,16.04)
  IN2 w0.127: v2(131.77,7.52) 131.77,6.69 133.4,5.06 137.59,5.06 v2(138.26,5.73)
  IN3 w0.127: v2(224.69,18.48) 224.69,19.61 223.48,20.83 223.48,27.36 227.09,30.98 227.09,32.45 233.69,39.04 233.69,40.19 234.88,41.38 234.88,46.95 234.64,47.19 234.64,48.66 234.1,49.2 234.1,49.77 234.65,50.33 v2(234.65,51.28) ; v2(103.23,13.79) 103.71,13.79 104.88,14.96 111.69,14.96 112.34,14.32 114.6,14.32 114.75,14.47 119.4,14.47 119.86,14.01 125.19,14.01 125.65,13.56 128.02,13.56 v2(128.04,13.57) ; v2(167.7,6.63) 167.7,5.74 168.81,4.63 218.39,4.63 221.29,7.53 223.72,7.53 224.07,7.88 224.07,8.76 223.43,9.4 v2(223.43,10.24) 225.24,12.05 225.7,12.05 227.06,13.42 231.6,13.42 232.03,13.85 236.42,13.85 238.49,15.92 257.36,15.92 258.2,15.08 263.55,15.08 264.84,16.37 274.78,16.37 278.25,12.9 278.67,12.47 281.81,12.47 282.16,12.82 282.61,12.82 285.99,9.44 291.25,9.44 292.39,10.59 298.2,10.59 298.66,11.05 301.45,11.05 303.56,13.15 308.23,13.15 v2(308.51,12.88)
  BOTTOM w0.102: v2(224.69,18.48) 224.76,18.42 224.76,17.47 223.43,16.14 223.43,10.24 v2(223.43,10.24) ; v2(128.04,13.57) 131.03,10.58 131.03,9.83 131.77,9.09 v2(131.77,7.52) ; UG2.1 234.94,51.57 v2(234.65,51.28) ; v2(35.69,13.66) 35.57,13.79 R5218.2 ; RV19.2 31.65,59.65 31.91,59.65 32.31,60.05 32.31,60.15 v2(32.86,60.7) ; v2(58.28,16.04) 58.28,16.09 57.86,16.52 57.21,16.52 57.02,16.71 56.83,16.71 56.31,17.23 UL1.19 ; v2(308.51,12.88) 308.51,12.42 309.08,11.85 JWLAN1.44
  BOTTOM w0.127: UR1.1 43.01,14.51 43.45,14.07 v2(43.88,14.07)
PLT_RST#_R: length 25.7
  BOTTOM w0.102: R5218.1 34.52,13.2 34.23,12.91 34.23,12.16 34.11,12.05 32.95,12.05 v1(32.19,11.29) 31.75,10.85 21.27,10.85 20.72,10.3 20.72,7.7 23.6,4.81 JSSD1.50
PLT_RST#_TPM: length 3.5
  TOP w0.102: UT1.17 126.25,15.16 127.04,14.37 R28.2 127.89,14.18 127.55,13.84 v1(127.55,13.4)
PLTRST_VGA#_1V8: length 115.8
  IN2 w0.127: v2(236.13,60.98) 234.85,60.98 233.84,59.97 233.84,55.06 235.21,53.69 235.21,51.18 234.82,50.79 231.68,50.79 230.34,49.44 224.49,49.44 221.51,52.42 197.45,52.42 197.42,52.45 196.42,52.45 193.03,55.84 192.91,55.95 192.91,70.03 193.81,70.93 193.81,73.63 191.46,75.98 191.46,76.33 192.05,76.92 192.05,78.1 v2(191.7,78.45)
  BOTTOM w0.127: UG1.AJ12 196,84.41 196,83.9 196.15,83.75 196.15,82.8 195.99,82.64 195.99,82.2 195.72,81.94 194.57,81.94 194.36,81.73 194.36,81.31 194.14,81.09 192.02,81.09 191.42,80.49 191.42,79.97 191.7,79.69 v2(191.7,78.45) 191.05,78.45 190.89,78.61 190.38,78.61 v1(189.36,79.63) 186,79.63 185.42,79.05 UG8.1 ; UG29.2 240.22,60.06 239.92,60.36 239.22,60.36 238.63,59.76 237.13,59.76 236.81,60.08 RG16.1 236.81,60.35 CG200.1 236.81,61.25 236.92,61.36 UG28.2 236.88,61.87 236.13,61.13 v2(236.13,60.98) 236.13,60.74 RG100.2 234.57,60.32 233.94,60.32 233.72,60.11 233.72,55.18 233.64,55.1 UG2.4
PLUG_IN#: length 49.9
  TOP w0.127: v2(281.76,25.81) 281.76,25.52 v3(282.21,25.07)
  TOP w0.135: RA17.2 v2(291.17,14.63)
  IN2 w0.127: v2(281.76,25.81) 281.76,24.95 280.99,24.18 280.99,20.99 284.71,17.27 286.05,17.27 288.23,15.09 290.7,15.09 291.16,14.63 v2(291.17,14.63)
  BOTTOM w0.135: JIO1.28 308.24,32.25 307.82,32.67 305.27,32.67 304.97,32.97 293.84,32.97 286.37,25.5 282.07,25.5 v2(281.76,25.81)
PLUG_IN#_R: length 4.4
  TOP w0.135: RA16.1 RA17.1 291.17,16.46 291.31,16.6 v1(291.31,17.04) 291.59,17.32 291.59,18.87 291.75,19.03 UA1.48
PM_BATLOW#: length 7.2
  TOP w0.127: RH41.1 190.73,13.61 190.97,13.61 191.56,14.2 191.56,15.38 v2(191.41,15.52)
  BOTTOM w0.102: UH1.BF44 192.84,18.03 192.84,17.55 192.78,17.49 192.49,17.49 192.43,17.42
  BOTTOM w0.127: v2(191.41,15.52) 191.74,15.85 191.74,16.73 192.43,17.42
PM_CLKRUN#: length 2.5
  TOP w0.127: v1(199.1,23.17) 198.55,22.61 v2(198.39,22.61) 197.77,22.61 RH44.1
  BOTTOM w0.127: UH1.AV32 198.58,22.42 v2(198.39,22.61)
PM_SLP_A#: length 4.6
  BOTTOM w0.102: UH1.BE40 195.12,18.95 195.12,17.52 194.93,17.32 194.93,16.28 194.88,16.22
  BOTTOM w0.127: RH200.1 195.13,14.98 194.84,15.27 194.84,15.44 194.72,15.56 194.72,16.06 194.88,16.22
PM_SLP_S0#: length 5
  BOTTOM w0.102: UH1.BC28 200.96,19.68 200.96,19.09 200.86,18.99 200.86,18.11 201.19,17.78 201.19,17.13 200.68,16.62
  BOTTOM w0.127: 200.68,16.62 200.68,16.34 201.26,15.76 TH4972.1
PM_SLP_S3#: length 81.4
  TOP w0.127: RH197.2 191.98,13.22 v1(192.47,13.71) 192.61,13.85 192.61,14.66 v2(192.74,14.78) ; v2(145.48,16.68) 145.01,16.2 143.41,16.2 142.36,15.15 142.36,13.34 139.24,10.22 UK1.6
  IN1 w0.127: v2(170.86,6.28) 174.56,6.28 174.74,6.46 174.74,6.84 177.31,9.41 180.3,9.41 181.34,10.44 183.79,10.44 185.38,12.03 189.72,12.03 192.12,14.42 192.38,14.42 v2(192.74,14.78)
  BOTTOM w0.127: v2(170.86,6.28) 170.29,6.28 170.03,6.55 170.03,9.62 167.39,12.26 164.92,12.26 163.32,13.87 151.76,13.87 150.52,12.62 144.45,12.62 143.74,13.33 143.74,15 145.42,16.68 v2(145.48,16.68) ; UH1.BF42 193.81,18.05 193.81,17.6 193.16,16.95 193.16,16.57 192.23,15.65 192.23,15.29 v2(192.74,14.78)
PM_SLP_S4#: length 151.9
  TOP w0.127: v2(115,22.86) 115,20.2 114.02,19.21 114.02,16.57 114.34,16.25 v2(114.34,15.27) 113.61,14.54 113.61,13.98 112.11,12.48 v3(111.41,12.48) 111.27,12.62 108,12.62 PR2501.1 ; v2(140.2,18.69) 140.29,18.59 140.29,17.62 139.32,16.64 139.32,14.51 136.63,11.82 UK1.123 ; v2(192.74,16.89) 192.74,16.79 192.23,16.28 192.23,15.27 192.35,15.16 192.35,14.24 191.22,13.11 RH198.2
  IN2 w0.127: v2(182.1,22.36) 182.09,22.36 181.46,22.36 180.82,21.73 180.82,19.93 184.25,16.51 188.1,16.51 188.48,16.89 v2(192.74,16.89)
  IN3 w0.127: v2(182.1,22.36) 181.88,22.58 180.14,22.58 179.81,22.25 177.83,22.25 177.31,22.77 169.67,22.77 169.45,22.99 166.15,22.99 165.82,22.67 161.71,22.67 161.47,22.91 160.09,22.91 159.64,23.36 152.59,23.36 150.11,20.88 147.49,20.88 146.16,19.55 144.8,19.55 143.81,18.55 141.4,18.55 140.83,19.12 140.63,19.12 v2(140.2,18.69) 140.29,18.59 140.29,17.84 135.98,13.52 132.04,13.52 131.58,13.99 128.58,13.99 127.35,15.22 125.82,15.22 125.12,14.52 120.07,14.52 119.61,14.97 114.64,14.97 v2(114.34,15.27)
  BOTTOM w0.127: UH1.BE42 193.53,18.31 193.53,17.64 193.09,17.19 192.79,16.89 v2(192.74,16.89) ; v2(115,22.86) 114.09,23.77 111.17,23.77 109.99,24.95 106.66,24.95 105.67,25.93 104.88,25.93 104.84,25.98 102.16,25.98 101.53,25.35 100.41,25.35 99.68,24.62 98.86,24.62 98.44,24.2 98.44,22.91 95.68,20.14 94.66,20.14 94.47,20.33 PDM1.1
PM_SLP_S5#: length 64.3
  TOP w0.127: UK1.14 142.44,9.13 142.23,9.33 142.23,10.48 144.52,12.76 v2(144.52,13.89) ; v2(184.38,16.96) 184.14,16.72 RH199.2 v1(183.12,16.31)
  IN3 w0.127: v2(144.52,13.89) 146.34,15.71 149.6,15.71 153.18,19.29 153.81,19.29 154.25,18.86 155.03,18.86 155.27,19.09 158.07,19.09 158.32,18.85 160.43,18.85 160.67,19.09 164.52,19.09 164.66,18.96 172.6,18.96 172.74,19.09 174.22,19.09 174.93,18.39 181.4,18.39 182.83,16.96 v2(184.38,16.96) 184.8,17.38 186.59,17.38 189.48,20.27 191.32,20.27 191.85,20.81 192.83,20.81 193.02,20.62 v2(193.82,20.62)
  BOTTOM w0.102: v2(193.82,20.62) 194.16,20.29 194.16,20.26 194.2,20.21 194.2,20.15 194.31,20.05 UH1.BC42
PM_SLP_SUS#: length 65.9
  TOP w0.127: v2(145.86,13.89) 145.86,13.28 142.76,10.18 142.76,9.55 143.24,9.07 UK1.16
  IN3 w0.127: v2(145.86,13.89) 147.15,15.18 149.76,15.18 152.7,18.12 178.84,18.12 180.6,16.36 180.6,15.38 181,14.98 189.16,14.98 190.48,16.29 194.48,16.29 195.17,16.98 195.17,19.91 v2(195.08,20)
  BOTTOM w0.122: v2(195.08,20) 195.5,20 195.83,19.67 UH1.BD39
  BOTTOM w0.127: v1(145.51,14.6) 145.86,14.25 v2(145.86,13.89)
PROC_SELECT#: length 8.7
  BOTTOM w0.137: UC1.BN1 129.3,82.02 128.64,81.36 127.09,81.36 124.89,79.16 124.89,77.4 TC97.1
PWM1_1PH/ICCMAX1: length 23.7
  TOP w0.127: v2(173.23,129.11) v1(174.08,129.11)
  IN1 w0.254: v2(173.23,129.11) 173.02,129.11 172.7,128.79 172.22,128.79 171.46,129.56 171.46,131.41 170.48,132.4 164.89,132.4 163.02,134.26 161.07,134.26 160.56,133.75 159.96,133.75 159.47,134.25 v2(159.47,134.39)
  BOTTOM w0.203: PUZ1.44 172.21,130.43 172.49,130.15 173.13,130.15 173.52,129.75 173.62,129.75 PRZ24.1 173.47,129.11 v2(173.23,129.11)
  BOTTOM w0.254: v2(159.47,134.39) 159.47,134.14 159.85,133.75 PUA1.2
PWM1_2PH/ICCMAX2: length 120.6
  TOP w0.254: PUG1.2 120.2,94.4 120.54,94.07 120.54,92.42 119.99,91.87 116.49,91.87 115.8,91.18 107.8,91.18 107.16,91.83 v1(107.16,96.02) 107.16,103.91 109.56,106.31 112.07,106.31 115.73,109.97 119.18,109.97 121.03,111.82 121.03,111.82 121.7,112.49 121.7,112.49 126.35,117.15 126.35,121.53 122.99,124.89 122.99,133 124.41,134.42 128.82,134.42 129.38,133.86 131.24,133.86 131.91,134.54 136.37,134.54 137.1,133.81 138.48,133.81 139.27,134.6 143.78,134.6 144.52,133.86 146.2,133.86 146.92,134.58 151.31,134.58 152.06,133.84 153.29,133.84 154.1,134.65 157.37,134.65 158.39,133.63 160.74,133.63 161.37,134.26 162.35,134.26 165.1,131.5 PRZ58.1 164.91,130.83 164.39,130.83 164.31,130.75 v2(164.09,130.75)
  BOTTOM w0.254: PUZ1.23 164.17,130.83 v2(164.09,130.75)
PWM1_4PH/ICCMAX4: length 27.9
  TOP w0.203: PRZ61.1 163.45,127.94 v2(162.89,128.5)
  IN2 w0.203: v2(162.89,128.5) 163.02,128.37 164.68,128.37 165.64,129.33 165.64,132.99 165.31,133.32 165.31,134.01 163.87,135.45 162.94,135.45 161.87,136.52 159.57,136.52 158.2,135.15 154.09,135.15 153.58,135.66 152.72,135.66 152.22,136.16 v2(152.22,136.42)
  BOTTOM w0.203: v2(162.89,128.5) 163.01,128.61 v1(163.47,128.61) 163.73,128.61 163.9,128.45 164.28,128.45 164.53,128.7 164.59,128.7 164.72,128.83 PUZ1.18
  BOTTOM w0.254: v2(152.22,136.42) 152.23,136.41 PUZ2.2
PWM2_2PH/ROSC1: length 2
  BOTTOM w0.203: PRZ65.1 163.57,130.58 163.88,130.27 164.26,130.27 164.42,130.43 PUZ1.22
PWM2_4PH/ADDR: length 32.1
  TOP w0.254: v2(164.09,128.9) 164.24,129.06 164.76,129.06 PRZ62.1
  IN2 w0.203: v2(144.61,136.41) 144.61,135.91 144.75,135.77 145.51,135.77 146.39,134.9 150.51,134.9 150.9,135.28 153.43,135.28 153.94,134.77 158.35,134.77 159.75,136.17 161.73,136.17 162.83,135.06 163.74,135.06 164.95,133.86 164.95,133.17 165.29,132.84 165.29,129.5 164.69,128.9 v2(164.09,128.9)
  BOTTOM w0.203: v2(164.09,128.9) 164.18,128.9 164.3,129.02 164.37,129.02 164.4,129.04 164.46,129.04 164.64,129.23 PUZ1.19
  BOTTOM w0.254: PUZ3.2 144.61,136.41 v2(144.61,136.41)
PWM3_4PH/VBOOT: length 40.6
  TOP w0.127: v2(163.05,129.13) v1(162.37,129.13)
  IN2 w0.203: v2(136.99,136.42) 136.99,136.04 137.62,135.41 137.88,135.41 138.89,134.39 142.88,134.39 143.77,135.28 145.4,135.28 146.16,134.52 150.67,134.52 151.05,134.9 153.27,134.9 153.78,134.39 158.58,134.39 159.36,135.18 160.53,135.18 161.45,134.26 162.74,134.26 164.89,132.11 164.89,129.73 164.52,129.36 163.28,129.36 v2(163.05,129.13)
  BOTTOM w0.203: PUZ1.20 164.56,129.63 164.36,129.42 164.36,129.42 164.31,129.37 164.3,129.37 164.28,129.36 163.91,129.36 163.48,129.79 PRZ63.1 163.05,129.39 v2(163.05,129.13)
  BOTTOM w0.254: PUZ4.2 136.99,136.41 v2(136.99,136.42)
PWM4_4PH/ROSCM: length 43.4
  TOP w0.254: PRZ64.1 164.53,130.26 164.1,129.83 v2(164.1,129.82)
  IN2 w0.203: v2(129.62,136.39) 129.62,136.17 131.65,134.14 135.72,134.14 136.48,134.9 137.75,134.9 138.64,134.01 143.01,134.01 143.9,134.9 145.24,134.9 146,134.14 151.59,134.14 151.85,133.88 153.5,133.88 153.62,134.01 159.19,134.01 160.08,133.12 162.92,133.12 163.29,132.75 163.29,130.63 v2(164.1,129.82)
  BOTTOM w0.203: v2(164.1,129.82) 164.19,129.9 164.37,129.9 164.49,130.03 PUZ1.21
  BOTTOM w0.254: PUZ5.2 129.63,136.38 v2(129.62,136.39)
PWR_LED#: length 263
  TOP w0.127: v2(115.77,24.07) 115.92,23.91 115.92,20.37 114.54,18.99 114.54,16.79 115.36,15.97 115.36,13.36 117.16,11.56 122.93,11.56 v3(126.5,7.98) 126.65,7.84 v2(126.65,6.79) ; UK1.92 138.84,22.7 v2(139.02,22.52)
  IN3 w0.127: v2(126.65,6.79) 126.65,6.55 126.46,6.36 125.52,6.36 92.61,6.36 89.87,9.11 88.27,9.11 87.01,10.37 83.97,10.37 80.25,14.1 74.08,14.1 72.89,15.28 66.8,15.28 62.39,19.68 62.39,19.95 61.06,21.29 61.06,23.71 60.41,24.37 58.64,24.37 53.65,29.36 53.65,30.98 53.93,31.26 53.93,34.93 52.7,36.16 52.7,37.43 52.4,37.73 52.4,39.11 50.5,41.02 50.5,43.44 49.76,44.18 47.65,44.18 46.47,45.36 43.97,45.36 43.08,44.48 42.46,44.48 42.17,44.77 42.17,46.47 41.15,47.49 39.68,47.49 37.41,49.76 36.23,50.94 36.23,53.25 35.05,54.44 31.74,54.44 30.71,55.47 28.74,55.47 28.05,56.15 28.05,57.27 26.78,58.54 23.91,58.54 23.43,59.03 23.43,64.4 23.24,64.59 23.24,65.09 21.39,66.95 20.88,66.95 19.76,68.07 19.76,69.61 20.3,70.15 20.3,72.77 19.4,73.67 19.4,78.75 19.27,78.88 19.27,82.82 18.55,83.54 18.55,85 18.64,85.09 18.64,116.67 17.83,117.48 17.83,118.96 17.1,119.69 17.1,120.23 16.87,120.46 16.87,121.59 14.85,123.61 13.44,123.61 12.31,122.48 v2(11.51,122.48)
  BOTTOM w0.127: v2(139.02,22.52) 138.86,22.52 138.32,21.99 135.69,21.99 134.98,22.7 133.49,22.7 133.26,22.93 131.43,22.93 131.35,23 125.05,23 125.02,23.04 122.78,23.04 121.2,23.04 120.04,23.04 120.04,23.04 118.32,23.04 117,23.04 116.8,23.04 v2(115.77,24.07) ; v2(11.51,122.48) 11.25,122.74 JPWR1.4
PWROK_DDR: length 3.1
  BOTTOM w0.135: PTPM1.1 89.49,24.04 PUM1.10
QPCN:
  vias: v1(238.42,13.59)
REFCLK_CNV: length 154.2
  TOP w0.127: RWL29.1 311.66,11.48 312.36,12.18 312.36,33.83 v1(311.71,34.48) 310.86,35.33 v2(309.99,35.33) ; v2(211.56,33.79) 211.28,34.07 RH173.1
  IN1 w0.127: v2(211.56,33.79) 211.56,33.24 211.11,32.79 211.11,30.26 210.46,29.62 210.46,28.75 209.4,27.69 209.4,26.7 209.98,26.12 211.54,26.12 211.94,26.52 213.13,26.52 214.18,27.57 217.56,27.57 219.1,29.11 v2(219.5,29.11)
  IN2 w0.127: v2(219.5,29.11) 222.77,32.37 223.62,32.37 225.88,34.63 239.41,34.63 239.54,34.5 239.54,34.5 239.6,34.44 246.83,34.44 247.83,35.44 252.29,35.44 252.57,35.15 255.81,35.15 257.76,37.11 257.76,37.11 257.85,37.19 257.85,37.87 257.86,37.87 258.29,38.29 258.78,38.29 259.39,37.68 260.14,37.68 260.33,37.49 276.49,37.49 v2(277.12,38.12)
  IN3 w0.127: v2(277.12,38.12) 276.71,38.53 276.71,39.72 281.94,44.95 295.22,44.95 297.99,42.19 308.03,42.19 309.99,40.23 v2(309.99,35.33)
  BOTTOM w0.127: v2(211.56,33.79) 211.56,33.56 UH1.R6
REFCLK_CNV_R: length 3.9
  TOP w0.127: v2(311.87,10.56) RWL29.2
  BOTTOM w0.127: v2(311.87,10.56) 311.87,9.36 311.36,8.85 JWLAN1.56
RJ45_RX1+: length 69.8
  IN1 w0.102: JRJ45.3 14.3,72.75 15.83,71.21 15.83,67.41 13.92,65.5 13.92,63.33 12.68,62.08 12.68,56.61 15.56,53.74 15.56,51.81 16.24,51.13 16.24,48.68 17.18,47.74 18.78,47.74 19.8,46.72 26.58,46.72 27.33,45.97 27.72,45.97 28.18,45.51 30.76,45.51 31.57,44.69 35.27,44.69 37.15,42.81 37.15,37.07 36.01,35.92 36.01,28.31 36.18,28.13 36.47,28.13 v2(36.66,28.32)
  BOTTOM w0.102: TSL1.17 37.41,28.5 37.06,28.15 36.82,28.15 v2(36.66,28.32)
RJ45_RX1-: length 69.8
  IN1 w0.102: v2(36.66,27.73) 36.56,27.83 36.06,27.83 35.7,28.18 35.7,36.05 36.85,37.19 36.85,42.68 35.14,44.39 31.44,44.39 30.63,45.2 28.05,45.2 27.59,45.66 27.2,45.66 26.46,46.41 19.67,46.41 18.65,47.44 17.05,47.44 15.93,48.55 15.93,51 15.25,51.69 15.25,53.61 12.37,56.49 12.37,62.21 13.62,63.45 13.62,65.62 15.53,67.54 15.53,71.09 15.14,71.47 15,71.47 14.79,71.27 14.79,69.88 14.6,69.69 JRJ45.6
  BOTTOM w0.102: v2(36.66,27.73) 36.77,27.85 37.06,27.85 37.41,27.5 TSL1.16
RJ45_TX0+: length 69.3
  IN3 w0.102: JRJ45.1 13.6,74.79 13.8,74.99 14.93,74.99 16.03,73.88 16.03,70.78 16.99,69.82 16.99,66.38 16.3,65.68 16.3,63.47 19.43,60.34 19.43,54.65 20.06,54.02 20.06,53.64 25.13,48.56 27.67,48.56 28.02,48.21 30.8,48.21 31.86,47.15 32.39,47.15 33.75,45.79 34.49,45.79 37.29,43 37.29,37.28 37.97,36.61 37.97,27.9 36.99,26.92 36.65,26.92 36.03,26.3 36.03,25.31 36.23,25.1 36.59,25.1 v2(36.73,25.24)
  BOTTOM w0.102: v2(36.73,25.24) 36.84,25.13 37.05,25.13 37.42,25.5 TSL1.14
RJ45_TX0-: length 69.4
  IN3 w0.102: JRJ45.2 13.62,74.09 13.62,74.37 13.93,74.68 14.8,74.68 15.73,73.75 15.73,70.65 16.69,69.69 16.69,66.5 15.99,65.81 15.99,63.34 19.13,60.21 19.13,54.52 19.75,53.89 19.75,53.51 25,48.26 27.54,48.26 27.89,47.9 30.68,47.9 31.73,46.85 32.26,46.85 33.62,45.49 34.37,45.49 36.99,42.87 36.99,37.16 37.66,36.48 37.66,28.02 36.86,27.23 36.52,27.23 35.73,26.43 35.73,25.18 36.11,24.8 36.59,24.8 v2(36.73,24.66)
  BOTTOM w0.102: TSL1.13 37.43,24.5 37.1,24.82 36.89,24.82 v2(36.73,24.66)
RJ45_TX2+: length 58.4
  IN3 w0.102: v2(36.72,31.27) 36.6,31.14 36.2,31.14 36.05,31.29 36.05,32.26 37.22,33.43 37.22,36.26 35.9,37.58 35.9,43.25 34.5,44.64 31.8,44.64 30.28,46.16 27.5,46.16 26.85,46.82 25.77,46.82 19.25,53.34 19.25,53.83 18.72,54.35 18.72,60.04 15.45,63.32 15.45,65.92 16.28,66.76 16.28,69.41 14.86,70.83 13.85,70.83 13.63,71.05 13.63,71.41 JRJ45.4
  BOTTOM w0.102: v2(36.72,31.27) 36.86,31.13 37.09,31.13 37.46,31.5 TSL1.20
RJ45_TX2-: length 58.4
  IN3 w0.102: JRJ45.5 13.54,70.71 13.72,70.53 14.74,70.53 15.98,69.29 15.98,66.88 15.14,66.05 15.14,63.19 18.42,59.92 18.42,54.23 18.94,53.7 18.94,53.21 25.64,46.51 26.72,46.51 27.38,45.86 30.15,45.86 31.67,44.34 34.38,44.34 35.59,43.12 35.59,37.45 36.91,36.13 36.91,33.55 35.74,32.39 35.74,31.17 36.07,30.84 36.57,30.84 v2(36.72,30.68)
  BOTTOM w0.102: TSL1.19 37.47,30.5 37.09,30.87 36.91,30.87 v2(36.72,30.68)
RJ45_TX3+: length 54.7
  IN3 w0.102: JRJ45.7 13.58,68.67 13.72,68.81 14.84,68.81 15.46,68.19 15.46,67.09 13.98,65.6 13.98,61.72 13.45,61.19 13.45,57.65 20.49,50.61 20.49,49.06 23.51,46.04 26.38,46.04 28.52,43.91 34.21,43.91 35.18,42.93 35.18,34.91 35.92,34.17 36.33,34.17 v2(36.47,34.32)
  BOTTOM w0.102: TSL1.23 37.3,34.5 36.93,34.13 36.66,34.13 v2(36.47,34.32)
RJ45_TX3-: length 54.7
  IN3 w0.102: v2(36.47,33.73) 36.34,33.87 35.8,33.87 34.88,34.79 34.88,42.81 34.08,43.6 28.39,43.6 26.26,45.74 23.39,45.74 20.19,48.94 20.19,50.48 13.14,57.52 13.14,61.32 13.67,61.85 13.67,65.73 15.16,67.21 15.16,68.06 14.71,68.51 13.85,68.51 13.63,68.29 13.63,67.97 JRJ45.8
  BOTTOM w0.102: v2(36.47,33.73) 36.61,33.87 37,33.87 37.38,33.5 TSL1.22
ROM_SCLK: length 27.3
  TOP w0.102: 217.85,73.74 217.17,74.42 217.17,74.59 215.69,76.06 214.89,76.06 214.38,76.58 214.38,76.95 v2(213.6,77.73)
  TOP w0.127: 217.85,73.74 218.44,73.15 219.44,73.15 220.02,72.58 223.73,72.58 228.69,67.62 228.69,64.61 v2(228.59,64.51)
  BOTTOM w0.102: UG1.H4 v2(213.6,77.73)
  BOTTOM w0.127: RG132.1 226.49,63.65 RG138.2 226.76,64.77 v1(227.23,64.77) 227.83,64.77 228.09,64.51 v2(228.59,64.51)
ROM_SI: length 29.5
  TOP w0.102: 218.61,75.56 218.35,75.81 218.35,76.26 217.28,77.33 215.91,77.33 215.67,77.57 215.67,78.67 215.43,78.91 214.86,78.91 v2(214.48,78.54)
  TOP w0.127: v2(230.57,62.98) 230.46,63.08 v1(230.46,66.1) 230.46,66.96 224.06,73.36 220.34,73.36 219.77,73.94 219.28,73.94 218.94,74.28 218.94,75.22 218.61,75.56
  BOTTOM w0.109: v2(214.48,78.54) 214.08,78.94 UG1.H5
  BOTTOM w0.127: v2(230.57,62.98) 230.57,63.28 RG136.2 230.99,63.43 230.99,62.24 RG130.1
ROM_SO: length 31.9
  TOP w0.102: v2(214.48,80.27) 214.7,80.27 215.06,80.62 215.57,80.62 215.71,80.76 217.06,80.76 217.86,79.96 217.86,79.11 218.99,77.98 218.99,76.35 218.97,76.34 218.97,75.92 220.07,74.81 220.07,74.37
  TOP w0.127: v2(232.96,62.94) 232.83,63.07 v1(232.83,63.93) 232.83,65.33 224.27,73.89 220.56,73.89 220.07,74.37
  BOTTOM w0.109: v2(214.48,80.27) 214.11,80.64 UG1.H7
  BOTTOM w0.127: RG131.1 232.4,63.4 RG137.2 232.96,63.16 v2(232.96,62.94)
RSET: length 6.1
  BOTTOM w0.127: RL11.2 51.33,22.38 50.86,21.91 v1(49.55,21.91)
  BOTTOM w0.203: 53.12,20.94 UL1.31
  BOTTOM w0.254: RL11.2 51.52,22.48 52.43,22.48 52.5,22.55 52.94,22.55 53.2,22.29 53.2,21.82 52.94,21.55 52.94,21.13 53.12,20.94
RTD3_CIO_PWR_EN: length 1.5
  TOP w0.127: v2(194.04,27.92) 193.33,27.92 TH4962.1
  BOTTOM w0.127: UH1.AE43 193.89,28.08 v2(194.04,27.92)
RTD3_USB_PWR_EN: length 2.7
  TOP w0.135: v2(201.13,21.18) 200.86,20.91 TH4960.1
  BOTTOM w0.127: UH1.BD29 200.58,19.39 200.58,20.63 v2(201.13,21.18)
S3_DDR: length 4.2
  BOTTOM w0.203: PUM1.7 92.05,24.99 92.67,24.36 v1(92.68,24.36) 92.71,24.33 92.71,24.32 PCM18.1 PRM11.2 PRM12.2
S5_DDR: length 6
  BOTTOM w0.203: PUM1.8 91.65,24.15 v2(91.67,24.13) 91.68,24.11 PCM17.1 PRM8.2 91.68,22.22 91.1,21.64 PDM2.2 91.1,20.94 PDM1.2
SA0_CHA_DIM1: length 6.5
  TOP w0.127: v1(169.7,37.72) 169.7,38.68 RD1.2 ; RD3.1 169.88,39.41 169.91,39.38
  TOP w0.137: RD3.1 170.54,39.77 170.68,39.63 v2(170.69,39.63) ; 169.91,39.38 RD1.2
  BOTTOM w0.135: 169.56,40.17 170.1,39.63 v2(170.69,39.63)
  BOTTOM w0.137: 169.56,40.17 169.37,40.36 169.37,40.79 169.77,41.19 JDIMM1.256
SA0_CHB_DIM2: length 8.8
  TOP w0.127: v2(168.28,31.06) 167.79,31.06 v1(167.43,31.42) 167.43,34.07 167.72,34.36 167.72,35.06 167.94,35.28 167.94,36.29 167.7,36.54 RD22.1 166.69,36.54 RD19.2
  BOTTOM w0.127: JDIMM2.256 v2(168.28,31.06)
SA1_CHA_DIM1: length 5.1
  TOP w0.137: RD4.2 168.86,41.68 RD5.1 169.31,41.87 v1(169.93,41.87) 171.34,41.87 v2(171.4,41.93)
  BOTTOM w0.137: JDIMM1.260 170.77,41.42 170.9,41.3 171.11,41.3 171.4,41.59 v2(171.4,41.93)
