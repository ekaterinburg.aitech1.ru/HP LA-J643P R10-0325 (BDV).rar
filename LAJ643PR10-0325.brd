# Allegro board LAJ643PR10-0325.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCH_CPU_24M_CLK_P: length 98.1
  IN3 w0.127: v2(203.72,46.81) 203.95,47.04 203.95,48.33 203.13,49.15 200.53,49.15 199.32,50.36 194.51,50.36 190.71,54.17 190.71,68.8 189.21,70.3 189.21,72.91 186.73,75.39 186.73,80.13 185.44,81.41 185.44,82.96 171.17,97.23 171.17,100.07 171.53,100.42 171.53,102.72 170.82,103.43 170.82,104.43 170.57,104.68 170.41,104.68 v2(170.32,104.58)
  BOTTOM w0.089: 168.86,104.51 168.84,104.51 168.81,104.54 168.39,104.54 168.08,104.86 167.95,104.86 167.55,104.46 165.75,104.46 165.55,104.66 165.55,104.85 165.45,104.94 UC1.E31 ; UH1.D7 211.32,39.07 211.32,39.59 211.43,39.7 211.43,40.73 212.36,41.67 212.36,42.82 212.08,43.1 212.08,43.36 212.05,43.39 212.05,43.41
  BOTTOM w0.127: 168.86,104.51 169.48,104.51 169.8,104.84 170.06,104.84 v2(170.32,104.58) ; 212.05,43.41 212.05,43.99 211.33,44.7 205.2,44.7 203.95,45.96 203.95,46.58 v2(203.72,46.81)
PCH_CPU_BCLK_N: length 95.9
  IN3 w0.127: v2(202.55,46.81) 202.39,46.81 202.23,46.97 202.23,48.49 202.05,48.67 200.19,48.67 198.95,49.91 194.35,49.91 190.27,53.99 190.27,68.52 187.51,71.28 187.51,73.41 186.3,74.62 186.3,79.95 184.89,81.36 184.89,82.76 170.74,96.91 170.74,100.25 171.09,100.6 171.09,102.54 169.67,103.97 169.67,104.18 168.73,105.11 168.73,105.61 168.86,105.74 169.14,105.74 169.22,105.66 v2(169.22,105.49)
  BOTTOM w0.089: UH1.C8 211.13,39.55 211.13,39.68 211.24,39.8 211.24,40.96 212.15,41.86 212.15,42.52 211.61,43.05 211.61,43.2 211.64,43.24 211.64,43.26 ; UC1.A32 167.91,105.33 168,105.25 168.16,105.25 168.22,105.31 168.22,105.6 168.29,105.67 168.37,105.67 168.45,105.75 168.62,105.75
  BOTTOM w0.127: v2(202.55,46.81) 202.38,46.81 202.23,46.66 202.23,46.39 204.45,44.17 211.22,44.17 211.64,43.74 211.64,43.26 ; 168.62,105.75 169.12,105.75 169.22,105.65 v2(169.22,105.49)
PCH_CPU_BCLK_P: length 95.9
  IN3 w0.127: v2(201.84,46.81) 201.97,46.94 201.97,48.38 201.94,48.41 200.08,48.41 198.84,49.65 194.25,49.65 190.02,53.88 190.02,68.41 187.26,71.17 187.26,73.3 186.04,74.52 186.04,79.84 184.63,81.26 184.63,82.66 170.48,96.8 170.48,100.35 170.84,100.71 170.84,102.43 169.41,103.86 169.41,104.07 168.48,105 168.48,105.72 168.76,106 169.02,106 v2(169.22,106.2)
  BOTTOM w0.089: UH1.B8 210.97,39.92 211.05,40.01 211.05,41.03 211.96,41.94 211.96,42.44 211.42,42.98 211.42,43.2 211.39,43.23 211.39,43.26 ; UC1.B31 167.58,105.26 167.58,105.52 167.75,105.69 168.04,105.69 168.21,105.86 168.29,105.86 168.37,105.94 168.37,105.94 168.44,106 168.62,106
  BOTTOM w0.127: v2(169.22,106.2) 169.03,106 168.62,106 ; v2(201.84,46.81) 201.98,46.67 201.98,46.28 204.34,43.91 211.11,43.91 211.39,43.64 211.39,43.26
PCH_CPU_PCIBCLK_N: length 98.3
  IN3 w0.127: v2(206.31,46.81) 206.08,47.04 206.08,47.94 203.93,50.09 201.29,50.09 200.05,51.33 194.94,51.33 191.65,54.62 191.65,69.19 191.05,69.79 191.05,70.93 190.4,71.58 190.4,73.28 187.68,76 187.68,82.16 186.18,83.66 186.18,84.37 172.12,98.43 172.12,99.68 172.47,100.03 172.47,103.11 171.81,103.77 171.81,105.16 169.33,107.64 v2(166,107.64)
  BOTTOM w0.089: 213.1,43.18 213.1,43.16 213.06,43.12 213.06,41.43 212.15,40.51 212.15,40.24 212.14,40.24 211.9,39.99 UH1.B6 ; v2(166,107.64) 166.02,107.66 UC1.C36
  BOTTOM w0.127: v2(206.31,46.81) 206.08,46.58 206.08,46.09 206.53,45.65 211.79,45.65 213.1,44.33 213.1,43.18
PCH_CPU_PCIBCLK_P: length 98.4
  IN3 w0.127: v2(166.53,107.06) 166.53,107.3 166.62,107.38 169.22,107.38 171.55,105.05 171.55,103.67 172.21,103.01 172.21,100.14 171.86,99.78 171.86,98.32 185.92,84.26 185.92,83.55 187.42,82.05 187.42,75.9 190.15,73.17 190.15,71.48 190.79,70.83 190.79,69.69 191.39,69.09 191.39,54.52 194.84,51.07 199.94,51.07 201.18,49.84 203.83,49.84 205.82,47.84 205.82,47.04 v2(205.6,46.81)
  BOTTOM w0.089: UC1.D35 165.68,107.17 165.57,107.06 165.57,106.94 165.68,106.84 166.45,106.84 166.53,106.92 v2(166.53,107.06) ; UH1.A6 211.93,40.45 211.96,40.47 211.96,40.59 212.87,41.51 212.87,43.12 212.84,43.16 212.84,43.18
  BOTTOM w0.127: v2(205.6,46.81) 205.82,46.58 205.82,45.99 206.42,45.39 211.68,45.39 212.84,44.23 212.84,43.18
PCH_CS_TPM: length 82.2
  TOP w0.127: v2(174.23,30.34) 174.23,28.65 178.83,24.05 v1(181.08,24.05) 181.43,24.05 182.79,22.69 185.75,22.69 186.54,23.48 187.17,23.48 188.25,22.41 191.98,22.41 192.25,22.14 193.68,22.14 194.29,22.74 194.97,22.74 v2(195.09,22.63) ; RTT7.1 129.51,16.66 130.36,17.52 v2(130.62,17.52)
  IN3 w0.127: v2(174.23,30.34) 173.37,29.49 169.68,29.49 169.23,29.03 150.69,29.03 150.14,28.48 149.88,28.48 149.02,27.63 141.52,27.63 141.08,28.06 135.05,28.06 133.7,26.71 133.7,25.33 132.5,24.13 132.5,23.44 131.05,21.99 131.05,20.15 130.43,19.53 130.43,17.71 v2(130.62,17.52)
  BOTTOM w0.089: v2(195.09,22.63) 195.32,22.85 UH1.AT40
PCH_CS_TPM_R: length 2.1
  TOP w0.127: RTT7.2 127.77,16.66 127.76,16.66 v1(126.95,16.66) UT1.20
PCH_DP1_CTRL_CLK: length 7.8
  TOP w0.127: RH33.2 210.09,23.77 209.54,23.23 v1(209.28,23.23) 208.83,23.67 208.83,24.69 208.6,24.92 208.2,24.92 v2(207.81,25.31)
  BOTTOM w0.127: UH1.AL13 207.81,25.49 v2(207.81,25.31)
PCH_DP1_CTRL_DATA: length 3.8
  TOP w0.127: RH34.2 213.01,23.01 212.54,23.48 211.24,23.48 v1(211.1,23.34) 211.01,23.24 v2(211.01,22.84)
  BOTTOM w0.127: UH1.AR8 v2(211.01,22.84)
PCH_DP1_HPD: length 65.3
  TOP w0.127: v2(50.8,30.24) 50.51,30.54 50.51,34.29 51.09,34.87 52.17,34.87 52.91,34.12 v1(53.19,34.12) 53.51,34.45 53.51,36.33 52.76,37.09 52.76,38.81 52.53,39.04 RU78.2 RU79.2 52.53,40.27 52.16,40.64 51.59,40.64 50.97,41.26 UU4.30
  IN3 w0.127: v2(24.72,51.6) 27.39,51.6 27.79,51.19 29.15,51.19 29.38,50.96 32.66,50.96 33.09,50.53 33.09,47.96 34.23,46.83 34.93,46.83 38.33,43.43 38.33,40.02 40.51,37.84 41.84,37.84 42.62,37.06 49.53,37.06 49.78,36.82 49.78,36.12 49.64,35.99 49.64,35.23 50.42,34.45 50.42,30.63 v2(50.8,30.24)
  BOTTOM w0.127: RT839.1 26.69,51.59 26.37,51.9 25.02,51.9 v2(24.72,51.6) 24.72,51.39 24.27,50.95 23.51,50.95 22.5,51.97 DT2.1
PCH_DP2_CTRL_CLK: length 1.7
  TOP w0.127: RH35.2 209.21,25.32 v2(208.41,25.32)
  BOTTOM w0.127: v2(208.41,25.32) 208.18,25.08 UH1.AN13
PCH_DP2_CTRL_DATA: length 3.1
  TOP w0.127: RH36.2 210.24,25.78 210.08,25.62 v2(210.08,25.18) v1(210.08,24.22)
  BOTTOM w0.127: UH1.AL10 209.68,25.58 v2(210.08,25.18)
PCH_DP2_HPD: length 303
  IN2 w0.127: v2(208.7,27.65) 208.06,27.01 208.06,26.74 207.42,26.1 205.63,26.1 205.3,25.77 200.47,25.77 200.16,26.07 200.16,26.56 200,26.72 200,26.72 199.89,26.83 198.66,26.83 198.41,27.09 195.89,27.09 194.29,28.69 188.92,28.69 187.48,27.25 186.05,27.25 184.72,28.58 182.92,28.58 180.37,26.03 179.8,26.03 175.6,21.83 161.05,21.83 160.43,22.44 152.76,22.44 151.22,20.9 146.8,20.9 146.29,20.39 141.52,20.39 140.97,19.83 137.99,19.83 137.18,19.03 132.54,19.03 131.57,20 130.66,20 130.42,19.76 124.27,19.76 123.45,18.95 121.57,18.95 121.45,18.83 119.42,18.83 117.79,17.2 116.8,17.2 116.18,17.81 112.82,17.81 108.78,21.85 99.89,21.85 99.44,21.4 98.42,21.4 97.7,20.67 95.79,20.67 95.47,20.99 95.12,20.99 94.81,20.67 90.67,20.67 87.49,23.86 83.61,23.86 81.7,25.77 81.7,26.74 81.46,26.99 64.14,26.99 62.18,25.03 60.74,25.03 60.37,24.67 58.77,24.67 54.39,29.05 54.39,32.91 55.61,34.13 55.61,35.57 56.08,36.04 56.08,40.17 55.52,40.72 54.69,40.72 54.38,41.03 49.09,41.03 48.56,40.5 44.27,40.5 43.96,40.81 43.96,41.14 38.64,46.47 38.31,46.47 34.68,50.1 34.3,50.1 33.32,51.09 30.17,51.09 29.74,51.53 27.9,51.53 27.41,52.02 26.25,52.02 24.24,54.03 23.13,54.03 22.76,54.4 22.76,55.17 20.89,57.03 20.89,61.23 17.94,64.18 17.94,65.43 19.4,66.9 19.4,70.42 19.64,70.65 19.64,72 17.69,73.95 17.69,75.24 16.98,75.95 16.98,82.13 16.65,82.45 16.65,84.51 17.37,85.22 17.37,96.67 16.65,97.38 16.65,106.5 17.37,107.21 17.37,114.32 17.11,114.58 16.67,114.58 15.47,115.78 15.47,117.77 15.82,118.12 v2(15.82,118.8)
  BOTTOM w0.127: v2(208.7,27.65) 208.37,27.32 208.37,26.25 208.5,26.12 208.5,25.78 209.68,24.6 UH1.AN10 ; v1(17.8,119.25) 17.58,119.46 QV1.3 16.61,119.97 16.69,120.06 RV38.2 16.59,120.51 15.95,119.87 15.95,118.93 v2(15.82,118.8)
PCH_DP3_CTRL_CLK: length 3.5
  TOP w0.127: RH38.2 212.64,25.3 212.24,24.9 v1(211.17,24.9) 210.9,24.9 v2(210.67,25.13)
  BOTTOM w0.127: v2(210.67,25.13) 210.41,25.38 UH1.AL9
PCH_DP3_CTRL_DATA: length 4.1
  TOP w0.127: RH37.2 212.47,24.53 v1(212.41,24.6) 212.41,24.61 212.38,24.64 211.91,24.64 v2(211.46,24.19)
  BOTTOM w0.127: UH1.AR3 212.16,23.51 211.91,23.76 211.9,23.76 v2(211.46,24.19)
PCH_DP3_HPD: length 2.4
  TOP w0.127: v2(210.09,23.09) 210.6,22.59 TH4953.1
  BOTTOM w0.127: UH1.AP9 210.41,23.42 v2(210.09,23.09)
PCH_DPWROK: length 64.7
  TOP w0.127: v2(140.71,18.41) 140.71,18.23 140.83,18.11 140.83,17.47 139.58,16.22 139.58,14.4 136.71,11.53 136.71,10.45 136.48,10.22 UK1.127 ; v2(181.69,21.94) 181.69,21.94 183.07,21.94 v1(183.14,22) 190.49,22 CK14.2 190.54,21.96 RH52.2
  IN3 w0.127: v2(140.71,18.41) 140.87,18.26 143.9,18.26 144.91,19.28 146.27,19.28 147.6,20.61 150.22,20.61 152.7,23.09 159.52,23.09 159.97,22.64 161.35,22.64 161.59,22.4 165.94,22.4 166.26,22.72 169.34,22.72 169.56,22.5 177.19,22.5 177.71,21.98 180.07,21.98 180.36,22.27 181.35,22.27 181.68,21.94 v2(181.69,21.94)
PCH_DPWROK_R: length 4.6
  TOP w0.127: v1(194.53,22.32) 194.16,21.96 v2(194.16,21.75) 193.58,21.75 192.61,20.78 RH50.2 191.62,20.78 RH52.1
  BOTTOM w0.127: v2(194.16,21.75) 194.44,21.75 UH1.AW41
PCH_ENBKL: length 65.3
  TOP w0.127: UK1.97 137.09,22.22 v2(137.37,22.5) ; v2(172.13,28.25) 173.65,28.25 179.12,22.78 179.98,22.78 v1(180.01,22.74) 180.05,22.78 182.31,22.78 182.71,22.38 186.14,22.38 v2(186.84,23.09)
  BOTTOM w0.102: 191.42,22.56 192.27,22.56 UH1.AV46
  BOTTOM w0.127: 191.42,22.56 190.73,22.56 189.98,23.31 189.78,23.31 189.41,23.68 189.28,23.68 188.9,24.06 188.13,24.06 RH204.1 ; v2(172.13,28.25) 172.13,26.72 171.65,26.24 166.42,26.24 165.22,25.04 165.09,25.04 165.08,25.02 165.07,25.02 165.06,25.01 165.02,25 164.31,25 163.09,23.79 163,23.79 148.02,23.79 147.42,23.18 147.09,23.18 145.63,23.18 145.63,23.18 138.05,23.18 v2(137.37,22.5)
  BOTTOM w0.135: RH204.1 186.84,24.23 v2(186.84,23.09)
PCH_ENVDD: length 173.9
  TOP w0.127: v2(72.11,31.73) 72.11,30.71 71.65,30.25 71.76,30.14 71.87,30.14 72.09,29.92 72.09,29.44 71.31,28.65 67.47,28.65 v3(67.4,28.58) 64.31,25.49 v2(63.35,25.49) ; v2(70.26,41.22) 70.52,40.97 RV47.1 71.28,40.54 71.47,40.34 UV1.1
  IN1 w0.127: v2(72.11,31.73) 72.11,31.56 71.55,31 69,31 68.41,31.59 68.41,39.37 70.26,41.21 v2(70.26,41.22)
  IN2 w0.127: v2(63.35,25.49) 65.02,23.83 65.02,21.71 65.28,21.45 66.77,21.45 67.1,21.12 67.1,20.15 67.12,20.12 73.98,20.12 75.34,21.48 83.91,21.48 86.88,18.52 101.49,18.52 102.11,17.9 107.77,17.9 108.07,17.6 110.33,17.6 113.19,14.74 118.11,14.74 118.98,15.61 120.99,15.61 121.41,16.03 127.28,16.03 127.76,16.52 131.03,16.52 131.24,16.73 131.79,16.73 132.07,16.44 134.35,16.44 135.63,15.16 140.77,15.16 142.71,17.1 150.12,17.1 152.21,19.19 168.2,19.19 168.95,19.94 177.49,19.94 181.2,23.65 184.16,23.65 184.3,23.51 187.83,23.51 188.35,22.99 v2(193.07,22.99)
  BOTTOM w0.122: UH1.AV44 193.07,22.14 v2(193.07,22.99)
PCH_ENVDD#: length 2.6
  TOP w0.127: v1(74.55,29.96) RV51.2
  TOP w0.254: RV51.2 74.54,30.9 QV7.3 73.55,30.25
PCH_GPP_B11: length 1.5
  TOP w0.135: TH129.1 199.82,24.47 v2(199.97,24.62)
  BOTTOM w0.127: v2(199.97,24.62) 200.49,24.11 UH1.AP29
PCH_GPP_J11: length 3.9
  TOP w0.127: RH273.1 206.54,21.46 v2(206.8,21.72)
  BOTTOM w0.127: UH1.AR13 207.88,23.36 207.88,22.39 207.51,22.01 207.09,22.01 v2(206.8,21.72)
PCH_GPP_K17: length 3.9
  BOTTOM w0.127: UH1.R47 191.83,33.72 190.82,33.72 190.47,34.06 189.36,34.06 188.68,33.37 TH128.1
PCH_JTAG_TCK1: length 4.6
  BOTTOM w0.102: UH1.AJ3 213.17,26.79 214.23,26.79 214.41,26.97 215.29,26.97 215.56,26.7
  BOTTOM w0.127: 215.56,26.7 v2(215.64,26.62) 215.89,26.38 217.31,26.38 RC391.1
PCH_PECI: length 4.5
  BOTTOM w0.102: UH1.AF2 214.19,28.41 215.78,28.41 v1(216.34,27.86) 216.86,27.34
  BOTTOM w0.127: RH13.1 217.12,27.07 216.86,27.34
PCH_PLTRST#: length 43.6
  TOP w0.102: RH7.1 217.28,9.55 217.62,9.89 UH3.2 218.05,10.61 218.17,10.61 218.27,10.51 UH3.1 218.27,9.55 217.53,8.81 v2(217.53,8.23) 217.53,7.66 v1(217.64,7.54)
  IN1 w0.127: v2(195.78,16.48) 196.51,15.74 198.68,15.74 199.77,16.83 203.17,16.83 203.78,16.22 203.78,16 204.21,15.57 204.21,15.06 207.34,11.92 207.34,11.57 207.83,11.08 209.06,11.08 209.57,10.57 215.42,10.57 215.7,10.28 215.7,10.05 v2(217.53,8.23)
  IN2 w0.127: v2(199.99,22.91) 200.06,22.91 200.44,22.54 200.44,21.82 200.32,21.71 200.32,19.74 199.4,18.81 197.75,18.81 196.37,17.42 196.37,16.67 196.17,16.48 v2(195.78,16.48)
  BOTTOM w0.102: v2(199.99,22.91) 200.48,22.42 UH1.AV29
PCH_PWR_EN: length 238.1
  TOP w0.127: v2(275.78,20.46) 273.68,22.57 v3(271.66,22.57) 269.44,22.57 267.54,24.46 v2(263.63,24.46) ; v2(136.82,18.34) 136.71,18.22 UK1.107 134.31,18.22 133.56,18.97 RK30.2 ; v2(180.89,7.02) 180.89,7.05 179.48,8.46 177.32,8.46 174.8,10.98 172.07,10.98 164.02,19.04 164.02,21.59 163.14,22.47 163.14,26.09 v2(163.13,26.1) ; v2(178,33.09) 177.79,32.87 U11.3
  IN2 w0.127: v2(153.77,4.8) 153.77,6.72 154.16,7.11 154.16,9.71 156.28,11.84 167.84,11.84 171.69,7.99 180.15,7.99 180.91,7.23 180.91,7.04 v2(180.89,7.02) 181.27,6.65 198.88,6.65 199.67,7.44 202.38,7.44 203.25,6.58 220.75,6.58 224.29,10.11 224.29,11.62 228.2,15.53 231.18,15.53 232.19,14.51 236.48,14.51 237.92,15.95 256.68,15.95 257.68,14.95 263.9,14.95 264.91,15.96 275.52,15.96 276.8,17.24 276.8,19.44 v2(275.78,20.46)
  IN3 w0.127: v2(178,33.09) 177.04,32.13 177.04,30.82 173.51,27.3 171.82,27.3 170.91,26.38 170.59,26.07 167.09,26.07 166.24,26.92 166.24,26.95 164.52,26.95 164.48,26.99 164.13,26.99 164.13,26.99 164.12,26.99 164.09,26.95 163.98,26.95 v2(163.13,26.1)
  BOTTOM w0.127: v2(263.63,24.46) 264.37,23.72 PR1804.1 ; v2(136.82,18.34) 136.82,17.57 137.09,17.3 138.16,17.3 138.57,16.9 138.57,15.86 137.99,15.28 137.99,11.24 143.25,5.98 153.13,5.98 153.77,5.34 v2(153.77,4.8)
PCH_PWROK: length 79.6
  TOP w0.127: v2(194.81,20.66) 194.78,20.66 v3(193.99,19.86) 193.94,19.81 193.94,18.09 CH73.2 ; CH73.2 193.35,17.55 RH210.2 ; CH73.2 193.55,17.35 DH2.2 ; v2(147.19,13.8) 147.19,14.05 147.5,14.35 148.01,14.35 148.19,14.18 148.19,13.17 147.77,12.75 147.77,11.62 148.06,11.33 148.97,11.33 150.12,10.18 150.12,9.58 149.64,9.09 UK1.32 149.64,7.17 RK20.2 148.19,6.56 CK10.1
  IN3 w0.127: v2(194.81,20.66) 194.98,20.66 195.63,20.01 195.63,19.2 197.48,17.35 197.48,16.11 196.93,15.57 194.71,15.57 193.23,14.09 190.5,14.09 190.16,14.44 180.78,14.44 180.06,15.16 180.06,16.13 178.61,17.58 153.74,17.58 151.88,15.72 151.2,15.72 150.12,14.64 147.88,14.64 147.19,13.95 v2(147.19,13.8)
  BOTTOM w0.127: v2(194.81,20.66) 194.51,20.66 UH1.AY42
PCH_RSMRST#: length 71.6
  TOP w0.102: v2(188.04,17.04) 188.04,16.87 188.38,16.53 189.31,16.53 189.9,15.95 CH108.1 190,16.33 189.95,16.38 RH212.2 190.33,16.76 190.81,16.28 DH2.1 191.22,16.02 191.01,15.81 DH3.2 ; v2(136.97,19.85) 136.89,19.94 136.89,20.7 136.56,21.02 UK1.100
  IN3 w0.127: v2(178.26,22.76) 176.63,24.39 173.75,24.39 173.37,24.76 172.45,24.76 171.52,23.83 166.16,23.83 165.9,24.1 164.9,24.1 164.25,23.45 162.03,23.45 161.79,23.69 160.41,23.69 159.96,24.14 152.27,24.14 149.79,21.66 147.17,21.66 145.84,20.32 137.45,20.32 v2(136.97,19.85)
  BOTTOM w0.102: v2(178.26,22.76) v1(179.56,21.46) 180.26,20.76 180.57,20.76 183.44,17.89 187.19,17.89 v2(188.04,17.04) 188.44,17.44 188.44,18.42 190.32,20.3 191.49,20.3 UH1.BA47
PCH_RTCRST#: length 22.2
  TOP w0.102: RH32.2 186.52,21.23 186.95,21.66 188.75,21.66 189.03,21.38 CLRP2.2 189.25,20.85 CH10.2 CH83.2 191.31,19.42 v2(191.49,19.42) ; QC11.6 v2(181.84,15.44) v3(181.13,16.15)
  IN3 w0.127: v2(191.49,19.42) 189.73,17.66 189.73,16.26 188.95,15.48 187.35,15.48 186.83,16.01 182.41,16.01 v2(181.84,15.44)
  BOTTOM w0.122: v2(191.49,19.42) 191.64,19.27 UH1.BE47
PCH_RTCX1: length 6.2
  BOTTOM w0.127: YH2.2 185.36,21.07 186.08,20.34 CH6.1 187.04,20.34 187.16,20.47 RH19.1 187.76,20.47 188.07,20.78 UH1.BA49
PCH_RTCX2: length 7.1
  BOTTOM w0.102: 189.98,20.54 191.15,20.54 UH1.BA48
  BOTTOM w0.127: YH2.1 185.37,18.57 186.26,19.45 CH7.1 186.93,19.45 187.02,19.55 RH19.2 187.91,19.97 187.91,20.1 188.35,20.54 189.98,20.54
PCH_SERIRQ: length 11.8
  TOP w0.102: v2(196.7,20.84) 196.7,20.47 196.17,19.94 196.17,16.09 v1(195.9,15.82)
  TOP w0.127: RH65.1 194.39,13.04 194.2,13.23 193.63,13.23 193.51,13.35 193.51,13.87 194.14,14.5 194.9,14.5 195.52,15.12 195.52,15.44 v1(195.9,15.82)
  BOTTOM w0.127: UH1.AW35 197.31,21.35 197.21,21.35 v2(196.7,20.84)
PCH_SMBCLK: length 16.1
  TOP w0.102: 203.33,17.25 202.9,17.68 202.9,19.2 202.99,19.3 202.99,19.72 v2(202.58,20.13)
  TOP w0.127: RH226.1 205.46,8.66 QC7.1 204.26,9.08 204.26,10.26 204.97,10.97 v1(204.97,11.28) 204.97,11.49 205.5,12.03 205.5,13.09 205.61,13.2 205.61,13.95 204.93,14.63 204.45,14.63 203.94,15.14 QC8.6 203.94,15.8 203.84,15.9 203.84,16.74 203.33,17.25
  BOTTOM w0.102: UH1.BE26 202.2,19.44 202.2,19.74 v2(202.58,20.13)
PCH_SMBDATA: length 14.1
  TOP w0.102: v2(202.6,19.52) 202.7,19.42 202.7,17.48 202.93,17.25 202.93,16.95
  TOP w0.127: QC7.4 203.31,10.49 203.31,10.6 RH227.1 204.05,10.92 204.09,10.88 204.5,10.88 204.65,11.03 204.65,11.5 205.27,12.12 205.27,13.45 QC8.3 205.24,13.71 204.82,14.13 203.88,14.13 202.93,15.09 v1(202.93,16.67) 202.93,16.95
  BOTTOM w0.102: v2(202.6,19.52) 202.59,19.52 202.08,19.01 202.08,18.61 UH1.BF26
PCH_SML0ALERT#: length 4.2
  BOTTOM w0.127: RH97.2 204.32,15.49 v1(204.19,15.62) 203.82,15.99 203.82,16.18 203.03,16.97 UH1.BF24
PCH_SML0CLK: length 4.4
  BOTTOM w0.127: RH225.1 v1(202.9,15.68) 202.9,16.39 202.62,16.68 202.2,16.68 202.09,16.79 201.97,16.92 201.97,17.76 UH1.BF25
PCH_SML0DATA: length 5.5
  BOTTOM w0.102: 201.96,16.62 201.76,16.81 201.76,17.89 202.27,18.4 202.27,18.93 202.44,19.1 203.13,19.1 UH1.BE24
  BOTTOM w0.127: 201.96,16.62 202.14,16.44 RH224.1
PCH_SML1ALERT#: length 4.9
  BOTTOM w0.127: RH63.2 198.66,15.22 199.09,15.66 199.09,17.1 198.9,17.3 198.9,17.93 198.74,18.09 198.74,19.03 UH1.BD33
PCH_SML1CLK: length 38.8
  TOP w0.127: v2(201.76,16.28) 201.76,15.95 202.39,15.31 RH223.1 ; v2(224.97,10.71) v1(225.89,10.71) 226.9,10.71 228.42,12.23 QC9.1
  IN1 w0.127: v2(224.97,10.71) 222.71,8.45 221.86,8.45 220.91,7.51 216.25,7.51 214.6,9.15 209.48,9.15 209.28,9.36 206.66,9.36 205.29,10.73 205.29,11.75 204.31,12.72 202.08,12.72 201.56,13.25 201.56,15.93 201.76,16.13 v2(201.76,16.28)
  BOTTOM w0.102: v2(201.76,16.28) 201.57,16.46 201.57,18.15 UH1.BF27
PCH_SML1DATA: length 40.6
  TOP w0.127: v2(201.19,16.41) 201.17,16.39 201.17,15.59 RH222.1 ; v2(224.97,10.1) 224.54,10.53 224.54,11.53 v1(225.39,12.38) 225.39,12.57 226.35,13.53 QC9.4
  IN1 w0.127: v2(201.19,16.41) 201.19,16.32 201.12,16.25 201.12,13.07 201.9,12.29 204.13,12.29 204.85,11.57 204.85,10.55 206.48,8.93 209.1,8.93 209.3,8.72 214.43,8.72 216.07,7.07 221.09,7.07 222.03,8.02 222.89,8.02 v2(224.97,10.1)
  BOTTOM w0.102: UH1.BE27 201.05,18.66 201.05,18.19 201.38,17.86 201.38,17.05 201.17,16.84 201.17,16.42 v2(201.19,16.41)
PCH_SPI_CLK: length 106.3
  TOP w0.127: v2(129.57,16.03) 129.44,15.9 RTT6.1
  IN3 w0.127: v2(129.57,16.03) 129.57,16.8 130,17.23 130,17.83 129.67,18.15 129.33,18.15 128.71,18.78 128.71,19.18 129.92,20.39 129.92,22.12 131.47,23.67 131.47,24.33 132.83,25.69 132.83,28.06 133.73,28.96 148.77,28.96 149.16,29.35 149.67,29.35 150.22,29.9 168.87,29.9 169.32,30.35 171.73,30.35 173.47,32.09 174.77,32.09 177.86,35.18 180.1,35.18 180.45,34.82 v2(181.05,34.82) 181.09,34.86 181.09,40.16 179.85,41.4 179.85,42.88 182.41,45.45 182.41,46.43 v2(180.83,48.02)
  BOTTOM w0.089: 189.02,22.66 189.75,22.66 190.52,21.89 191.04,21.89 191.22,21.7 191.82,21.7 UH1.AW47
  BOTTOM w0.127: 189.02,22.66 186.37,22.66 186.08,22.94 186.08,23.72 CH65.2 184.93,24.88 184.93,28.82 185.04,28.94 185.04,32.8 183.02,34.82 182.75,34.82 182.63,34.95 182.63,35.73 182.49,35.87 182.11,35.87 181.99,35.75 181.99,34.95 181.86,34.82 v2(181.05,34.82) ; v2(180.83,48.02) 181.09,48.28 RH2.1
PCH_SPI_CLK_R: length 4.5
  BOTTOM w0.127: RH243.1 182.32,48.28 RH2.2 CH3.1 184.01,51 UH2.6
PCH_SPI_CLK_TPM: length 2.2
  TOP w0.127: UT1.19 127.21,16.16 127.47,15.9 RTT6.2
PCH_SPI_CS#0: length 34.5
  TOP w0.127: v2(184.35,44.78) 184.84,44.29 184.84,35.12 184.54,34.82 v1(184.54,34.33) v2(183.71,33.49)
  BOTTOM w0.089: 189.02,22.45 189.7,22.45 190.43,21.71 190.96,21.71 191.15,21.53 191.51,21.53 191.72,21.32 UH1.AY47
  BOTTOM w0.127: RH259.1 185.85,44.26 RH242.1 184.87,44.26 v2(184.35,44.78) ; 189.02,22.45 184.87,22.45 184.1,23.21 RH175.2 183.76,23.21 181.9,25.07 181.9,27.55 183.02,28.67 183.02,33.05 183.46,33.49 v2(183.71,33.49)
PCH_SPI_CS#0_R: length 11.3
  BOTTOM w0.127: UH2.1 190.79,53.54 v2(187.58,50.33) 186.82,49.57 186.82,46.7 185.86,45.74 RH259.2
PCH_SPI_HOLD#: length 44.8
  TOP w0.127: v2(182.36,49.96) 183.09,49.23 183.09,47.39 183.72,46.76 183.72,44.89 182.61,43.77 182.61,42.97 182.76,42.82 v3(182.76,37.04) 182.76,35.77 180.91,33.93 v2(179.83,33.93)
  BOTTOM w0.076: 190.13,21.18 190.74,21.18 191.03,20.89 191.94,20.89 UH1.BA46
  BOTTOM w0.127: v2(179.83,33.93) 180.3,33.46 181.26,33.46 181.72,33 181.72,29.21 180.6,28.09 180.6,24.54 183.34,21.8 188.6,21.8 189.21,21.18 190.13,21.18 ; RH238.1 181.41,50.91 v2(182.36,49.96)
PCH_SPI_HOLD#_R: length 3.6
  BOTTOM w0.127: RH238.2 182.33,51.49 182.35,51.51 RH176.1 182.35,52.23 182.33,52.25 RH4.1 182.89,52.47 183.1,52.27 UH2.7
PCH_SPI_SI: length 107.4
  TOP w0.127: v2(181.49,43.3) 182.33,42.47 182.33,36.54 181.37,35.58 v1(175.4,35.58) 175.11,35.58 v2(174.02,34.5) 174.66,33.86 174.66,28.83 179.01,24.48 181.61,24.48 182.61,23.48 185.32,23.48 185.63,23.78 RH98.1 186.95,24.03 188.34,22.63 192.08,22.63 192.35,22.37 193.59,22.37 194.33,23.11 v2(194.33,23.27) ; RTT8.1 129.35,17.42 v2(129.46,17.52)
  IN3 w0.127: v2(129.46,17.52) 129.44,17.54 129.32,17.54 128.27,18.58 128.27,19.36 129.39,20.48 129.39,22.31 130.95,23.87 130.95,24.42 132.4,25.87 132.4,28.27 133.53,29.4 148.59,29.4 148.98,29.78 149.47,29.78 150.02,30.33 168.69,30.33 169.14,30.79 170.31,30.79 v2(174.02,34.5)
  BOTTOM w0.089: v2(194.33,23.27) 194.33,22.94 UH1.AU41
  BOTTOM w0.127: RH236.1 181.44,45.96 181.23,45.75 181.23,43.57 v2(181.49,43.3)
PCH_SPI_SI_R: length 7.2
  BOTTOM w0.127: UH2.5 183.59,49.73 183.24,49.38 183.24,47.17 RH236.2 182.35,45.21 v2(182.87,44.69) 183.19,44.69 RH240.1
PCH_SPI_SI_TPM: length 2.2
  TOP w0.127: RTT8.2 127.47,17.42 127.22,17.16 UT1.21
PCH_SPI_SO: length 98.7
  TOP w0.127: v2(129.14,18.97) 129.04,19.07 RTT9.1
  IN3 w0.127: v2(129.14,18.97) 130.35,20.18 130.35,21.93 131.97,23.55 131.97,24.22 133.27,25.51 133.27,26.97 134.83,28.53 148.95,28.53 149.34,28.92 149.88,28.92 150.43,29.47 169.05,29.47 169.5,29.92 173.12,29.92 174.36,31.16 174.45,31.16 177.99,34.7 v2(179.84,34.7)
  BOTTOM w0.089: 189.16,22.01 189.62,22.01 190.29,21.35 190.82,21.35 191.11,21.06 192.49,21.06 UH1.BA45
  BOTTOM w0.127: 189.16,22.01 184.6,22.01 184.38,22.23 183.52,22.23 181.04,24.72 181.04,27.91 182.15,29.03 v1(182.15,30.58) 182.15,33.27 181.53,33.89 180.64,33.89 v2(179.84,34.7) 179.84,34.92 183.99,39.08 183.99,41.54 185.08,42.63 185.62,42.63 186.19,43.2 186.74,43.2 187.42,43.88 RH237.1
PCH_SPI_SO_R: length 9.9
  BOTTOM w0.127: RH241.1 RH237.2 187.42,48.62 v2(189.9,51.09) 191.07,52.27 UH2.2
PCH_SPI_SO_TPM: length 1.8
  TOP w0.127: UT1.24 126.56,18.66 126.97,19.07 RTT9.2
PCH_SPI_WP#: length 33.9
  BOTTOM w0.089: UH1.AY48 191.1,21.32 190.89,21.53 190.36,21.53 189.66,22.23 189.02,22.23
  BOTTOM w0.127: RH239.1 186.33,42.73 185.8,42.2 185.26,42.2 184.42,41.36 184.42,38.9 180.6,35.08 180.6,34.58 180.86,34.32 181.71,34.32 182.58,33.45 v1(182.58,32.9) 182.58,28.85 181.47,27.73 181.47,24.89 183.7,22.66 184.26,22.66 184.69,22.23 189.02,22.23
PCH_SPI_WP#_R: length 10.3
  BOTTOM w0.127: UH2.3 191.02,51 189.25,49.22 189.25,48.54 v2(189.14,48.44) 188.37,47.67 RH3.1 187.93,44.71 187.93,43.46 187.55,43.08 RH239.2
PCH_SRTCRST#: length 26.5
  TOP w0.127: v2(192.11,20.18) 192.07,20.18 191.93,20.04 191.93,19.33 192.03,19.23 CH82.2 191.98,18.9 CH9.2 191.17,18.9 190.71,18.44 189.08,18.44 CLRP1.2 188.45,18.51 188.02,18.51 RH31.2 ; QC11.3 183.14,13.38 182.73,13.79 181.11,13.79 180.8,14.1 v1(180.8,14.3) 180.8,15.11 v2(181.13,15.44)
  IN3 w0.127: v2(181.13,15.44) 181.13,15.79 181.86,16.51 188.16,16.51 188.8,17.15 188.8,18.83 189.78,19.82 191.74,19.82 v2(192.11,20.18)
  BOTTOM w0.127: UH1.BD46 191.96,19.18 191.96,20.04 v2(192.11,20.18)
PCH_SUSWARN#: length 66.7
  TOP w0.127: v2(146.52,13.89) 146.52,13.57 143.02,10.07 143.02,9.65 143.26,9.41 143.48,9.41 143.64,9.25 UK1.17
  IN3 w0.127: v2(146.52,13.89) 147.54,14.91 149.87,14.91 152.81,17.85 178.73,17.85 180.33,16.24 180.33,15.27 180.89,14.71 190.27,14.71 190.61,14.36 193.12,14.36 194.55,15.79 195.99,15.79 v2(197.08,16.89)
  BOTTOM w0.102: UH1.BC37 196.61,19.64 196.61,18.28 196.74,18.16 196.74,17.24 v2(197.08,16.89)
  BOTTOM w0.127: v1(146.85,14.59) 146.52,14.26 v2(146.52,13.89)
PCH_THERMTRIP#: length 4.6
  BOTTOM w0.102: RH158.1 216.79,29.18 v1(216.37,29.18) 215.73,29.18 215.36,28.81 214,28.81 213.94,28.87 213.53,28.87 UH1.AD3
PCH_THERMTRIP#_R: length 167.5
  TOP w0.127: RH166.2 219.05,28.47 v2(218.93,28.34) ; RC45.1 175.95,101.82 v2(176.25,101.52)
  IN2 w0.127: v2(237.64,42.63) 232.68,42.63 231.53,41.48 225.35,41.48 217.72,49.11 196.1,49.11 196.06,49.16 195.05,49.16 188.72,55.49 188.72,68.09 188.28,68.53 186.67,70.14 186.67,80.11 187.58,81.02 187.58,83.88 187.95,84.25 187.95,85.94 188.82,86.81 188.82,93.68 187.36,95.13 185.22,95.13 184.61,94.52 178.42,94.52 177.42,95.52 177.42,100.86 176.84,101.45 176.32,101.45 v2(176.25,101.52) ; v2(246.65,38.12) 246.59,38.06 246.59,37.49 245.7,36.6 241.78,36.6 223.82,36.6 221.78,34.56 221.78,32.62 218.93,29.77 v2(218.93,28.34)
  IN3 w0.127: v2(246.65,38.12) 246.65,38.12 247.5,38.12 248.07,38.69 248.07,38.95 247.7,39.31 245.5,39.31 244.36,38.17 239.52,38.17 237.64,40.05 v2(237.64,42.63)
  BOTTOM w0.127: RH158.2 218.67,28.6 v2(218.93,28.34)
PCH_TRIGOUT: length 4.9
  BOTTOM w0.102: UH1.AK3 213.15,26.13 213.9,26.13 214.14,25.89 214.99,25.89 215.27,26.18 216.5,26.18 RH1.1
PCH_TRIGOUT_R: length 118.9
  IN1 w0.127: v2(180.4,68.5) 180.4,68.57 182.85,71.02 182.85,78.28 181.95,79.18 181.95,81.32 180.74,82.53 180.74,84.12 169.73,95.13 169.73,95.34 169.18,95.9 169.18,96.37 167.86,97.68 166.42,97.68 165.3,98.8 164.85,98.8 164.62,98.58 164.06,98.58 163.62,99.02 v2(163.62,99.06)
  BOTTOM w0.127: UC1.H23 v2(163.62,99.06) ; v2(180.4,68.5) 180.4,68.2 180.7,67.89 v1(181.3,67.89) 181.77,67.89 184.36,65.3 184.36,62.52 189.26,57.62 190.11,57.62 193.3,54.42 193.3,50.03 195.32,48.01 200.39,48.01 201.08,47.32 209.84,47.32 210.32,46.84 217.12,46.84 218.52,45.44 220.31,45.44 221.43,44.31 221.43,42.73 222.67,41.49 222.67,31.78 220.58,29.69 220.58,27.28 218.59,25.3 RH1.2
PCH_VRALERT#: length 3.7
  BOTTOM w0.102: 199.47,17.99 199.35,18.11 199.35,18.67 UH1.BE32
  BOTTOM w0.127: 199.47,17.99 199.47,17.42 199.8,17.09 199.8,16.08 TH125.1
PCH_XDP_CLK_R_DN: length 1.9
  TOP w0.127: v2(212.74,30.12) 212.74,30.34 TC305.1
  BOTTOM w0.089: v2(212.74,30.12) 212.74,30.43 UH1.Y3
PCH_XDP_CLK_R_DP: length 1.8
  TOP w0.127: v2(212.16,30.12) 212.16,30.35 TC306.1
  BOTTOM w0.089: v2(212.16,30.12) 212.81,30.77 UH1.Y4
PCIE_PRX_C_DTX_N14: length 3.8
  BOTTOM w0.127: UL1.18 56.71,17.45 57.14,17.02 58.06,17.02 v4(58.36,16.71) 58.89,16.19 59.17,16.19 CR13.2
PCIE_PRX_C_DTX_N15: length 2.8
  BOTTOM w0.127: UR1.8 40.21,14.39 40.28,14.32 40.28,14.19 40.11,14.02 39.4,14.02 39.03,13.65 39.03,13.36 CR15.2
PCIE_PRX_C_DTX_P14: length 3.8
  BOTTOM w0.127: CR11.2 59.57,16.68 59.57,16.53 59.49,16.45 59.03,16.45 58.56,16.91 58.16,17.32 57.2,17.32 57.11,17.41 UL1.17
PCIE_PRX_C_DTX_P15: length 2.8
  BOTTOM w0.127: CR14.2 39.29,13.4 39.29,13.54 39.51,13.76 40.21,13.76 40.53,14.08 40.53,14.28 40.61,14.35 UR1.7
PCIE_PRX_DTX_N9: length 195.4
  IN1 w0.135: v2(34.03,11.14) 34.2,10.97 34.57,10.97 34.94,11.34 34.94,11.34 35.35,11.75 35.93,11.75 36.62,11.06 46.05,11.06 47.33,12.34 56.86,12.34 61.3,16.78 79.42,16.78 81.93,14.27 81.93,13.6 83.91,11.62 85.54,11.62 87.92,9.24 89.62,9.24 91.03,7.83 106.44,7.83 108.69,10.08 111.37,10.08 112.94,8.51 114.93,8.51 121.87,8.51 122.26,8.89 122.26,9.29 122.73,9.76 134.87,9.76 135.15,10.03 139.01,10.03 140.38,11.39 151.26,11.39 152.63,12.76 153.2,12.76 155.09,14.65 172.21,14.65 172.35,14.51 173.47,14.51 177.39,18.43 178.13,18.43 179.89,20.2 180.75,20.2 185.59,25.04 185.59,26.79 186.04,27.24 186.67,27.24 187.22,27.79 187.22,28.18 188.82,29.78 188.82,37.55 189.34,38.07 189.68,38.07 191.26,39.65 191.97,39.65 192.84,38.78 193.25,38.78 193.56,39.09 196.16,39.09 197.06,38.19 197.06,37.79 196.82,37.55 v2(196.82,37.41)
  BOTTOM w0.127: JSSD1.5 34.85,10.53 34.57,10.81 34.19,10.81 34.03,10.97 v2(34.03,11.14) ; v2(196.82,37.41) 196.85,37.35 197.2,37.21 UH1.G36
PCIE_PRX_DTX_N10: length 203.7
  IN1 w0.135: v2(31.97,6.63) 31.77,6.63 31.68,6.72 31.68,6.96 31.82,7.11 36.57,7.11 37.65,6.03 45.63,6.03 48.78,9.18 59.56,9.18 63.91,13.54 72.4,13.54 73.49,12.45 77.05,12.45 78.5,10.99 79.17,10.99 83.85,6.31 83.85,5.65 84.86,4.64 138.95,4.64 139.75,5.44 141.04,5.44 141.49,5.89 154.1,5.89 155.66,7.46 155.66,8.73 157,10.06 167.51,10.06 168.89,8.68 172.62,8.68 173.41,7.88 174.94,7.88 176.98,9.92 180.09,9.92 182.71,12.54 189.51,12.54 190.97,14 190.97,15.91 191.44,16.38 191.44,18.31 191,18.75 191,19.73 192.23,20.96 192.23,24.12 193.04,24.94 193.04,26.02 193.48,26.46 193.99,26.46 195.58,28.05 195.58,33.22 194.31,34.49 194.31,34.83 194.89,35.41 195.45,35.41 195.82,35.78 196.18,35.78 v2(196.28,35.68)
  BOTTOM w0.127: JSSD1.17 31.85,8.41 31.74,8.3 31.74,6.86 v2(31.97,6.63) ; UH1.K37 196.45,35.86 v2(196.28,35.68)
PCIE_PRX_DTX_N11: length 202.9
  IN1 w0.135: v2(28.92,7.72) 28.92,7.77 28.63,8.05 28.63,8.17 29.08,8.62 36.08,8.62 37.95,6.75 45.32,6.75 48.47,9.9 59.06,9.9 63.48,14.32 72.63,14.32 73.32,13.64 77.21,13.64 78.4,12.44 79,12.44 83.82,7.62 84.93,7.62 87.19,5.36 135.95,5.36 136.75,6.16 140.62,6.16 141.09,6.63 153.82,6.63 154.95,7.76 154.95,9.02 156.7,10.78 167.81,10.78 169.2,9.39 175.24,9.39 176.48,10.64 177.79,10.64 180.4,13.26 187.05,13.26 187.93,14.14 188.62,14.14 190.25,15.77 190.25,17.27 189.75,17.77 189.75,19.27 190.11,19.63 190.11,20.34 191.51,21.74 191.51,24.42 191.86,24.77 191.86,26.04 192.84,27.02 192.84,27.41 193.97,28.54 193.97,34.06 193.61,34.42 193.61,35.03 195.32,36.74 195.67,36.74 v2(195.71,36.7)
  BOTTOM w0.127: v2(195.71,36.7) 195.95,36.7 196.02,36.77 UH1.G38 ; JSSD1.29 28.85,8.41 28.76,8.32 28.76,7.88 v2(28.92,7.72)
PCIE_PRX_DTX_N12: length 207
  IN1 w0.135: v2(194.15,36.52) 193.95,36.52 192.75,35.31 192.75,29.03 191.76,28.04 191.76,27.22 191.14,26.61 191.14,25.18 190.33,24.36 189.83,24.36 189.45,23.98 189.45,22.23 189,21.78 189,20.87 189.2,20.67 189.2,19.76 189,19.56 189,17.39 189.34,17.05 189.34,15.87 188.39,14.93 187.55,14.93 186.6,13.98 180.1,13.98 177.49,11.36 176.15,11.36 174.91,10.11 169.49,10.11 168.11,11.5 156.4,11.5 154.23,9.32 154.23,8.21 153.37,7.35 140.79,7.35 140.32,6.88 136.46,6.88 135.65,6.07 88.36,6.07 87.06,7.37 86.29,7.37 85.24,8.43 84.54,8.43 80.21,12.76 80.21,13.39 79.23,14.37 73.6,14.37 72.91,15.06 63.17,15.06 58.72,10.62 48.14,10.62 45.09,7.57 41.16,7.57 39.95,8.78 39.33,8.78 38.53,7.98 38.53,7.71 38.67,7.58 39.01,7.58 v2(39.07,7.64)
  BOTTOM w0.089: v2(194.15,36.52) 193.97,36.7 UH1.H42
  BOTTOM w0.127: v2(39.07,7.64) 38.82,7.64 37.06,5.89 33.54,5.89 33,5.35 27.46,5.35 25.35,7.46 JSSD1.43
PCIE_PRX_DTX_N14: length 159.1
  IN1 w0.135: v2(192.05,38.58) 190.39,36.91 190.39,32.98 189.91,32.51 189.91,29.46 188.22,27.77 188.22,27.14 186.94,25.85 186.94,24.94 185.64,23.65 185.64,22.64 184.96,21.96 183.93,21.96 178.19,16.22 178.19,15.14 176.56,13.52 171.94,13.52 171.8,13.65 155.51,13.65 153.62,11.76 153.04,11.76 151.67,10.4 140.79,10.4 139.43,9.03 135.56,9.03 135.29,8.76 124.22,8.76 123.38,7.92 122.97,7.92 122.55,7.51 111.05,7.51 110.05,8.51 110.05,8.88 110.01,8.92 v2(109.91,9.02)
  BOTTOM w0.127: v2(109.91,9.02) 110.17,9.02 110.32,9.17 110.32,9.45 109.92,9.84 106.19,9.84 104.52,11.51 102.78,11.51 101.11,13.19 101.11,14.1 98.52,16.68 82.56,16.68 80.55,18.69 65.78,18.69 63.43,16.34 60.4,16.34 60.32,16.26 CR13.1 ; v2(192.05,38.58) 192.09,38.61 192.09,39.02 UH1.D46
PCIE_PRX_DTX_N15: length 185.7
  IN1 w0.135: v2(41.1,9.93) 41.26,9.77 41.26,9.57 42.49,8.34 44.84,8.34 47.84,11.34 58.42,11.34 62.87,15.78 73.21,15.78 73.9,15.09 79.52,15.09 80.93,13.68 80.93,13.08 84.74,9.26 86.48,9.26 88.95,6.79 122.85,6.79 123.26,7.21 123.68,7.21 124.52,8.04 135.59,8.04 135.86,8.31 139.72,8.31 140.52,9.11 151.98,9.11 155.8,12.93 171.5,12.93 171.64,12.8 176.89,12.8 180.18,16.09 185.25,16.09 186.67,17.5 186.67,22.25 186.42,22.49 186.42,23.27 189.69,26.54 189.69,28.22 191.24,29.77 191.24,35.88 192.23,36.87 192.23,37.12 v2(192.82,37.71)
  BOTTOM w0.127: v2(41.1,9.93) 41.29,10.12 41.29,10.39 40.76,10.93 39.52,10.93 39.05,11.39 39.05,11.83 CR15.1 ; UH1.F44 193.32,37.71 v2(192.82,37.71)
PCIE_PRX_DTX_N16: length 166.1
  IN1 w0.135: v2(310.66,25.17) 310.49,25.33 310.49,25.82 311.45,26.77 311.45,28.1 310.8,28.75 310.8,30.24 311.59,31.02 311.59,39.08 308,42.67 287.91,42.67 286.73,41.49 272.72,41.49 271.81,42.39 265.84,42.39 265.43,41.98 262.95,41.98 261.77,40.81 258.21,40.81 257.57,41.45 255.55,41.45 255.17,41.83 254.82,41.83 253.72,42.93 249.07,42.93 248.3,43.7 242.71,43.7 241.4,42.38 238.64,42.38 238.2,41.94 236.84,41.94 236.4,42.38 234.36,42.38 233.38,41.4 231.97,41.4 231.55,40.99 230.54,40.99 230.04,40.48 222.23,40.48 218.98,43.74 214.62,43.74 213.84,44.52 210.38,44.52 209.83,43.97 203,43.97 202.32,43.3 202.32,41.12 201.76,40.56 201.14,40.56 199.83,39.25 199.06,39.25 198.37,38.56 198.37,36.9 197.79,36.33 197.79,35.54 196.82,34.57 196.04,34.57 195.61,35 195.15,35 194.82,34.67 v2(194.71,34.67)
  BOTTOM w0.127: UH1.L41 194.71,35.39 v2(194.71,34.67) ; v2(310.66,25.17) 310.51,25.17 310.46,25.11 310.07,24.72 309.08,24.72 308.54,24.18 307.14,24.18 306.6,23.64 306.6,22.09 307.09,21.6 307.09,20.84 308.07,19.87 308.07,17.45 307.66,17.04 307.66,16.1 306.29,14.73 304.57,14.73 304.09,14.24 303.84,14.24 303.7,14.1 JWLAN1.35
PCIE_PRX_DTX_P9: length 195.4
  IN1 w0.135: v2(196.37,37.9) 196.51,37.76 196.63,37.76 196.78,37.9 196.78,38.08 196.05,38.81 193.68,38.81 193.36,38.5 192.72,38.5 191.85,39.37 191.38,39.37 189.8,37.79 189.45,37.79 189.1,37.43 189.1,29.66 187.5,28.07 187.5,27.68 186.79,26.96 186.16,26.96 185.87,26.68 185.87,24.92 180.86,19.92 180.01,19.92 178.24,18.15 177.5,18.15 173.58,14.24 172.24,14.24 172.1,14.37 155.21,14.37 153.32,12.48 152.74,12.48 151.38,11.11 140.49,11.11 139.13,9.75 135.26,9.75 134.99,9.48 122.84,9.48 122.54,9.17 122.54,8.78 121.99,8.23 114.93,8.23 112.83,8.23 111.26,9.8 108.81,9.8 106.56,7.55 90.91,7.55 89.51,8.96 87.81,8.96 85.42,11.34 83.79,11.34 81.65,13.49 81.65,14.15 79.3,16.5 61.42,16.5 56.97,12.06 47.44,12.06 46.17,10.78 36.51,10.78 35.82,11.47 35.47,11.47 35.22,11.22 35.22,11.22 34.69,10.69 34.05,10.69 34.03,10.72 33.74,10.72 v2(33.57,10.55)
  BOTTOM w0.127: UH1.F36 v2(196.37,37.9) ; JSSD1.7 34.35,10.03 34.59,10.28 34.59,10.42 34.47,10.55 34.09,10.55 33.94,10.69 33.71,10.69 v2(33.57,10.55)
PCIE_PRX_DTX_P10: length 203.8
  IN1 w0.135: v2(195.98,36.18) 195.85,36.06 195.7,36.06 195.34,35.69 194.78,35.69 194.03,34.95 194.03,34.37 195.3,33.1 195.3,28.16 193.87,26.74 193.37,26.74 192.76,26.13 192.76,25.05 191.95,24.24 191.95,21.07 190.72,19.85 190.72,18.64 191.16,18.2 191.16,16.5 190.69,16.03 190.69,14.12 189.39,12.82 182.59,12.82 179.98,10.2 176.87,10.2 174.83,8.16 173.53,8.16 172.73,8.96 169,8.96 167.62,10.34 156.88,10.34 155.39,8.84 155.39,7.58 153.98,6.17 141.38,6.17 140.92,5.72 139.63,5.72 138.83,4.92 84.97,4.92 84.13,5.76 84.13,6.43 79.29,11.27 78.62,11.27 77.16,12.73 73.61,12.73 72.52,13.82 63.8,13.82 59.44,9.46 48.67,9.46 45.51,6.31 37.77,6.31 36.69,7.39 31.71,7.39 31.4,7.08 31.4,6.77 v2(31.26,6.63)
  BOTTOM w0.127: UH1.J37 v2(195.98,36.18) ; JSSD1.19 31.35,8.41 31.48,8.28 31.48,6.85 v2(31.26,6.63)
PCIE_PRX_DTX_P11: length 202.9
  IN1 w0.135: v2(195.34,37.15) 193.33,35.14 193.33,34.3 193.69,33.95 193.69,28.66 192.56,27.53 192.56,27.13 191.58,26.16 191.58,24.89 191.23,24.53 191.23,21.85 189.83,20.45 189.83,19.75 189.47,19.39 189.47,17.66 189.97,17.16 189.97,15.89 188.5,14.42 187.82,14.42 186.94,13.54 180.29,13.54 177.67,10.92 176.37,10.92 175.12,9.67 169.31,9.67 167.93,11.06 156.58,11.06 154.67,9.14 154.67,7.87 153.7,6.91 140.98,6.91 140.5,6.44 136.64,6.44 135.84,5.63 87.31,5.63 85.05,7.9 83.94,7.9 79.11,12.72 78.52,12.72 77.32,13.92 73.43,13.92 72.75,14.6 63.36,14.6 58.94,10.18 48.36,10.18 45.21,7.03 38.06,7.03 36.19,8.9 28.97,8.9 28.35,8.29 28.35,7.74 v2(28.33,7.72)
  BOTTOM w0.127: UH1.F39 v2(195.34,37.15) ; JSSD1.31 28.35,8.41 28.51,8.25 28.51,7.9 v2(28.33,7.72)
PCIE_PRX_DTX_P12: length 207
  IN1 w0.135: v2(194.43,37.08) 194.12,37.08 192.47,35.43 192.47,29.15 191.48,28.15 191.48,27.33 190.87,26.72 190.87,25.29 190.21,24.64 189.71,24.64 189.17,24.1 189.17,22.35 188.72,21.9 188.72,20.76 188.92,20.56 188.92,19.88 188.72,19.68 188.72,17.28 189.06,16.94 189.06,15.99 188.28,15.21 187.44,15.21 186.49,14.25 179.99,14.25 177.37,11.64 176.04,11.64 174.79,10.39 169.61,10.39 168.23,11.78 156.29,11.78 153.95,9.44 153.95,8.32 153.25,7.63 140.68,7.63 140.2,7.15 136.34,7.15 135.54,6.35 88.47,6.35 87.17,7.65 86.41,7.65 85.36,8.71 84.65,8.71 80.49,12.87 80.49,13.5 79.34,14.65 73.72,14.65 73.03,15.34 63.05,15.34 58.61,10.9 48.03,10.9 44.98,7.85 41.28,7.85 40.07,9.06 39.21,9.06 38.21,8.05 v2(38.08,8.05)
  BOTTOM w0.089: UH1.J41 194.43,36.92 v2(194.43,37.08)
  BOTTOM w0.127: v2(38.08,8.05) 38.55,8.05 38.62,7.99 38.62,7.81 36.95,6.14 33.43,6.14 32.9,5.61 27.56,5.61 25.61,7.57 25.61,8.28 25.67,8.34 25.77,8.34 25.85,8.42 JSSD1.41
PCIE_PRX_DTX_P14: length 159.2
  IN1 w0.135: v2(191.52,38.91) 191.58,38.91 191.65,38.84 191.65,38.57 190.11,37.03 190.11,33.1 189.63,32.62 189.63,29.57 187.94,27.88 187.94,27.25 186.66,25.97 186.66,25.06 185.36,23.76 185.36,22.76 184.84,22.24 183.81,22.24 177.91,16.34 177.91,15.25 176.45,13.8 172.05,13.8 171.92,13.93 155.39,13.93 153.5,12.04 152.93,12.04 151.56,10.67 140.67,10.67 139.31,9.31 135.45,9.31 135.17,9.04 124.1,9.04 123.27,8.2 122.85,8.2 122.44,7.79 111.17,7.79 110.33,8.63 110.33,9.15 110.41,9.23 110.61,9.23 v2(110.81,9.02)
  BOTTOM w0.127: UH1.C47 191.64,39.03 v2(191.52,38.91) ; v2(110.81,9.02) 110.57,9.26 110.57,9.55 110.03,10.1 106.3,10.1 104.62,11.77 102.89,11.77 101.36,13.29 101.36,14.2 98.63,16.94 82.66,16.94 80.65,18.95 65.67,18.95 63.33,16.6 60.56,16.6 CR11.1
PCIE_PRX_DTX_P15: length 185.7
  IN1 w0.135: v2(41.97,10.13) 41.67,10.13 41.54,10 41.54,9.68 42.6,8.62 44.73,8.62 47.73,11.62 58.31,11.62 62.75,16.06 73.32,16.06 74.01,15.37 79.64,15.37 81.21,13.8 81.21,13.19 84.86,9.54 86.6,9.54 89.07,7.07 122.74,7.07 123.15,7.48 123.57,7.48 124.4,8.32 135.47,8.32 135.74,8.59 139.61,8.59 140.4,9.39 151.86,9.39 155.69,13.21 171.62,13.21 171.76,13.08 176.78,13.08 180.06,16.36 185.14,16.36 186.39,17.61 186.39,22.13 186.14,22.38 186.14,23.38 189.41,26.66 189.41,28.34 190.96,29.89 190.96,36 191.95,36.98 191.95,37.23 192.42,37.7 192.42,38.03 v2(192.36,38.08)
  BOTTOM w0.127: v2(192.36,38.08) 192.6,38.08 UH1.E45 ; v2(41.97,10.13) 41.68,10.13 41.55,10.26 41.55,10.5 40.87,11.18 39.62,11.18 39.31,11.5 39.31,11.83 CR14.1
PCIE_PRX_DTX_P16: length 166.1
  IN1 w0.135: v2(309.75,25.42) 309.75,25.24 309.88,25.11 310.12,25.11 310.22,25.2 310.22,25.94 311.17,26.89 311.17,27.99 310.52,28.63 310.52,30.35 311.31,31.14 311.31,38.97 307.89,42.39 288.03,42.39 286.84,41.21 272.61,41.21 271.7,42.11 265.96,42.11 265.55,41.7 263.06,41.7 261.89,40.53 258.1,40.53 257.45,41.17 255.44,41.17 255.06,41.55 254.7,41.55 253.61,42.65 248.95,42.65 248.18,43.42 242.83,43.42 241.51,42.1 238.76,42.1 238.32,41.66 236.72,41.66 236.29,42.1 234.47,42.1 233.49,41.12 232.08,41.12 231.67,40.71 230.66,40.71 230.15,40.2 222.12,40.2 218.86,43.46 214.5,43.46 213.72,44.24 210.49,44.24 209.94,43.69 203.11,43.69 202.6,43.18 202.6,41 201.88,40.28 201.25,40.28 199.94,38.97 199.18,38.97 198.65,38.44 198.65,36.79 198.07,36.21 198.07,35.43 196.94,34.29 195.92,34.29 195.5,34.72 195.27,34.72 195.13,34.58 195.13,34.42 v2(195.23,34.32)
  BOTTOM w0.127: UH1.M40 195.53,34.66 195.53,34.39 195.47,34.32 v2(195.23,34.32) ; v2(309.75,25.42) 310.06,25.42 310.15,25.33 310.15,25.17 309.96,24.98 308.98,24.98 308.43,24.44 307.04,24.44 306.34,23.74 306.34,21.98 306.84,21.49 306.84,20.74 307.81,19.76 307.81,17.56 307.41,17.15 307.41,16.21 306.18,14.98 304.47,14.98 303.98,14.5 303.84,14.5 303.74,14.6 JWLAN1.33
PCIE_PTX_C_DRX_N9: length 4
  TOP w0.127: v2(33.39,7.83) 33.25,7.7 33.25,7.46 33.32,7.39 33.63,7.39 33.84,7.6 34.56,7.6 34.67,7.71 34.67,7.85 C369.2
  BOTTOM w0.127: v2(33.39,7.83) 33.23,8 33.23,8.48 33.35,8.6 JSSD1.11
PCIE_PTX_C_DRX_N10: length 2.7
  TOP w0.127: C371.2 30.23,7.24 30.23,7.75 v2(30.39,7.91)
  BOTTOM w0.127: JSSD1.23 30.35,8.58 30.23,8.46 30.23,8.07 v2(30.39,7.91)
PCIE_PTX_C_DRX_N11: length 2.9
  TOP w0.127: C373.2 27.26,7.18 27.26,7.75 v2(27.4,7.89)
  BOTTOM w0.127: JSSD1.35 27.35,8.49 27.23,8.37 27.23,8.07 v2(27.4,7.89)
PCIE_PTX_C_DRX_N12: length 2.7
  TOP w0.127: v2(24.4,7.88) 24.29,7.77 24.29,7.29 C375.2
  BOTTOM w0.127: v2(24.4,7.88) 24.23,8.05 24.23,8.52 24.35,8.65 JSSD1.47
PCIE_PTX_C_DRX_N14: length 167.1
  IN1 w0.135: v2(112.71,9.97) 112.85,9.82 112.85,9.41 113.31,8.95 114.18,8.95 115.45,10.22 115.7,10.22 116.54,11.06 119.51,11.06 120.8,12.35 124.45,12.35 124.87,12.78 134.88,12.78 135.13,13.03 138.33,13.03 139.55,14.24 142.21,14.24 143.17,15.2 150.59,15.2 150.75,15.36 152.01,15.36 153.89,17.25 171.79,17.25 172.51,17.96 173.24,17.96 173.99,18.71 173.99,19.36 186.19,31.56 186.19,33.51 185.62,34.08 185.62,35.66 186.05,36.08 186.05,38.72 190.81,43.48 193.8,43.48 194.82,44.5 194.82,45.07 v2(194.92,45.18)
  BOTTOM w0.127: v2(112.71,9.97) 113.05,9.97 113.12,10.05 113.12,10.5 112.66,10.97 109.08,10.97 107.59,12.46 105.74,12.46 99.99,18.21 86.96,18.21 83.66,21.52 75.46,21.52 74.57,20.62 72.71,20.62 72.32,20.23 65.16,20.23 63.03,18.11 60.36,18.11 59.39,19.08 59.15,19.08 58.75,19.49 58.32,19.49 58.17,19.34 UL1.14 ; CH76.1 194.68,44.82 194.68,44.93 v2(194.92,45.18)
PCIE_PTX_C_DRX_N15: length 182.5
  IN1 w0.135: v2(193.11,45.2) 192.98,45.07 192.98,44.74 192.67,44.42 190.5,44.42 184.9,38.82 184.9,33.78 185.1,33.58 185.1,31.57 171.49,17.97 152.16,17.97 150.12,15.92 142.87,15.92 141.91,14.96 139.25,14.96 138.56,14.26 134.75,14.26 134.36,14.65 133.02,14.65 132.38,14.01 128.47,14.01 127.86,14.63 125.55,14.63 124.94,14.01 121.45,14.01 119.21,11.78 110.77,11.78 109.66,10.67 108.66,10.67 107.21,9.22 100.47,9.22 99.35,10.34 88.62,10.34 87.08,11.88 87.08,12.9 86.22,13.76 83.09,13.76 79.55,17.31 60.99,17.31 56.46,12.78 51.6,12.78 50.98,13.39 49.86,13.39 49.27,12.8 47.15,12.8 45.85,11.5 44.78,11.5 44.41,11.87 44.41,12.17 v2(44.26,12.31)
  BOTTOM w0.127: CH78.1 192.85,44.8 192.85,44.94 v2(193.11,45.2) ; UR1.4 41.81,14.39 41.92,14.27 41.92,13.38 42.51,12.8 44.47,12.8 44.6,12.67 44.6,12.6 44.31,12.31 v2(44.26,12.31)
PCIE_PTX_C_DRX_N16: length 168
  IN1 w0.135: v2(190.99,45.26) 190.83,45.42 190.83,46.02 191.33,46.52 196.71,46.52 197.13,46.09 209.08,46.09 209.54,46.55 214.94,46.55 215.66,45.83 219.86,45.83 223.14,42.56 227.46,42.56 228.16,43.26 230.86,43.26 231.42,43.82 232.83,43.82 233.73,44.73 234.92,44.73 235.92,45.73 236.73,45.73 237.56,44.9 238.48,44.9 240.49,46.9 245.04,46.9 245.8,46.14 249.58,46.14 250.77,44.96 254.66,44.96 255.32,44.29 257.91,44.29 258.81,43.4 259.46,43.4 260.76,42.1 261.56,42.1 261.92,42.45 264.09,42.45 265.28,43.65 281.55,43.65 282.45,42.75 286.72,42.75 287.64,43.68 309.24,43.68 310.11,42.81 310.11,41.59 312.03,39.67 312.03,30.81 311.24,30.02 311.24,29 311.57,28.67 311.93,28.67 312.05,28.55 312.05,28.37 v2(311.93,28.26)
  BOTTOM w0.127: JWLAN1.29 303.73,15.6 303.86,15.72 304.65,15.72 304.81,15.57 305.95,15.57 306.95,16.57 306.95,19.37 306.3,20.03 306.3,21.37 305.91,21.75 305.91,23.99 306.19,24.27 306.19,24.94 307.51,26.26 308.52,26.26 308.83,25.95 310.25,25.95 310.6,26.3 310.6,27.98 311.19,28.57 311.62,28.57 v2(311.93,28.26) ; v2(190.99,45.26) 190.84,45.11 190.84,44.89 CH60.1
PCIE_PTX_C_DRX_P9: length 4
  TOP w0.127: C370.2 34.29,7.34 33.94,7.34 33.73,7.13 33.22,7.13 33,7.35 33,7.65 v2(32.81,7.83)
  BOTTOM w0.127: JSSD1.13 32.85,8.58 32.97,8.46 32.97,8 v2(32.81,7.83)
PCIE_PTX_C_DRX_P10: length 2.7
  TOP w0.127: C372.2 29.97,7.21 29.97,7.74 v2(29.81,7.91)
  BOTTOM w0.127: JSSD1.25 29.85,8.62 29.97,8.5 29.97,8.08 v2(29.81,7.91)
PCIE_PTX_C_DRX_P11: length 2.9
  TOP w0.127: C374.2 27.01,7.08 27.01,7.71 v2(26.82,7.89)
  BOTTOM w0.127: v2(26.82,7.89) 26.97,8.05 26.97,8.38 26.85,8.5 JSSD1.37
PCIE_PTX_C_DRX_P12: length 2.8
  TOP w0.127: v2(23.81,7.88) 24.03,7.66 24.03,7.23 C376.2
  BOTTOM w0.127: v2(23.81,7.88) 23.97,8.04 23.97,8.48 23.85,8.6 JSSD1.49
PCIE_PTX_C_DRX_P14: length 167.1
  IN1 w0.135: v2(194.21,45.18) 194.36,45.18 194.54,45 194.54,44.61 193.69,43.76 190.69,43.76 185.77,38.83 185.77,36.2 185.34,35.77 185.34,33.96 185.91,33.39 185.91,31.67 173.72,19.48 173.72,18.83 173.13,18.24 172.39,18.24 171.68,17.53 153.78,17.53 151.89,15.64 150.64,15.64 150.48,15.48 143.05,15.48 142.09,14.52 139.43,14.52 138.22,13.3 135.01,13.3 134.77,13.06 124.76,13.06 124.33,12.63 120.69,12.63 119.4,11.34 116.43,11.34 115.59,10.5 115.34,10.5 114.07,9.23 113.43,9.23 113.13,9.53 113.13,10.07 113.22,10.16 113.45,10.16 v2(113.62,9.99)
  BOTTOM w0.127: v2(113.62,9.99) 113.38,10.23 113.38,10.61 112.77,11.22 109.19,11.22 107.69,12.72 105.85,12.72 100.09,18.47 87.07,18.47 83.76,21.77 75.36,21.77 74.46,20.88 72.6,20.88 72.21,20.49 65.05,20.49 62.93,18.37 60.46,18.37 59.5,19.34 59.26,19.34 58.85,19.74 UL1.13 ; CH75.1 194.12,44.52 194.42,44.82 194.42,44.97 v2(194.21,45.18)
PCIE_PTX_C_DRX_P15: length 182.5
  IN1 w0.135: v2(192.4,45.2) 192.57,45.2 192.7,45.07 192.7,44.85 192.55,44.7 190.38,44.7 184.62,38.94 184.62,33.67 184.82,33.47 184.82,31.69 171.38,18.25 152.05,18.25 150,16.2 142.76,16.2 141.79,15.24 139.14,15.24 138.44,14.54 134.86,14.54 134.47,14.93 132.91,14.93 132.27,14.29 128.59,14.29 127.98,14.91 125.44,14.91 124.82,14.29 121.33,14.29 119.1,12.06 110.65,12.06 109.54,10.95 108.54,10.95 107.1,9.5 100.58,9.5 99.47,10.62 88.74,10.62 87.36,11.99 87.36,13.01 86.34,14.04 83.21,14.04 79.66,17.59 60.87,17.59 56.34,13.05 51.71,13.05 51.1,13.67 49.75,13.67 49.15,13.08 47.03,13.08 45.73,11.78 44.89,11.78 44.69,11.98 44.69,12.38 44.81,12.5 44.97,12.5 v2(45.23,12.25)
  BOTTOM w0.127: v2(192.4,45.2) 192.59,45.01 192.59,44.9 CH77.1 ; v2(45.23,12.25) 44.85,12.63 44.85,12.78 44.58,13.05 42.62,13.05 42.18,13.49 42.18,14.29 42.21,14.32 UR1.3
PCIE_PTX_C_DRX_P16: length 168
  IN1 w0.135: v2(190.41,45.27) 190.55,45.41 190.55,46.14 191.21,46.8 196.82,46.8 197.25,46.37 208.96,46.37 209.42,46.83 215.06,46.83 215.77,46.11 219.98,46.11 223.25,42.84 227.34,42.84 228.04,43.54 230.74,43.54 231.31,44.1 232.71,44.1 233.61,45.01 234.8,45.01 235.8,46.01 236.84,46.01 237.67,45.18 238.37,45.18 240.37,47.18 245.15,47.18 245.92,46.42 249.7,46.42 250.88,45.24 254.78,45.24 255.44,44.57 258.03,44.57 258.93,43.68 259.58,43.68 260.88,42.38 261.45,42.38 261.8,42.73 263.97,42.73 265.17,43.93 281.67,43.93 282.56,43.03 286.6,43.03 287.53,43.96 309.36,43.96 310.39,42.93 310.39,41.7 312.31,39.79 312.31,30.69 311.52,29.9 311.52,29.11 311.68,28.95 311.79,28.95 v2(311.93,29.1)
  BOTTOM w0.127: v2(190.41,45.27) 190.58,45.1 190.58,44.8 CH61.1 ; v2(311.93,29.1) 311.66,28.83 311.08,28.83 310.34,28.08 310.34,26.41 310.14,26.21 308.93,26.21 308.63,26.52 307.4,26.52 305.94,25.05 305.94,24.38 305.66,24.1 305.66,21.64 306.04,21.26 306.04,19.92 306.7,19.27 306.7,16.67 305.85,15.82 304.91,15.82 304.76,15.98 303.86,15.98 303.73,16.1 JWLAN1.27
PCIE_PTX_DRX_N9: length 203.1
  TOP w0.127: v2(115.48,9.13) 115.56,9.13 115.78,8.91 115.78,8.62 115.65,8.5 113,8.5 111.24,10.26 106.14,10.26 104.05,12.34 102.5,12.34 101.06,13.79 101.06,14.64 96.44,19.27 88.86,19.27 84.27,23.86 74.53,23.86 69.29,18.63 65.75,18.63 61.45,14.32 60.8,14.32 58.13,11.65 54.16,11.65 53.34,12.47 46.69,12.47 46,11.79 45.68,11.79 40.75,6.85 38.54,6.85 37.79,7.6 35.5,7.6 35.44,7.65 C369.1
  IN1 w0.135: v2(196.14,44.01) 196.01,43.88 194.86,43.88 194.02,43.03 190.99,43.03 186.55,38.6 186.55,35.85 186.17,35.47 186.17,34.15 186.63,33.69 186.63,31.33 180.42,25.12 180.42,24.04 176.97,20.59 176.49,20.59 173.43,17.52 172.69,17.52 171.97,16.81 154.07,16.81 152.19,14.92 150.96,14.92 150.8,14.77 143.35,14.77 142.39,13.8 139.73,13.8 138.27,12.34 125.06,12.34 124.63,11.91 120.99,11.91 119.69,10.62 116.72,10.62 115.62,9.52 115.62,9.27 v2(115.48,9.13)
  BOTTOM w0.089: v2(196.14,44.01) 196.14,43.92 196.3,43.76 196.72,43.76 198.07,42.4 198.07,39.44 198.16,39.35 198.16,39.19 198.11,39.14 198.01,39.14 UH1.C34
PCIE_PTX_DRX_N10: length 209.8
  TOP w0.127: v2(119.63,9.07) 119.27,9.43 119.27,9.58 119,9.85 117.9,9.85 117.4,9.35 117.4,8.81 116.4,7.81 v4(114.3,7.81) 102.66,7.81 100.34,10.13 100.34,14.33 96.11,18.56 88.33,18.56 83.72,23.16 74.96,23.16 69.67,17.87 66.16,17.87 61.93,13.64 61.09,13.64 58.42,10.97 53.87,10.97 53.08,11.76 47,11.76 46.32,11.08 45.96,11.08 41,6.13 38.27,6.13 37.83,6.57 35.57,6.57 34.38,5.39 30.36,5.39 30.24,5.5 30.24,5.68 C371.1
  IN1 w0.135: v2(196.12,42.24) 195.91,42.45 195.15,42.45 194.48,41.78 191.14,41.78 187.63,38.26 187.63,30.9 181.82,25.1 181.82,23.93 177.49,19.59 176.91,19.59 173.84,16.53 173.1,16.53 172.39,15.81 154.49,15.81 152.6,13.92 151.6,13.92 150.75,13.07 143.07,13.07 142.8,12.8 140.15,12.8 138.68,11.34 125.47,11.34 125.04,10.91 121.4,10.91 120.11,9.62 119.35,9.62 119.12,9.4 119.12,9.17 119.25,9.04 119.59,9.04 v2(119.63,9.07)
  BOTTOM w0.089: UH1.C35 197.34,39.24 197.34,40.04 197.48,40.18 197.48,41.83 196.89,42.42 196.3,42.42 v2(196.12,42.24)
PCIE_PTX_DRX_N11: length 211.5
  TOP w0.127: C373.1 27.33,5.87 27.18,5.71 27.18,5.15 27.69,4.65 34.62,4.65 35.85,5.88 37.42,5.88 37.86,5.44 41.28,5.44 46.23,10.39 46.63,10.39 47.29,11.05 52.82,11.05 53.59,10.28 58.71,10.28 61.38,12.95 62.25,12.95 66.17,16.87 69.67,16.87 75.23,22.42 83.33,22.42 87.9,17.84 95.81,17.84 99.65,14.01 99.65,9.85 102.52,6.97 119.21,6.97 120.83,8.59 120.83,9.23 v2(120.58,9.48)
  IN1 w0.135: v2(196.17,41.65) 195.46,41.65 194.75,40.94 191.54,40.94 189.38,38.79 188.92,38.79 188.09,37.96 188.09,30.06 186.8,28.78 186.14,28.78 184.82,27.46 184.82,26.61 183.7,25.49 183.32,25.49 182.35,24.52 182.35,23.73 177.77,19.15 177.09,19.15 174.02,16.09 173.29,16.09 172.57,15.37 154.77,15.37 152.89,13.49 151.97,13.49 151.12,12.64 143.26,12.64 142.98,12.36 140.33,12.36 138.87,10.9 125.65,10.9 125.23,10.48 121.58,10.48 v2(120.58,9.48)
  BOTTOM w0.089: v2(196.17,41.65) 196.34,41.49 196.94,41.49 197.3,41.13 197.3,40.46 197.04,40.2 197.02,40.18 197.02,40.06 197.14,39.94 197.14,39.74 197.09,39.69 197.01,39.69 UH1.B36
