# Allegro board LAJ643PR10-0325.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CLKOUT_LPC1: length 2.2
  TOP w0.127: v2(199.6,20.93) 199.39,20.72 TH4973.1
  BOTTOM w0.127: v2(199.6,20.93) 198.98,20.3 UH1.BB34
CLKREQ_PCIE#1: length 131.2
  TOP w0.135: v2(199.86,17.59) 199.86,17.05 v1(200.39,16.52) 200.49,16.42 RH206.2
  IN1 w0.127: v2(199.86,17.59) 200.05,17.78 202.98,17.78 204.19,16.57 204.84,16.57 210.08,11.34 217.68,11.34 218.5,10.53 221.05,10.53 222.29,11.77 224.85,11.77 225.63,12.55 227.88,12.55 228.47,11.97 230.4,11.97 231.18,12.75 236.31,12.75 236.76,12.3 242.29,12.3 243.32,11.26 247.48,11.26 249.38,13.17 264.98,13.17 265.7,13.89 273.57,13.89 274.46,12.99 274.96,12.99 275.7,12.25 275.7,11.67 282.74,4.63 299.96,4.63 301.21,5.88 304.7,5.88 307.45,8.63 v2(307.45,11.19)
  BOTTOM w0.102: v2(199.86,17.59) 199.86,17.99 199.54,18.3 199.54,18.97 UH1.BE31
  BOTTOM w0.135: JWLAN1.45 303.57,11.6 303.84,11.32 307.31,11.32 v2(307.45,11.19)
CLKREQ_PCIE#2: length 218.2
  TOP w0.102: 198.56,17.75 198.56,19.77 198.87,20.08 198.87,21.04
  TOP w0.127: v2(67.3,21.57) 67.3,22.54 67.01,22.82 65.15,22.82 63.79,21.46 63.79,19.61 61.33,17.15 60.3,17.15 57.44,14.29 53.52,14.29 53.1,14.71 46.1,14.71 44.98,13.6 42.61,13.6 39.79,10.78 37.36,10.78 36.13,9.55 34.57,9.55 34.16,9.15 21.07,9.15 v1(20.88,8.96) 20.24,8.96 v2(19.84,8.56) ; 198.87,21.04 199.42,21.6 199.42,23.76 199.04,24.14 v2(198.67,24.14)
  TOP w0.135: RH207.2 198.13,15.31 198.13,17.32 198.56,17.75
  IN2 w0.127: v2(67.3,21.57) 68.84,23.11 72.11,23.11 72.93,22.29 84.25,22.29 87.21,19.33 109.78,19.33 112.4,16.71 114.39,16.71 114.98,16.12 118.24,16.12 118.53,16.41 120.65,16.41 121.08,16.84 122.22,16.84 122.99,17.6 123.63,17.6 124.25,16.98 127.09,16.98 128.06,17.95 134.2,17.95 136.18,15.97 140.44,15.97 143.07,18.61 146.03,18.61 147.25,19.83 151.67,19.83 152.5,20.66 158.39,20.66 158.48,20.74 160.61,20.74 161.32,20.03 167.9,20.03 168.62,20.75 177.1,20.75 181.9,25.54 184.09,25.54 184.65,24.98 187.11,24.98 187.67,25.54 188.67,25.54 189.59,26.46 190.59,26.46 192.07,24.99 193.79,24.99 194.36,24.42 195.35,24.42 195.5,24.57 197.94,24.57 198.37,24.14 v2(198.67,24.14)
  BOTTOM w0.127: JSSD1.52 23.1,4.61 20.22,7.49 20.22,8.17 v2(19.84,8.56) ; UH1.AR32 199.04,24.14 v2(198.67,24.14)
CLKREQ_PCIE#3: length 180.8
  TOP w0.127: v2(66.61,21.01) 65.37,19.77 65.37,19.34 61.87,15.84 60.84,15.84 57.16,12.16 54.37,12.16 53.55,12.98 52.98,12.98 52.63,13.33 50.09,13.33 49.74,12.98 v1(47.81,12.98) 47.49,12.98 v2(46.97,13.5)
  TOP w0.135: RH208.2 199.73,16.28 199.41,16.59 199.41,18.64 199.73,18.96 199.73,19.6 v2(199.44,19.89)
  IN2 w0.127: v2(66.61,21.01) 66.61,19.89 66.65,19.86 77.83,19.86 79.12,21.15 83.87,21.15 86.76,18.25 101.38,18.25 101.99,17.63 107.66,17.63 107.96,17.33 110.22,17.33 113.08,14.47 118.22,14.47 119.09,15.34 121.1,15.34 121.52,15.76 128.11,15.76 128.26,15.61 130.51,15.61 131.36,16.46 131.68,16.46 131.96,16.17 134.23,16.17 135.9,14.51 142.53,14.51 143.84,15.81 149.21,15.81 151.64,18.24 167.63,18.24 169.06,19.67 177.6,19.67 181.31,23.38 183.11,23.38 183.86,22.63 187.03,22.63 188.75,20.91 190.65,20.91 191.92,19.63 191.92,19.45 192.18,19.19 193.11,19.19 193.51,18.79 197.02,18.79 198.11,19.89 v2(199.44,19.89)
  BOTTOM w0.127: UH1.BB30 199.6,19.89 v2(199.44,19.89) ; UR1.2 42.61,14.12 43.17,13.56 45.1,13.56 45.56,13.1 46.58,13.1 v2(46.97,13.5)
CLKREQ_PCIE#5: length 168.3
  TOP w0.102: v2(199.82,21.68) 199.07,20.94 199.07,20 198.84,19.76 198.84,19 199.09,18.74 199.09,18.57
  TOP w0.135: RH205.2 v1(198.96,16.16) 198.96,16.53 199.09,16.66 199.09,18.57
  IN2 w0.127: v2(199.82,21.68) 199.47,21.68 198.81,22.35 198.81,22.81 198.56,23.06 198.4,23.06 197.93,23.53 194.87,23.53 193.68,24.72 191.95,24.72 190.48,26.2 189.7,26.2 188.78,25.27 187.78,25.27 187.22,24.71 184.54,24.71 184.04,25.21 181.94,25.21 177.21,20.48 168.73,20.48 168.02,19.76 161.21,19.76 160.5,20.47 158.59,20.47 158.47,20.36 152.58,20.36 149.86,17.64 142.49,17.64 140.55,15.7 136.07,15.7 134.09,17.68 131.44,17.68 130.81,17.05 127.54,17.05 127.2,16.71 124.14,16.71 123.52,17.33 123.1,17.33 122.33,16.57 121.19,16.57 120.77,16.14 118.75,16.14 117.88,15.27 115.45,15.27 114.28,16.44 112.29,16.44 110.59,18.14 108.3,18.14 107.37,19.06 87.1,19.06 84.13,22.02 72.82,22.02 72,22.85 69.1,22.85 67.94,21.68 67.94,21.45 67.69,21.2 v2(67.69,21.14)
  BOTTOM w0.127: UH1.AN29 200.85,24.45 200.85,22.27 200.59,22.02 200.15,22.02 v2(199.82,21.68) ; RL6.2 60.23,19.41 60.76,18.88 62.72,18.88 65.14,21.3 65.14,22.16 65.6,22.61 67.02,22.61 67.78,21.85 67.78,21.27 67.69,21.17 v2(67.69,21.14)
CLKREQ_PCIE#5_R: length 2
  BOTTOM w0.127: UL1.12 59.04,20.14 59.31,19.88 RL6.1
CLKREQ_PEG#4: length 107.8
  TOP w0.127: v2(183.78,82.2) 183.34,81.76 v1(183.34,78.42) 183.34,75.99 176.59,69.23 176.59,67.4 v2(177,66.98) ; v2(216.32,18.29) 216.24,18.21 RH209.2
  IN1 w0.127: v2(198.73,23.54) 199.05,23.22 199.05,20.68 199.3,20.43 199.83,20.43 201.26,19 202.67,19 203.02,19.35 203.02,22.36 203.26,22.61 203.61,22.61 204.57,21.65 204.57,21.3 205.13,20.74 206.02,20.74 206.18,20.57 206.18,19.68 207.39,18.48 209.89,18.48 211.17,17.2 212.67,17.2 213.64,18.17 215.14,18.17 215.26,18.29 v2(216.32,18.29)
  IN3 w0.102: 195.53,25.66 198.08,25.66 198.3,25.45 198.3,24.87 198.17,24.75 198.17,24.1 v2(198.73,23.54)
  IN3 w0.127: v2(177,66.98) 177,66.95 176.44,66.4 176.44,56.63 181.61,51.46 181.61,49.05 185.16,45.51 185.16,42.69 187.02,40.83 187.14,40.83 192.06,35.91 192.06,30.97 191.36,30.26 191.36,27.72 192.43,26.65 194.71,26.65 195.11,26.25 195.11,26.09 195.53,25.66
  BOTTOM w0.127: v2(198.73,23.54) 199.33,23.54 199.55,23.33 199.55,22.15 199.39,21.99 199.39,21.57 199.66,21.3 199.95,21.3 200.11,21.15 UH1.BA30 ; QG1.6 183.47,81.89 v2(183.78,82.2)
CMSRC: length 38.9
  TOP w0.203: 237.32,14.37 237.32,13.9 238.09,13.13 PUB01.29
  TOP w0.381: PRB04.2 264.26,30.45 263.28,30.45 262.54,29.71 v2(262.5,29.71) ; 237.32,14.37 237.32,15.45 237.69,15.82 241.38,15.82 241.54,15.65 248.51,15.65 v1(251.07,18.21) 251.61,18.74 251.61,20.63 252.01,21.02 v2(252.17,21.02)
  IN3 w0.381: v2(252.17,21.02) 252.21,21.06 254.8,21.06 262.43,28.69 262.43,29.64 v2(262.5,29.71)
CNV_BRI_PRX_DTX: length 117
  TOP w0.127: v2(307.39,19.02) 307.23,19.19 306.99,19.19 v1(306.73,19.45)
  TOP w0.135: RWL13.2 RWL18.1 306.91,18.54 v2(307.39,19.02)
  IN1 w0.127: v2(216.92,21.73) 217.05,21.86 217.7,21.86 217.81,21.75 219.41,21.75 219.96,22.3 219.96,23.85 220.48,24.37 220.48,28.03 224.87,32.42 230.4,32.42 231.04,33.06 234.83,33.06 235.68,33.91 247.63,33.91 249.15,32.39 252.63,32.39 252.99,32.03 255.04,32.03 258.36,28.71 264.89,28.71 265.9,27.7 274.26,27.7 275.02,26.94 276.34,26.94 277.02,26.26 278.16,26.26 280.9,23.53 281.45,23.53 288.99,16 295.03,16 296.16,17.13 298.27,17.13 300.95,19.81 302.35,19.81 303.85,21.32 305.66,21.32 306.28,20.7 306.87,20.7 307.78,19.79 307.78,19.41 v2(307.39,19.02)
  BOTTOM w0.102: 215.16,20.99 214.94,21.21 213.79,21.21 UH1.AY2
  BOTTOM w0.127: 215.16,20.99 215.49,20.66 216.5,20.66 216.82,20.98 216.82,21.63 v2(216.92,21.73)
CNV_BRI_PRX_DTX_R: length 4.1
  TOP w0.135: RWL18.2 308.25,18.44 308.47,18.22 v1(308.83,18.22) 309.06,18.22 v2(309.38,18.54) 309.48,18.44 RWL32.2
  BOTTOM w0.127: v2(309.38,18.54) 309.38,19.08 309.65,19.35 JWLAN1.22
CNV_BRI_PTX_DRX: length 121.4
  TOP w0.135: RWL22.1 306.93,15.36 306.93,15.19 307.43,14.68 v2(308.13,14.68)
  IN1 w0.127: v2(219.8,24.28) 219.89,24.28 220.22,24.61 220.22,28.14 224.76,32.68 230.29,32.68 230.93,33.32 234.72,33.32 235.57,34.17 247.74,34.17 249.26,32.65 252.74,32.65 253.1,32.29 255.15,32.29 258.45,28.99 262.74,28.99 263.32,29.56 264.41,29.56 266.01,27.96 274.37,27.96 275.13,27.2 276.45,27.2 277.13,26.52 278.27,26.52 281,23.79 281.56,23.79 289.09,16.26 294.92,16.26 296.05,17.39 298.16,17.39 300.84,20.08 302.24,20.08 303.74,21.58 305.77,21.58 306.39,20.96 306.98,20.96 308.13,19.81 v2(308.13,14.68)
  BOTTOM w0.102: 216.48,22.13 215.92,22.13 215.38,21.59 214.39,21.59 213.79,22.2 213.43,22.2 213.34,22.11 212.92,22.11 UH1.AV4
  BOTTOM w0.127: 216.48,22.13 217.31,22.13 217.68,22.5 RH26.2
  BOTTOM w0.135: v2(219.8,24.28) v1(219.8,23.67) 219.8,23.35 219.18,22.73 218.33,22.73 RH26.2
CNV_BRI_PTX_DRX_R: length 3.9
  TOP w0.127: v1(309.54,14.49) 309.54,14.87 309.07,15.34 v2(308.95,15.34)
  TOP w0.135: v2(308.95,15.34) 308.47,15.34 308.43,15.38 RWL22.2
  BOTTOM w0.127: JWLAN1.28 309.46,15.85 v2(308.95,15.34)
CNV_CLKREQ: length 124.8
  TOP w0.127: v2(309.28,21.1) 309.58,20.8 309.58,20.68 310.05,20.22 RWL2.1
  TOP w0.135: v2(291.71,9.05) 291.71,9.33 294.13,11.75 297.26,11.75 300.28,14.77 300.6,14.77 301.16,15.34 301.16,15.76 301.91,16.5 303.12,16.5 303.87,17.24 303.87,19.12 304.76,20.01 305.93,20.01 v1(306.8,20.88) 307.18,21.26 309.12,21.26 v2(309.28,21.1)
  IN1 w0.127: v2(207.14,16.99) 206.84,16.69 206.84,16.35 209.55,13.64 211.03,13.64 212.02,12.64 212.98,12.64 213.36,13.02 215.26,13.02 215.89,12.39 221.44,12.39 221.87,12.83 223.54,12.83 224.8,14.08 226.04,14.08 226.34,13.79 234.02,13.79 234.36,14.13 247.3,14.13 247.98,14.8 257.02,14.8 257.6,14.21 263.92,14.21 264.64,14.93 267.33,14.93 267.73,15.33 274.69,15.33 275.62,14.4 275.62,13.81 281.16,8.28 290.94,8.28 v2(291.71,9.05)
  BOTTOM w0.127: v2(309.28,21.1) 309.54,21.35 JWLAN1.14 ; UH1.BA17 205.97,20.6 205.97,19.41 206.15,19.23 206.15,18.08 206.09,18.02 206.09,17.42 206.51,16.99 v2(207.14,16.99)
CNV_PRX_DTX_N0: length 124.6
  IN1 w0.135: v2(304.71,18.7) 304.5,18.49 304.09,18.49 303.25,17.65 303.25,17.2 303.57,16.89 303.57,16.61 303.25,16.3 303.25,15.54 301.63,13.92 301.01,13.92 300.87,14.05 300.87,14.2 300.57,14.5 299.97,14.5 299.67,14.2 299.67,14.05 298.99,13.36 298.23,13.36 297.69,12.83 293.66,12.83 292.75,11.92 286.46,11.92 285.64,12.75 285.64,13.32 282.23,16.73 282.23,18.59 279.76,21.07 278.94,21.07 277.41,22.6 273.78,22.6 271.76,24.63 264.69,24.63 263.8,25.52 256.18,25.52 255.35,26.34 254.95,26.34 254.87,26.26 254.66,26.26 254.41,26.5 254.41,26.71 254.49,26.8 254.49,27.2 251.64,30.05 248.18,30.05 246.68,31.55 237.82,31.55 237,30.72 232.01,30.72 231.36,30.07 226.81,30.07 222.82,26.08 222.82,21.65 219.71,18.54 219.71,18.12 219.44,17.85 219.14,17.85 218.89,18.1 216.75,18.1 216.5,17.85 215.44,17.85 215.33,17.74 214.88,17.74 214.53,17.39 214.53,16.66 v2(214.42,16.55)
  BOTTOM w0.102: v2(214.42,16.55) 214.32,16.65 214.32,16.74 214.42,16.84 214.74,16.84 214.8,16.91 214.8,17.06 215.22,17.47 215.22,17.99 215.04,18.17 215.04,18.44 215.22,18.62 215.22,19.14 214.99,19.38 214.77,19.38 214.62,19.53 214.62,19.74 214.44,19.92 214.14,19.92 214.08,19.87 214.08,19.8 213.98,19.69 213.91,19.69 UH1.BB3
  BOTTOM w0.127: v2(304.71,18.7) 304.58,18.57 304.33,18.57 304.21,18.68 304.21,20.68 303.95,20.94 303.62,20.94 303.46,21.1 JWLAN1.15
CNV_PRX_DTX_N1: length 125.2
  IN1 w0.135: v2(215.61,16.56) 215.83,16.77 215.83,16.79 216.02,16.98 216.42,16.98 216.57,17.14 218.04,17.14 219.01,16.73 219.33,16.73 220.42,17.83 220.42,18.24 223.54,21.35 223.54,25.79 227.09,29.34 231.64,29.34 232.31,30 237.29,30 238.12,30.83 241.4,30.83 242.48,29.75 245.29,29.75 245.72,29.33 250.57,29.33 255.1,24.8 261.47,24.8 262.36,23.91 271.46,23.91 273.48,21.88 277.11,21.88 278.65,20.35 279.46,20.35 281.51,18.3 281.51,16.34 284.92,12.93 284.92,12.45 286.16,11.2 293.05,11.2 293.96,12.11 297.99,12.11 298.53,12.65 299.39,12.65 299.94,13.2 301.98,13.2 304.22,15.44 305.31,17.93 305.75,18.37 306.05,18.37 v2(306.19,18.51)
  BOTTOM w0.102: UH1.BA3 213.52,20.29 213.95,20.29 213.99,20.33 214.58,20.33 215.75,19.17 215.75,16.7 v2(215.61,16.56)
  BOTTOM w0.127: v2(306.19,18.51) 305.94,18.27 305.75,18.27 305.53,18.48 305.53,21.01 304.19,22.36 303.87,22.36 303.62,22.6 JWLAN1.9
CNV_PRX_DTX_P0: length 124.6
  IN1 w0.135: v2(215,16.55) 215.01,16.55 215.23,16.77 215.23,16.91 215.16,16.98 214.9,16.98 214.81,17.08 214.81,17.27 214.99,17.46 215.44,17.46 215.56,17.57 216.62,17.57 216.86,17.82 217.27,17.82 217.41,17.68 217.82,17.68 217.96,17.82 218.78,17.82 219.03,17.57 219.55,17.57 219.99,18.01 219.99,18.42 223.1,21.54 223.1,25.97 226.93,29.79 231.48,29.79 232.13,30.44 237.11,30.44 237.94,31.27 246.57,31.27 248.07,29.77 251.53,29.77 254.22,27.08 254.22,26.91 254.13,26.83 254.13,26.39 254.54,25.98 254.98,25.98 255.07,26.06 255.23,26.06 256.06,25.24 263.68,25.24 264.57,24.35 271.64,24.35 273.67,22.32 277.3,22.32 278.83,20.79 279.64,20.79 281.95,18.48 281.95,16.61 285.36,13.2 285.36,12.63 286.35,11.64 292.87,11.64 293.77,12.55 297.81,12.55 298.34,13.09 299.1,13.09 299.95,13.93 299.95,14.08 300.09,14.22 300.46,14.22 300.59,14.08 300.59,13.93 300.89,13.64 301.74,13.64 303.53,15.43 303.53,16.19 303.84,16.5 303.84,17.01 303.53,17.32 303.53,17.53 304.21,18.21 304.61,18.21 304.61,18.21 v2(304.71,18.12)
  BOTTOM w0.102: v2(215,16.55) 215,16.97 215.42,17.39 215.42,19.23 214.52,20.13 214.05,20.13 213.99,20.06 213.41,20.06 UH1.BB4
  BOTTOM w0.127: JWLAN1.17 303.58,20.6 303.66,20.68 303.84,20.68 303.95,20.57 303.95,18.58 304.22,18.31 304.51,18.31 v2(304.71,18.12)
CNV_PRX_DTX_P1: length 125.2
  IN1 w0.135: v2(216.2,16.56) 216.41,16.35 216.52,16.35 216.62,16.46 216.62,16.79 216.69,16.86 217.98,16.86 218.95,16.45 219.44,16.45 220.7,17.71 220.7,18.12 223.82,21.24 223.82,25.67 227.21,29.06 231.76,29.06 232.42,29.72 237.41,29.72 238.24,30.55 241.28,30.55 242.36,29.47 245.18,29.47 245.6,29.05 250.45,29.05 254.98,24.52 261.36,24.52 262.24,23.63 271.34,23.63 273.37,21.6 277,21.6 278.53,20.07 279.34,20.07 281.24,18.18 281.24,16.23 284.64,12.82 284.64,12.33 286.05,10.92 293.17,10.92 294.07,11.83 298.11,11.83 298.64,12.37 299.51,12.37 300.06,12.92 302.09,12.92 304.45,15.28 305.54,17.77 305.87,18.09 306.1,18.09 306.19,18.01 v2(306.19,17.65)
  BOTTOM w0.102: UH1.BA2 213.85,20.54 214.67,20.54 215.96,19.25 215.96,16.98 216.01,16.93 216.21,16.93 216.31,16.83 216.31,16.67 v2(216.2,16.56)
  BOTTOM w0.127: v2(306.19,17.65) 306.19,17.77 305.95,18.01 305.64,18.01 305.27,18.38 305.27,20.91 304.08,22.1 JWLAN1.11
CNV_PTX_DRX_N0: length 131.7
  IN1 w0.135: v2(213.06,14.84) 212.92,14.71 212.92,14.52 213.18,14.26 215.84,14.26 216.34,13.76 219.1,13.76 219.96,14.62 219.96,15.33 221.86,17.23 221.86,17.59 224.98,20.7 224.98,25.19 227.69,27.9 232.24,27.9 232.9,28.57 237.89,28.57 238.72,29.39 240.76,29.39 241.95,28.2 243.08,28.2 243.4,27.87 248.36,27.87 249.06,27.17 250.69,27.17 254.5,23.36 260.7,23.36 261.59,22.47 270.86,22.47 273.29,20.04 276.92,20.04 278.05,18.92 278.86,18.92 280.08,17.7 280.08,15.61 280.62,15.06 280.62,14.64 279.62,13.64 279.62,13.45 279.88,13.19 280.07,13.19 281.07,14.19 281.5,14.19 283.48,12.2 283.48,11.85 284.06,11.28 284.06,10.86 283.74,10.54 283.74,10.35 284.01,10.09 284.2,10.09 284.51,10.4 284.93,10.4 285.57,9.77 293.65,9.77 294.55,10.67 296.85,10.67 298.83,8.69 298.83,6.58 298.97,6.44 299.53,6.44 299.67,6.58 299.67,8.85 298.46,10.05 298.46,10.54 299.12,11.21 299.87,11.21 300.24,10.83 300.24,10.54 v2(300.4,10.38)
  BOTTOM w0.102: UH1.BE6 211.76,18.74 211.8,18.7 211.8,18.57 211.64,18.41 211.48,18.41 211.41,18.34 211.41,17.16 212.76,15.8 212.76,15.08 213,14.84 v2(213.06,14.84)
  BOTTOM w0.127: JWLAN1.57 302.21,8.6 301.96,8.36 300.63,8.36 300.24,8.75 300.24,9.86 300.34,9.96 300.52,9.96 300.62,10.06 300.62,10.27 300.51,10.38 v2(300.4,10.38)
CNV_PTX_DRX_N1: length 132.9
  IN1 w0.135: v2(301.43,9.98) 300.96,9.98 300.87,9.89 300.87,9.67 301.09,9.46 301.92,9.46 302.06,9.6 302.06,10.04 303.36,11.34 305.59,11.34 306.06,11.81 306.06,12.24 305.9,12.41 305.4,12.41 305.05,12.76 305.05,13.42 305.43,13.8 305.91,13.8 306.19,14.08 306.19,14.67 305.95,14.9 305.09,14.9 302.68,12.49 302.68,11.89 301.73,10.93 300.78,10.93 300.06,11.65 298.94,11.65 298.4,11.11 294.37,11.11 293.46,10.21 285.75,10.21 283.92,12.03 283.92,12.52 280.52,15.93 280.52,17.88 279.04,19.35 278.23,19.35 276.7,20.89 273.07,20.89 271.05,22.91 261.88,22.91 260.99,23.8 254.69,23.8 250.16,28.32 243.59,28.32 243.25,28.66 242.11,28.66 240.94,29.83 238.53,29.83 237.71,29 232.72,29 232.06,28.34 227.5,28.34 224.54,25.37 224.54,20.88 221.42,17.77 221.42,17.41 219.64,15.63 219.12,15.63 217.76,14.27 216.53,14.27 215.53,15.27 214.37,15.27 214.23,15.13 214.23,15 v2(214.39,14.83)
  BOTTOM w0.102: v2(214.39,14.83) 214.13,15.09 214.13,15.59 213.81,15.92 213.37,15.92 211.94,17.34 211.94,17.45 212.16,17.66 212.16,17.88 212.07,17.97 211.97,17.97 211.9,17.89 UH1.BG6
  BOTTOM w0.127: JWLAN1.51 302.15,10.1 301.77,9.73 301.5,9.73 301.43,9.8 v2(301.43,9.98)
CNV_PTX_DRX_P0: length 131.7
  IN1 w0.135: v2(299.82,10.38) 299.96,10.53 299.96,10.71 299.75,10.93 299.24,10.93 298.74,10.43 298.74,10.17 299.94,8.96 299.94,6.46 299.65,6.16 298.85,6.16 298.55,6.46 298.55,8.57 296.73,10.39 294.67,10.39 293.76,9.49 285.45,9.49 284.82,10.12 284.63,10.12 284.31,9.81 283.89,9.81 283.46,10.24 283.46,10.66 283.78,10.97 283.78,11.16 283.2,11.74 283.2,12.08 281.38,13.91 281.19,13.91 280.19,12.91 279.77,12.91 279.34,13.34 279.34,13.76 280.34,14.76 280.34,14.95 279.8,15.49 279.8,17.58 278.74,18.64 277.93,18.64 276.81,19.76 273.18,19.76 270.75,22.19 261.48,22.19 260.59,23.08 254.39,23.08 250.57,26.9 248.95,26.9 248.25,27.59 243.29,27.59 242.97,27.92 241.84,27.92 240.64,29.11 238.83,29.11 238.01,28.29 233.02,28.29 232.35,27.62 227.8,27.62 225.26,25.07 225.26,20.59 222.14,17.47 222.14,17.11 220.24,15.21 220.24,14.5 219.22,13.48 216.23,13.48 215.73,13.98 213.06,13.98 212.64,14.4 212.64,14.68 v2(212.48,14.84)
  BOTTOM w0.102: v2(212.48,14.84) 212.56,14.93 212.56,15.72 211.21,17.07 211.21,18.43 211.28,18.51 211.28,18.81 211.41,18.94 UH1.BD7
  BOTTOM w0.127: JWLAN1.59 300.52,8.1 299.98,8.64 299.98,10.22 v2(299.82,10.38)
CNV_PTX_DRX_P1: length 132.9
  IN1 w0.135: v2(213.81,14.83) 213.95,14.97 213.95,15.24 214.25,15.55 215.65,15.55 216.64,14.55 217.64,14.55 219,15.91 219.52,15.91 221.14,17.53 221.14,17.89 224.26,21 224.26,25.49 227.39,28.62 231.94,28.62 232.61,29.28 237.59,29.28 238.42,30.11 241.05,30.11 242.22,28.94 243.37,28.94 243.71,28.6 250.28,28.6 254.8,24.08 261.11,24.08 262,23.19 271.16,23.19 273.19,21.17 276.82,21.17 278.35,19.63 279.16,19.63 280.8,18 280.8,16.04 284.2,12.64 284.2,12.15 285.87,10.49 293.35,10.49 294.25,11.39 298.29,11.39 298.82,11.93 300.18,11.93 300.9,11.21 301.61,11.21 302.4,12 302.4,12.61 304.98,15.18 306.07,15.18 306.47,14.78 306.47,13.96 306.03,13.52 305.54,13.52 305.33,13.31 305.33,12.88 305.52,12.69 306.01,12.69 306.34,12.35 306.34,11.69 305.71,11.06 303.48,11.06 302.34,9.92 302.34,9.48 302.04,9.18 301.59,9.18 v2(301.43,9.02)
  BOTTOM w0.102: v2(213.81,14.83) 213.93,14.95 213.93,15.5 213.72,15.71 213.29,15.71 211.61,17.39 211.61,18.01 UH1.BF6
  BOTTOM w0.127: v2(301.43,9.02) 301.43,9.23 301.67,9.47 301.88,9.47 302.01,9.6 JWLAN1.53
CNV_RF_RESET#: length 121
  TOP w0.127: v2(309.16,21.85) 309.22,21.85 RWL1.1
  TOP w0.135: v2(309.16,21.85) 308.83,21.53 306.79,21.53 305.7,20.43 v1(305.24,20.43) 304.8,20.43 303.6,19.23 303.6,17.36 303.01,16.77 301.79,16.77 300.9,15.87 300.9,15.47 300.47,15.04 300.17,15.04 297.15,12.02 294.02,12.02 v2(290.97,8.97)
  IN1 w0.127: v2(206.94,17.99) 207.88,17.99 209.41,16.46 209.99,16.46 211.78,14.66 211.78,13.38 212.26,12.91 212.88,12.91 213.25,13.28 215.37,13.28 216,12.66 221.33,12.66 221.76,13.09 223.43,13.09 224.69,14.35 226.15,14.35 226.44,14.06 233.92,14.06 234.25,14.39 247.19,14.39 247.87,15.06 257.13,15.06 257.71,14.47 263.81,14.47 264.53,15.2 267.22,15.2 267.62,15.59 274.8,15.59 277.54,12.86 278.82,12.86 283.14,8.54 290.54,8.54 v2(290.97,8.97)
  BOTTOM w0.127: UH1.BE16 206.84,18.76 206.84,18.09 v2(206.94,17.99) ; v2(309.16,21.85) 309.26,21.85 309.76,22.35 JWLAN1.10
CNV_RGI_PRX_DTX: length 120.6
  TOP w0.135: RWL21.1 RWL12.2 306.89,16.9 306.52,16.53 305.96,16.53 305.64,16.85 v1(305.64,16.91) 305.64,19.19 307.29,20.84 v2(307.7,20.84)
  IN1 w0.127: v2(219.73,24.86) 219.96,25.09 219.96,28.25 224.65,32.94 230.18,32.94 230.82,33.58 234.61,33.58 235.46,34.43 250.51,34.43 250.93,34.01 253.06,34.01 253.46,33.6 254.21,33.6 258.52,29.29 262.67,29.29 263.21,29.83 264.52,29.83 266.12,28.22 274.48,28.22 275.24,27.46 276.56,27.46 277.24,26.78 278.38,26.78 281.11,24.05 281.67,24.05 289.2,16.52 294.81,16.52 295.95,17.65 298.05,17.65 300.74,20.34 302.13,20.34 303.63,21.84 305.88,21.84 306.5,21.22 307.31,21.22 v2(307.7,20.84)
  BOTTOM w0.102: v2(219.73,24.86) 219.73,24.86 219.26,24.4 219.26,23.83 219.41,23.69 219.41,23.32 219.07,22.98 217.8,22.98 217.15,22.34 215.86,22.34 215.3,21.78 214.47,21.78 213.87,22.39 213.17,22.39 UH1.AV3
CNV_RGI_PRX_DTX_R: length 3.2
  TOP w0.127: v2(308.94,16.03) v1(308.94,16.53)
  TOP w0.135: RWL21.2 308.54,16.14 308.65,16.03 v2(308.94,16.03)
  BOTTOM w0.127: JWLAN1.26 309.27,16.35 v2(308.94,16.03)
CNV_RGI_PTX_DRX: length 122.6
  TOP w0.135: v2(307.36,19.61) v1(309.1,19.61) 310.79,19.61 311.72,18.68 311.72,16.88 311.37,16.53 RWL20.1
  IN1 w0.127: v2(217.41,21.33) 217.57,21.49 219.52,21.49 220.22,22.19 220.22,23.74 220.74,24.27 220.74,26.66 226.24,32.16 230.51,32.16 231.15,32.8 234.93,32.8 235.78,33.65 247.52,33.65 249.05,32.12 252.53,32.12 252.88,31.77 254.93,31.77 258.25,28.45 264.78,28.45 265.79,27.44 274.15,27.44 274.99,26.6 276.31,26.6 276.91,26 278.05,26 280.79,23.27 281.35,23.27 288.88,15.74 295.14,15.74 296.27,16.87 298.38,16.87 301.06,19.55 302.46,19.55 303.34,20.44 306.76,20.44 307.36,19.84 v2(307.36,19.61)
  BOTTOM w0.102: 215.01,20.84 214.82,21.02 214.19,21.02 214.01,20.84 213.01,20.84 UH1.BA4
  BOTTOM w0.127: RH167.1 217.76,19.84 217,19.84 216.71,20.12 215.72,20.12 215.01,20.84
  BOTTOM w0.135: RH168.1 RH167.1 217.76,20.98 v2(217.41,21.33)
CNV_RGI_PTX_DRX_R: length 4
  TOP w0.135: RWL33.2 RWL20.2 310.06,17.13 310.42,17.49 v1(310.55,17.49) 310.88,17.49 311.12,17.24 v2(311.3,17.24)
  BOTTOM w0.127: v2(311.3,17.24) 311.3,17.07 311.08,16.85 JWLAN1.24
CNV_WT_RCOMP: length 6.6
  BOTTOM w0.127: v1(219.7,17.82) 218.25,17.82 RH25.1 ; 216.89,18.77 216.64,19.03 216.47,19.03 215.42,20.07 215.42,20.08 214.71,20.78 UH1.BA1
  BOTTOM w0.305: 216.89,18.77 217.35,18.31 RH25.1
COMP_1PH: length 4.1
  TOP w0.127: 172.47,127.16 v1(172.89,126.74)
  TOP w0.203: v2(172.47,127.3) 172.47,127.14 171.91,126.58 PCZ11.2 PCZ10.2
  BOTTOM w0.203: v2(172.47,127.3) 172.39,127.38 172.31,127.38 171.66,128.03 PUZ1.50
COMP_2PH: length 3.7
  TOP w0.127: v2(168.27,133.75) 168.25,133.74 168.25,133.46 v1(167.87,133.08)
  TOP w0.203: PCZ22.2 168.1,134.47 PCZ21.2 168.03,134 v2(168.27,133.75)
  BOTTOM w0.203: PUZ1.33 168.23,133.22 168.27,133.26 v2(168.27,133.75)
COMP_4PH: length 7
  TOP w0.203: PRZ38.1 172.36,123.94 171.5,124.8 PCZ16.1 170.8,124.8 170.49,124.48 v1(169.84,124.48) 169.36,124.48 v2(168.92,124.92)
  BOTTOM w0.203: PUZ1.6 168.63,125.23 168.92,124.93 v2(168.92,124.92)
CPU_C10_GATE#: length 3.5
  BOTTOM w0.102: TH135.1 216,21.4 214.04,21.4 213.91,21.53 213.4,21.53 UH1.AY3
CPU_DISPA_BCLK: length 4.6
  BOTTOM w0.127: RH29.2 217.29,23.77 216.78,24.29 214.18,24.29 213.8,24.66 213.65,24.66 UH1.AM3
CPU_DISPA_BCLK_R: length 123.6
  IN1 w0.127: v2(164.32,101.42) 163.02,100.12 163.02,98.19 163.4,97.81 163.78,97.81 163.94,97.97 164.55,97.97 165.27,97.25 167.02,97.25 167.81,96.45 167.81,96 168.09,95.72 168.74,95.72 169.3,95.16 169.3,94.95 180.31,83.94 180.31,82.34 181.51,81.14 181.51,79 182.41,78.1 182.41,72.93 182.41,71.22 v2(180.91,69.73)
  BOTTOM w0.127: RH29.1 218.6,23.77 218.7,23.87 218.7,24.42 221.31,27.03 221.31,29.44 223.82,31.95 223.82,34.16 223.37,34.62 223.37,41.78 222.13,43.02 222.13,44.6 220.6,46.13 218.81,46.13 217.4,47.54 210.6,47.54 210.13,48.01 201.48,48.01 200.79,48.7 195.85,48.7 194,50.56 194,54.71 190.39,58.31 189.55,58.31 185.05,62.81 185.05,65.96 181.81,69.21 v1(181.43,69.21) v2(180.91,69.73)
  BOTTOM w0.135: UC1.G27 v2(164.32,101.42)
CPU_DISPA_SDI: length 12.5
  TOP w0.127: RC2.2 169.96,102.59 167.93,104.63 167.14,104.63 166.71,104.2 166.71,103.54 166.35,103.18 v1(165.83,103.18) 164.53,103.18 v2(164.32,102.97)
  BOTTOM w0.135: UC1.G29 v2(164.32,102.97)
CPU_DISPA_SDI_R: length 120.6
  TOP w0.127: v2(188.83,80.35) v1(189.21,79.97) 189.21,77.28 186.11,74.18 184.03,74.18 178.83,68.98 v2(178.83,68.19) ; v2(176.7,101.92) 176.7,102.12 176.22,102.59 RC2.1
  IN2 w0.127: v2(205.36,22.82) 205.36,23.06 206.06,23.76 209.33,23.76 209.35,23.78 210.92,23.78 210.94,23.76 214.38,23.76 214.53,23.91 v2(214.89,23.91)
  IN3 w0.127: v2(176.7,101.92) 177.74,100.88 177.74,96.12 188.42,85.44 188.42,83.77 189.08,83.11 189.08,80.6 v2(188.83,80.35) ; v2(205.36,22.82) 205.42,22.88 205.42,23.87 203.37,25.92 200.33,25.92 200.16,26.1 200.16,26.56 199.88,26.84 196.65,26.84 196.3,27.19 195.53,27.19 192.33,30.38 192.33,36.71 185.7,43.34 185.7,45.73 182.78,48.65 182.78,50.43 182.15,51.06 182.15,52.48 177.07,57.57 177.07,65.91 178.8,67.64 178.8,68.15 v2(178.83,68.19)
  BOTTOM w0.127: UH1.AN3 213.24,24.42 213.74,24.42 214.25,23.91 v2(214.89,23.91)
CPU_DISPA_SDO: length 4.1
  BOTTOM w0.127: UH1.AM2 214.12,24.73 215.44,24.73 215.78,25.07 v1(216.36,25.07) 216.84,25.07 RH28.2
CPU_DISPA_SDO_R: length 120.4
  IN1 w0.127: v2(181,68.47) 183.29,70.76 183.29,78.46 182.38,79.36 182.38,81.5 181.18,82.71 181.18,84.3 170.17,95.3 170.17,95.52 169.67,96.01 169.67,97.61 169.01,98.28 167.51,98.28 167.1,98.69 166.24,98.69 165.7,99.24 164.93,99.24 v2(164.32,99.84)
  BOTTOM w0.127: v2(181,68.47) 181.79,68.47 v1(183.34,66.93) 184.79,65.48 184.79,62.7 189.44,58.05 190.29,58.05 193.73,54.6 193.73,50.21 195.5,48.44 200.68,48.44 201.37,47.75 210.02,47.75 210.49,47.27 217.29,47.27 218.7,45.87 220.49,45.87 221.87,44.49 221.87,42.91 223.11,41.67 223.11,34.51 223.56,34.05 223.56,32.06 221.05,29.55 221.05,27.14 218.44,24.53 RH28.1
  BOTTOM w0.135: UC1.G25 v2(164.32,99.84)
CPU_GPIOB21: length 5.9
  BOTTOM w0.102: UH1.BD30 199.9,19.18 199.9,18.81 200.18,18.53 200.18,18.11 200.26,18.03 200.26,17.12 200.23,17.1 200.23,16.71
  BOTTOM w0.127: RH153.2 RH154.2 200.88,15.51 200.23,16.15 200.23,16.71
CPU_SVID_ALERT#: length 9.8
  IN1 w0.127: v2(131.85,104.92) 131.15,105.62 131.02,105.62 129.82,106.82 127.14,106.82 126.84,106.52 124.47,106.52 v2(124.16,106.83)
  BOTTOM w0.127: UC1.BH31 v2(131.85,104.92) ; RC39.2 v2(124.16,106.83)
CPU_SVID_ALERT#_R: length 72.5
  TOP w0.127: PRZ7.2 v2(174.52,131.79)
  IN3 w0.127: v2(174.52,131.79) 174.99,131.32 174.99,130.6 174.19,129.81 174.19,124.3 171.72,121.84 171.72,121.15 163.44,112.86 149.3,112.86 148.94,113.22 147.84,113.22 147.48,112.85 141,112.85 139.71,111.56 126.37,111.56 122.99,108.18 122.99,107.28 122.53,106.83 v2(122,106.83)
  BOTTOM w0.127: v1(121.51,108.13) 121.51,106.97 RC40.2 v2(122,106.83) RC39.1 ; PRZ7.2 v2(174.52,131.79)
CPU_SVID_CLK: length 10.5
  IN1 w0.127: v2(124.16,107.59) 126.95,107.59 127.29,107.25 129.99,107.25 131.18,106.07 131.35,106.07 v2(131.85,105.57)
  BOTTOM w0.127: UC1.BH32 v2(131.85,105.57) ; v2(124.16,107.59) RC37.2 123.53,107.62 CC155.1
CPU_SVID_CLK_R: length 68.3
  TOP w0.127: PRZ8.2 v2(174.52,131.02)
  IN3 w0.127: v2(174.52,131.02) 174.52,130.87 173.74,130.1 173.74,124.49 171.28,122.02 171.28,121.33 163.25,113.31 149.48,113.31 149.13,113.66 147.66,113.66 147.29,113.3 140.82,113.3 139.56,112.05 126.23,112.05 122,107.82 v2(122,107.59)
  BOTTOM w0.127: v2(174.52,131.02) PRZ8.2 ; RC37.1 v2(122,107.59)
CPU_SVID_DAT: length 11
  IN1 w0.127: v2(131.94,103.49) 131.94,104.09 131.54,104.49 130.83,104.49 130.49,104.83 130.49,105.54 129.64,106.39 127.42,106.39 127.06,106.04 124.26,106.04 v2(124.16,105.94)
  BOTTOM w0.127: UC1.BH29 v2(131.94,103.49) ; RC38.2 v2(124.16,105.94)
CPU_SVID_DAT_R: length 75.3
  TOP w0.127: PRZ6.1 v2(174.52,132.55)
  IN3 w0.127: v2(122,105.94) 122.76,105.94 123.44,106.61 123.44,107.99 126.55,111.11 139.89,111.11 141.2,112.41 163.62,112.41 172.17,120.96 172.17,121.65 174.63,124.12 174.63,127.61 175.42,128.39 176.79,128.39 177.18,128.78 177.18,129.89 v2(174.52,132.55)
  BOTTOM w0.127: RC41.1 v2(122,105.94) RC38.1 ; PRZ6.1 v2(174.52,132.55)
CPU_TRIGOUT: length 3.5
  TOP w0.127: RC8.2 165.44,97.79 164.88,97.79 164.22,98.45 v1(164.1,98.45) 163.8,98.45 v2(163.62,98.27)
  BOTTOM w0.127: v2(163.62,98.27) 163.04,98.27 UC1.J23
CPU_TRIGOUT_R: length 167.8
  TOP w0.127: v2(215.06,26.6) 215.07,26.59 215.07,25.46 215.55,24.98 215.97,24.98 216.38,24.57 216.38,23.52 216.13,23.27 216.13,21.93 218.35,19.71 222.1,19.71 v1(222.67,19.14) 223.84,17.97 v2(223.84,17.29) ; v2(169.17,97.23) 165.79,97.23 RC8.1
  IN2 w0.127: v2(191.16,83.27) 190.98,83.09 190.98,81.41 191.52,80.88 191.52,78.96 191.27,78.71 191.27,77.37 190.76,76.86 190.76,75.69 192.21,74.24 192.21,55.66 192.73,55.14 196.13,51.75 197.13,51.75 197.18,51.7 221.24,51.7 224.2,48.74 230.63,48.74 231.97,50.09 234.9,50.09 235.34,49.64 v2(235.92,49.64)
  IN3 w0.127: v2(235.92,49.64) 235.92,49.36 236.43,48.85 236.43,47.98 235.82,47.37 235.82,41 234.63,39.8 234.63,38.65 228.03,32.06 228.03,30.59 224.42,26.97 224.42,21.22 225.92,19.71 225.92,18.28 225.19,17.54 224.1,17.54 v2(223.84,17.29) ; v2(184.21,93.27) 184.21,90.27 188.86,85.62 188.86,84.36 189.31,83.91 190.52,83.91 v2(191.16,83.27)
  BOTTOM w0.102: v2(215.06,26.6) 215.06,26.5 214.64,26.08 214.21,26.08 213.93,26.37 UH1.AK2
  BOTTOM w0.127: v2(184.21,93.27) 181.4,93.27 179.83,94.83 177.09,94.83 176.72,95.2 170.09,95.2 169.17,96.12 v2(169.17,97.23)
CPU_XDP_TCK0: length 230.7
  TOP w0.127: v2(214.35,28.04) 214.11,28.04 v3(213.77,28.38)
  IN2 w0.127: v2(110.43,27.9) 110.43,27.37 113.28,24.53 115.9,24.53 116.44,23.99 120.64,23.99 121.4,24.75 123.86,24.75 123.98,24.62 128.25,24.62 128.87,25.25 135.61,25.25 135.97,25.61 142.82,25.61 143.18,25.25 150.29,25.25 151.16,26.11 160.2,26.11 161.09,27 166.04,27 166.78,26.26 170.74,26.26 174.65,30.17 174.65,30.78 179.31,35.44 181.64,35.44 183.96,37.76 187.46,37.76 189.42,39.73 189.42,40.06 190.98,41.61 191.63,41.61 191.95,41.29 193.02,41.29 194.21,40.11 199.32,40.11 200.16,40.94 205.55,40.94 206.53,41.93 207.47,41.93 208.95,40.44 212.71,40.44 213.38,39.77 213.87,39.77 214.34,39.3 214.34,38.42 213.73,37.8 213.73,33.01 214.61,32.13 214.61,31.42 214.35,31.16 214.35,28.04 v2(214.35,28.04)
  IN3 w0.127: v2(124.16,101.83) 123.93,101.59 123.93,95.57 122.16,93.8 122.16,89.27 119.76,86.87 118.21,86.87 117.66,86.31 114.54,86.31 114.13,85.9 113.82,85.6 112.56,84.33 arc(111.21,82.31) 110.73,79.92 110.73,78.45 104.86,72.57 104.86,71.9 104.37,71.42 104.37,70.1 102.96,68.68 102.96,67.57 101.24,65.86 99.76,63.16 99.76,60.7 100.1,60.36 100.1,56.2 99.37,55.48 99.37,47.62 100.59,46.4 100.59,45.15 102.58,43.16 102.58,37.64 103.15,37.08 103.15,32.58 103.75,31.98 103.75,31.14 105.69,29.2 107.08,29.2 107.82,28.45 107.82,28.14 108.75,27.21 109.74,27.21 v2(110.43,27.9)
  BOTTOM w0.102: UC1.BR28 127.64,102.06 125.56,102.06 125.18,102.45 124.88,102.45 124.52,102.09 124.42,102.09 v2(124.16,101.83) ; v2(214.35,28.04) 214.15,27.84 214.1,27.84 213.83,27.57 213.1,27.57 UH1.AH4
  BOTTOM w0.127: v2(124.16,101.83) RC390.1
CPU_XDP_TDI: length 242.1
  TOP w0.127: v3(215.5,28.63) 214.93,28.06 v2(214.93,28.04)
  IN2 w0.127: v2(113.04,27.86) 113.9,27 114.17,26.73 114.79,26.73 116.65,24.87 118.64,24.87 119.09,24.42 120.47,24.42 121.22,25.18 128.05,25.18 128.78,25.91 135.66,25.91 135.79,26.04 136.78,26.04 137.44,26.7 143.38,26.7 144.4,25.68 148.99,25.68 150.41,27.09 155.33,27.09 155.88,26.54 160.02,26.54 160.91,27.43 166.22,27.43 166.96,26.7 169.11,26.7 172.07,29.65 172.91,29.65 179.13,35.87 181.46,35.87 183.78,38.19 187.28,38.19 188.99,39.9 188.99,40.24 190.8,42.05 192.79,42.05 194.42,40.42 199.16,40.42 199.91,41.17 205.38,41.17 207.79,43.58 211.67,43.58 212.82,42.43 212.82,40.97 213.56,40.23 213.92,40.23 214.69,39.47 214.69,38.21 214.19,37.71 214.19,35.16 215.77,33.58 215.77,31.86 215.99,31.64 215.99,30.25 215.41,29.67 215.41,28.52 v2(214.93,28.04)
  IN3 w0.127: v2(113.04,27.86) 113.04,27.84 112.03,26.83 111.2,26.83 110.28,25.91 108.21,25.91 106.91,27.21 105.43,27.21 102.96,29.68 102.54,29.68 99.95,32.27 99.95,35.57 100.71,36.33 100.71,43.18 99.29,44.6 99.29,45.86 98.08,47.08 98.08,56.01 98.8,56.74 98.8,59.82 98.46,60.17 98.46,63.49 99.19,64.81 99.6,65.57 100.19,66.64 101.66,68.11 101.66,69.23 103.08,70.65 103.08,71.96 103.56,72.44 103.56,73.11 109.44,78.98 109.44,79.92 arc(109.44,80.06) 109.44,80.2 arc(109.96,82.83) 111.45,85.06 113.63,87.23 114.32,87.92 116.08,87.92 120.55,92.4 120.55,94.03 121.69,95.16 121.69,98.29 122.63,99.23 122.63,100.8 121.87,101.56 v2(121.87,101.83)
  BOTTOM w0.102: UC1.BL32 130.3,104.88 130.3,104.48 130.15,104.33 129.76,104.33 129.58,104.15 129.58,103.76 129.27,103.45 125.69,103.45 125.26,103.02 124.63,103.02 124.32,102.71 122.76,102.71 v2(121.87,101.83) ; v2(214.93,28.04) 214.54,27.65 214.18,27.65 213.82,27.29 UH1.AH2
  BOTTOM w0.127: v2(121.87,101.83) RC381.1
CPU_XDP_TDO: length 236.3
  TOP w0.127: v2(216.24,27.12) 216.6,27.12 v3(217.07,27.59)
  IN2 w0.127: v2(111.04,27.9) 111.89,28.74 113.38,28.74 114.53,27.59 115.15,27.59 117,25.74 119,25.74 119.45,25.29 120.11,25.29 120.86,26.04 125.4,26.04 126.13,26.77 133.51,26.77 134.3,27.56 149.47,27.56 150.41,28.51 162.99,28.51 163.21,28.29 169.49,28.29 171.71,30.52 172.55,30.52 178.77,36.74 180.3,36.74 182.62,39.06 186.92,39.06 188.13,40.26 188.13,40.6 190.44,42.91 194.15,42.91 196.24,45 197.38,45 197.61,44.77 197.85,44.54 211.63,44.54 211.8,44.37 212.02,44.37 214.28,42.11 214.28,40.94 214.62,40.6 216.2,40.6 218.43,38.36 218.43,36.96 217.41,35.94 217.41,34.01 217.08,33.67 217.08,27.88 216.32,27.12 v2(216.24,27.12)
  IN3 w0.127: v2(123.4,101.83) 123.5,101.73 123.5,95.75 121.47,93.72 121.47,92.03 116.18,86.74 114.36,86.74 113.83,86.21 113.52,85.9 112.25,84.64 arc(110.81,82.47) 110.3,79.92 110.3,78.63 104.42,72.75 104.42,72.08 103.94,71.6 103.94,70.29 102.52,68.87 102.52,67.75 100.89,66.12 99.94,64.4 99.32,63.27 99.32,60.52 99.67,60.18 99.67,56.38 98.94,55.65 98.94,47.44 100.16,46.22 100.16,44.96 102.14,42.97 102.14,37.47 102.71,36.9 102.71,32.4 103.31,31.8 103.31,30.96 105.51,28.76 106.9,28.76 107.39,28.27 107.39,27.96 108.57,26.78 109.92,26.78 v2(111.04,27.9)
  BOTTOM w0.102: UH1.AH3 213.53,26.98 214.15,26.98 214.33,27.16 216.2,27.16 v2(216.24,27.12) ; v2(123.4,101.83) 123.85,102.28 124.44,102.28 124.8,102.64 125.26,102.64 125.62,102.28 127.21,102.28 UC1.BT28
  BOTTOM w0.127: RC384.1 v2(123.4,101.83)
CPU_XDP_TMS: length 241.7
  TOP w0.127: v2(122.64,101.83) v3(122.64,101.27)
  IN2 w0.127: v2(112.45,27.86) 112.9,28.31 113.2,28.31 113.91,27.6 114.35,27.16 114.97,27.16 116.83,25.3 118.82,25.3 119.27,24.85 120.29,24.85 121.04,25.61 127.87,25.61 128.6,26.34 133.94,26.34 134.73,27.13 149.83,27.13 150.23,27.52 155.51,27.52 156.06,26.98 159.84,26.98 160.73,27.86 169.67,27.86 171.89,30.09 172.73,30.09 178.95,36.3 181.28,36.3 183.6,38.63 187.1,38.63 188.56,40.08 188.56,40.42 190.62,42.48 194.06,42.48 195.98,44.4 196.43,44.4 196.82,44.01 196.82,43.56 197.28,43.09 197.87,43.09 198.25,43.48 198.25,43.73 198.81,44.28 211.5,44.28 213.86,41.92 213.86,40.82 214.53,40.14 216.04,40.14 218,38.18 218,37.14 216.98,36.12 216.98,34.19 216.29,33.5 216.29,32.08 216.43,31.95 216.43,27.85 216.03,27.46 214.94,27.46 214.49,27.01 v2(214.49,26.45)
  IN3 w0.127: v2(112.45,27.86) 111.85,27.26 111.02,27.26 110.1,26.34 108.39,26.34 107.09,27.65 105.61,27.65 103.14,30.11 102.71,30.11 100.38,32.44 100.38,35.39 101.14,36.15 101.14,43.36 99.72,44.78 99.72,46.04 98.51,47.26 98.51,55.83 99.24,56.56 99.24,60 98.89,60.35 98.89,63.38 99.56,64.61 99.98,65.36 100.54,66.38 102.09,67.93 102.09,69.05 103.51,70.47 103.51,71.78 103.99,72.26 103.99,72.93 109.87,78.8 109.87,79.92 arc(110.41,82.64) 111.95,84.94 113.46,86.45 114.18,87.17 116,87.17 121.04,92.21 121.04,93.9 122.12,94.98 122.12,98.11 123.06,99.05 123.06,101.13 122.64,101.56 v2(122.64,101.83)
  BOTTOM w0.102: v2(122.64,101.83) 123.3,102.49 124.38,102.49 124.72,102.83 125.34,102.83 125.67,102.49 126.96,102.49 127.18,102.72 128.22,102.72 UC1.BP28 ; v2(214.49,26.45) 214.11,26.45 213.97,26.6 213.47,26.6 213.34,26.47 212.95,26.47 UH1.AJ4
  BOTTOM w0.127: RC380.1 v2(122.64,101.83)
CPU_XDP_TRST#: length 234.8
  TOP w0.127: v3(212.04,26.72) 211.66,26.34 211.66,25.83 v2(211.96,25.54)
  IN2 w0.127: v2(109.81,27.9) 109.81,27.38 113.63,23.56 124.86,23.56 125.49,24.19 128.55,24.19 128.96,23.78 131.19,23.78 132.23,24.81 135.79,24.81 136.15,25.17 142.64,25.17 143,24.81 150.47,24.81 151.33,25.68 163.3,25.68 163.45,25.83 170.92,25.83 175.08,29.99 175.08,30.6 177.15,32.67 178.32,32.67 179.16,33.51 180.45,33.51 184.27,37.33 188.13,37.33 191.66,40.86 192.9,40.86 193.91,39.85 199.39,39.85 200.17,40.63 205.92,40.63 206.37,40.18 206.71,40.18 206.87,40.02 210.6,40.02 211.26,39.37 213.74,39.37 214.01,39.1 214.01,38.62 213.35,37.96 213.35,31.7 214.08,30.97 214.08,28.83 213.26,28.01 213.26,25.58 212.85,25.17 212.33,25.17 v2(211.96,25.54)
  IN3 w0.127: v2(124.16,103.4) 124.16,103.02 124.67,102.51 124.67,101.47 124.36,101.16 124.36,95.39 122.6,93.62 122.6,88.86 120.17,86.43 118.39,86.43 117.84,85.88 114.72,85.88 114.44,85.6 114.13,85.29 112.87,84.03 arc(111.61,82.14) 111.16,79.92 111.16,78.27 105.29,72.39 105.29,71.72 104.81,71.24 104.81,69.92 103.39,68.5 103.39,67.4 101.84,65.85 101.59,65.59 100.19,63.05 100.19,60.88 100.53,60.54 100.53,56.02 99.81,55.3 99.81,47.79 101.02,46.58 101.02,45.33 103.02,43.33 103.02,37.81 103.58,37.25 103.58,32.76 104.18,32.16 104.18,31.32 105.87,29.63 107.26,29.63 108.26,28.63 108.26,28.31 108.93,27.64 109.55,27.64 v2(109.81,27.9)
  BOTTOM w0.102: UC1.BP30 128.24,104.28 125.18,104.28 124.3,103.4 v2(124.16,103.4)
  BOTTOM w0.127: v2(211.96,25.54) 211.96,25.27 212.26,24.97 212.7,24.97 UH1.AM4 ; RC392.1 v2(124.16,103.4)
CR_WAKE#: length 4.4
  BOTTOM w0.127: RR15.1 RR12.2 RR3.2 ; RR15.1 46.93,14.63 47.23,14.32 QR2.3 ; RR15.1 46.33,13.74 v1(46.09,13.5)
CR_WAKE#_R: length 2
  BOTTOM w0.127: UR1.32 44.24,15.46 44.49,15.71 44.87,15.71 45.32,16.15 RR3.1
CS_DDR: length 3
  TOP w0.127: v2(89.13,27.52) v1(88.46,27.52)
  TOP w0.508: PRM2.2 89.53,27.11 v2(89.13,27.52)
  BOTTOM w0.203: v2(89.13,27.52) 89.13,27.31 89.49,26.95 PUM1.13
CSCL: length 3.2
  BOTTOM w0.127: UV2.29 29.48,61.88 29.66,62.06 30.12,62.06 30.32,61.86 RV14.2 30.71,61.89 31.31,62.49 31.31,62.53 31.32,62.55 TPV1.1
CSCOMP_2PH: length 88.9
  TOP w0.127: v1(167.16,136.45) PCZ28.1
  TOP w0.254: PCZ28.1 PCZ27.1 167.16,133.87 v2(167.28,133.75)
  IN1 w0.254: v2(118.37,103.83) 118.7,104.16 119.08,104.16 119.59,104.67 119.59,110.23 121.52,112.16 121.81,112.16 126.73,117.08 126.73,121.37 123.2,124.9 123.2,132.94 125.13,134.87 131.06,134.87 131.71,134.21 133.93,134.21 134.59,134.87 137.96,134.87 138.41,134.41 141.51,134.41 142.08,134.99 145.82,134.99 146.49,134.31 148.7,134.31 149.31,134.92 155.72,134.92 156.85,136.05 162.6,136.05 163.76,134.89 166.44,134.89 167.21,134.11 167.21,133.82 v2(167.28,133.75)
  BOTTOM w0.203: PUZ1.31 167.43,133.26 167.25,133.44 167.25,133.73 v2(167.28,133.75) 167.28,133.82 167.34,133.89 PRZ44.2 168.01,135.18 PRZ46.1
  BOTTOM w0.254: v2(118.37,103.83) PHZ1.1
CSCOMP_4PH: length 27
  TOP w0.203: PCZ25.2 PCZ24.1 168.93,123.54 v2(168.93,123.85)
  IN1 w0.203: v2(168.93,123.85) 169.56,123.21 169.56,120.06 166.26,116.76 156.55,116.76 v2(156.49,116.71)
  BOTTOM w0.127: v1(169.42,121.36) PRZ45.1
  BOTTOM w0.203: PRZ45.1 PRZ43.1 169.42,123.35 v2(168.93,123.85) 168.69,123.85 168.12,124.41 168.12,124.74 167.83,125.04 PUZ1.8
  BOTTOM w0.254: v2(156.49,116.71) 156.49,116.6 156.42,116.53 PHZ3.1
CSDA: length 2.4
  TOP w0.127: TPV2.1 30.46,62.52 v2(29.76,62.52)
  BOTTOM w0.127: RV16.2 30.27,62.69 30.1,62.52 v2(29.76,62.52) 29.68,62.52 29.44,62.28 UV2.28
CSIN: length 6.1
  TOP w0.127: PRB39.2 234.61,16.51 v1(234.29,16.83)
  TOP w0.203: PUB01.31 237.29,12.95 236.75,13.49 236.51,13.49 236.09,13.91 236.09,14.2 235.52,14.77 PCB04.2 235.48,15.19 235.48,15.19 PCB05.1 234.85,15.6 PRB39.2
CSIN_R: length 42
  TOP w0.254: PRB03.3 259.3,34.54 259.52,34.32 v2(259.77,34.32) ; PRB39.1 233.69,15.87 233.28,16.28 233.28,16.82 233.72,17.27 236.95,17.27 237.44,16.78 241.78,16.78 241.94,16.62 248.11,16.62 250.33,18.84 v1(250.33,19.54) 250.33,21.32 251.26,22.25 v2(252.17,22.25)
  IN3 w0.254: v2(259.77,34.32) 259.27,34.32 257.15,32.21 257.15,25.14 254.38,22.37 252.29,22.37 v2(252.17,22.25)
CSIP: length 6.3
  TOP w0.127: PCB03.2 234.58,15.06 234.28,15.36 233.33,15.36 233.03,15.67 v1(232.77,15.67)
  TOP w0.203: PCB03.2 234.58,13.94 PRB38.2 235.02,13.93 235.09,13.86 PCB04.1 235.66,13.86 236.39,13.13 236.63,13.13 236.89,12.87 PUB01.32
CSIP_R: length 45.7
  TOP w0.254: PRB38.1 233.03,13.93 232.36,14.6 232.36,16.46 233.56,17.66 237.11,17.66 237.6,17.17 241.94,17.17 242.11,17.01 247.95,17.01 249.89,18.94 249.89,21.5 251.22,22.83 v1(251.48,22.83) v2(252.16,22.83) ; PRB03.2 260.28,34.54 259.92,34.91 v2(259.75,34.91)
  IN3 w0.254: v2(252.16,22.83) 252.23,22.76 254.21,22.76 256.76,25.31 256.76,32.37 259.3,34.91 v2(259.75,34.91)
CSN_1PH: length 27.2
  IN1 w0.254: v2(177.25,128.06) 176.94,128.06 175.21,126.33 174.53,126.33 174.18,125.98 167.3,125.98 165.56,124.24 165.56,122.88 164.09,121.41 162.13,121.41 161.12,120.39 161.12,119.16 v2(160.99,119.03)
  BOTTOM w0.254: PRZ4.1 176.97,127.79 v2(177.25,128.06) ; PHZ2.1 162.39,119.05 161.88,119.56 161.51,119.56 v2(160.99,119.03) 159.22,119.03 158.96,118.77 PLA1.3
CSN_1PH_R: length 6.7
  TOP w0.203: v2(173.23,127.94) 173.16,127.94 171.98,129.12 PCZ8.1
  BOTTOM w0.203: PUZ1.48 171.82,128.83 172.35,128.29 v1(172.55,128.29) 172.67,128.29 173.03,127.94 v2(173.23,127.94) 173.26,127.96 173.69,127.96 PCZ5.1 PCZ2.1 174.91,127.79 PRZ4.2
CSP1_2PH: length 4.5
  BOTTOM w0.127: PRZ66.1 165.63,135.14 165.69,135.07 166.02,135.07 v1(166.25,135.3)
  BOTTOM w0.203: PUZ1.28 166.23,132.96 165.95,133.25 165.44,133.25 165.1,133.58 PCZ35.2 165.1,135 165.18,135.07 PRZ66.1
CSP1_4PH: length 5.6
  BOTTOM w0.203: PUZ1.11 v1(166.63,125.19) 166.63,124.31 167.71,123.23 PCZ34.2 PRZ60.2 167.71,121.52 PRZ59.2
CSP2_4PH: length 5.3
  BOTTOM w0.203: PUZ1.12 166.23,124.4 v1(165.93,124.1) PCZ36.2 PRZ69.2 165.93,121.52 PRZ67.2
CSP3_4PH: length 6.1
  BOTTOM w0.203: PUZ1.13 165.83,124.87 165.28,124.32 164.85,124.32 v1(164.6,124.06) 164.15,123.62 PCZ37.2 PRZ71.2 164.17,122.25 PRZ70.2
CSP4_4PH: length 18.5
  TOP w0.127: v1(162.02,124.89) 162.37,124.53 v2(162.37,123.71)
  IN3 w0.254: v2(162.37,123.71) 162.37,125.23 163.53,126.39 163.53,134.44 v2(163.48,134.49)
  BOTTOM w0.203: PUZ1.26 164.65,132.03 164.17,132.51 164.17,133.47 163.76,133.88 PRZ72.2 ; PCZ38.2 PRZ76.2 162.37,121.52 PRZ73.2
  BOTTOM w0.254: v2(163.48,134.49) PRZ72.2 ; PCZ38.2 v2(162.37,123.71)
CSP_1PH: length 23.2
  TOP w0.127: v1(160.23,122.17) PRZ3.1
  TOP w0.254: PRZ3.1 160.67,121.12 161.35,121.79 v2(161.35,122.12)
  IN1 w0.254: v2(161.35,122.12) 161.85,122.63 163.38,122.63 163.83,123.09 163.83,124.86 165.64,126.67 171.1,126.67 172.85,128.41 173.12,128.41 v2(173.23,128.52)
  BOTTOM w0.203: PUZ1.47 171.9,129.23 172.18,128.94 172.45,128.67 173.08,128.67 v2(173.23,128.52) 173.76,128.52 PCZ5.2 PCZ2.2 174.96,128.55 PRZ2.2
CSREF_2PH: length 92.5
  TOP w0.203: PCZ29.1 166.07,133.32 166.07,133.37 165.83,133.61 165.83,133.7 v2(165.82,133.7)
  TOP w0.254: v2(165.82,133.7) 165.75,133.63 163.53,133.63 162.64,134.52 162.64,135.43 162.01,136.07 159.49,136.07 158.62,135.19 124.28,135.19 121.92,132.84 v1(121.92,128.59) 121.92,125.09 v2(121.59,124.76) ; PRG3.2 113.16,100.48 v2(112.73,100.91)
  IN3 w0.254: v2(112.73,100.91) 112.69,100.95 112.69,104.51 117.39,109.21 117.39,110.55 118.39,111.54 120,111.54 125.49,117.03 125.49,121.47 123.51,123.45 121.93,123.45 121.4,123.98 121.4,124.57 v2(121.59,124.76)
  BOTTOM w0.203: v2(165.82,133.7) 165.9,133.63 166.1,133.63 166.63,133.1 PUZ1.29
  BOTTOM w0.254: PCZ35.1 166.02,134.26 165.82,134.06 165.82,133.7 v2(165.82,133.7)
CSREF_4PH: length 68.1
  TOP w0.203: PCZ26.2 167.09,124.36 167.46,123.98 v2(167.6,123.98) 167.34,123.72 v2(166.45,123.72) v2(165.07,123.72) v1(164.15,123.72) v2(163.34,123.72)
  IN3 w0.254: v2(163.34,123.72) 165.5,121.56 167.59,121.56 168.03,121.13 168.03,119.25 162.59,113.82 149.69,113.82 148.93,114.58 148.93,114.89 v2(148.35,115.47) 147.53,114.65 147.53,114.25 147.08,113.8 140.61,113.8 140.06,113.26 133.48,113.26 132.99,113.75 v2(132.99,115.49)
  BOTTOM w0.203: PRZ60.1 PCZ34.1 168.62,123.33 167.98,123.98 167.61,123.98 v2(167.6,123.98) 167.46,123.98 167.03,124.41 PUZ1.10 ; v2(166.45,123.72) 166.45,123.53 166.84,123.14 PCZ36.1 PRZ69.1 ; v2(165.07,123.72) PCZ37.1 PRZ71.1 ; v2(163.34,123.72) 163.29,123.67 PCZ38.1 PRZ76.1
  BOTTOM w0.254: PRZ87.2 133.42,115.07 133,115.49 v2(132.99,115.49) 132.95,115.49 132.53,115.07 PRZ90.2 ; PRZ84.2 147.88,115.06 148.29,115.47 v2(148.35,115.47) 148.76,115.06 PRZ81.2
CSSUM_2PH: length 8
  TOP w0.127: v1(163.87,135.1) 164.39,134.58 PRZ52.1
  TOP w0.203: PRZ52.1 165.37,134.58 166.2,135.41 PCZ28.2 PCZ27.2 166.25,134.01 166.57,133.68 v2(166.7,133.68)
  BOTTOM w0.203: PRZ50.2 166.61,134.64 166.61,133.77 v2(166.7,133.68) 166.7,133.51 167.03,133.18 PUZ1.30
CSSUM_4PH: length 15.1
  TOP w0.203: v2(167.59,124.61) 167.85,124.61 168.31,124.15 v1(168.31,123.26) 169.31,122.26 PCZ24.2 PCZ25.1 169.3,121.35 PRZ49.2 168.86,120.99 PRZ48.2 PRZ51.2 PRZ53.2 PRZ54.2
  BOTTOM w0.203: PUZ1.9 167.43,124.77 v2(167.59,124.61)
D_MIC_CLK: length 8.4
  BOTTOM w0.127: RV59.2 RV58.2 63.83,23.94 v1(64.13,24.25) 64.35,24.46 D506.3 64.35,26.85 64.05,27.15 64.05,28.87 63.55,29.37 JEDP1.6
D_MIC_CLK_CODEC: length 266.1
  TOP w0.127: RA55.2 295.48,15.25 295.71,15.02 295.71,13.76 294.59,12.64 293.86,12.64 290.97,9.74 289.64,9.74 288.36,8.46 288.36,5.39 287.63,4.66 283.04,4.66 282.1,5.6 281.13,5.6 280.21,4.68 279.75,4.68 v2(279.33,5.1) ; v2(179.12,7.05) 179.12,7.06 178.5,7.68 177,7.68 174.48,10.2 171.74,10.2 163.23,18.71 163.23,20.62 159.39,24.46 159.39,25.18 159.39,25.18 159.39,25.39 157.35,27.43 157.35,28.31 156.95,28.71 156.82,28.71 156.03,29.5 155.81,29.5 152.03,29.5 151.81,29.5 151.54,29.5 151.1,29.06 150.74,29.06 149.28,27.6 134.62,27.6 133.88,26.87 122.24,26.87 120.36,28.75 117.19,28.75 115.89,27.44 114.67,27.44 113,29.11 99.48,29.11 98.71,28.34 96.83,28.34 95.71,27.23 95.71,25.34 94,23.63 90,23.63 87.47,26.16 84.72,26.16 83.47,27.4 79.32,27.4 78.87,27.85 70.61,27.85 68.47,25.71 v1(65.74,25.71) 65.68,25.71 v2(65.24,25.27)
  IN1 w0.127: v2(179.12,7.05) 179.12,5.6 179.81,4.9 234.01,4.9 234.74,5.63 241.54,5.63 242.26,4.91 249.05,4.91 249.65,5.51 259.75,5.51 260.35,4.91 279.13,4.91 v2(279.33,5.1)
  BOTTOM w0.127: v2(65.24,25.27) 65.08,25.11 65.08,22.62 64.88,22.42 RV59.1
D_MIC_CLK_CPU: length 5.4
  TOP w0.127: v2(207.73,16.96) 207.81,16.88 207.81,16.18 207.52,15.89 207.03,15.89 RH253.1
  BOTTOM w0.127: UH1.BD16 207.32,19.15 207.32,18.8 207.14,18.62 207.14,18.33 207.32,18.15 207.32,17.37 v2(207.73,16.96)
D_MIC_CLK_R: length 191
  TOP w0.127: v2(180.29,7.05) 180.29,7.06 179.15,8.2 177.21,8.2 174.7,10.72 171.96,10.72 163.75,18.93 163.75,20.84 162.01,22.58 v2(162.01,26.43) ; v2(213.03,7.75) 212.6,7.31 212.08,7.31 211.33,8.07 211.33,9.59 210.2,10.72 207.68,10.72 206.57,11.82 206.57,14.57 RH253.2 ; v2(107.03,26.36) 106.32,27.07 104.58,27.07 104.26,27.39 97.41,27.39 97.08,27.06 97.08,25.25 96.58,24.74 96.22,24.74 94.33,22.85 89.67,22.85 87.15,25.37 78.8,25.37 78.11,26.06 78.11,26.67 77.71,27.07 70.94,27.07 68.34,24.47 v1(64.34,24.47) 63.7,24.47 v2(63.54,24.63)
  IN1 w0.127: v2(180.29,7.05) 180.68,7.44 181.12,7.44 182.16,8.47 185.53,8.47 185.84,8.78 192.3,8.78 193.87,7.21 200.89,7.21 201.15,6.95 201.15,6.59 201.67,6.06 211.35,6.06 v2(213.03,7.75)
  BOTTOM w0.127: RV58.1 63.57,22.16 63.57,21.78 63.35,21.56 CH107.1 62.97,21.69 62.97,24.06 v2(63.54,24.63) ; v2(162.01,26.43) 162.01,26.69 161.81,26.89 161.25,26.89 161.01,26.64 161.01,26.57 160.47,26.04 157.81,26.04 157.8,26.03 157.43,26.03 157,26.03 156.68,26.03 156.6,26.11 151.85,26.11 151.61,26.36 151.52,26.36 150.99,26.89 149.92,26.89 148.79,25.77 147.18,25.77 146.36,24.95 136.61,24.95 136.52,24.86 136.47,24.86 136.07,24.47 134.22,24.47 133.99,24.69 132.16,24.69 132,24.85 132,24.85 131.62,25.23 131.28,25.57 131.13,25.72 124.16,25.72 123.94,25.51 122.46,25.51 121.76,24.8 118.41,24.8 117.21,26 117,26 114.59,26 114.32,25.73 108.34,25.73 107.66,26.42 107.08,26.42 v2(107.03,26.36)
D_MIC_DATA: length 8.2
  BOTTOM w0.127: RV61.2 65.85,24.25 RV60.2 66.64,24.72 66.28,25.08 D506.2 65.22,27.05 64.91,27.05 64.55,27.41 64.55,28.87 64.05,29.37 JEDP1.7
D_MIC_DATA_CODEC: length 264.1
  TOP w0.127: v2(279.92,5.1) 280.26,5.1 281.02,5.87 282.2,5.87 283.15,4.92 287.52,4.92 288.1,5.5 288.1,8.57 289.53,10.01 290.86,10.01 293.75,12.9 294.48,12.9 295.45,13.87 295.45,14.91 RA56.1 ; v2(65.69,24.89) 66.1,25.31 68.44,25.31 70.72,27.59 78.36,27.59 79,26.95 v1(82.15,26.95) 83.55,26.95 84.61,25.89 87.36,25.89 89.89,23.37 94.11,23.37 95.97,25.23 95.97,27.12 96.91,28.05 98.79,28.05 99.59,28.85 112.89,28.85 114.56,27.18 116,27.18 117.3,28.49 120.25,28.49 122.13,26.61 133.99,26.61 134.73,27.34 149.39,27.34 150.85,28.8 151.21,28.8 151.65,29.24 151.92,29.24 155.92,29.24 156.71,28.45 156.85,28.45 157.09,28.2 157.09,27.33 159.13,25.28 159.13,24.35 162.97,20.51 162.97,18.6 171.64,9.93 174.37,9.93 176.89,7.42 178.16,7.42 v2(178.53,7.05)
  IN1 w0.127: v2(279.92,5.1) 279.46,4.64 260.25,4.64 259.65,5.25 249.76,5.25 249.16,4.64 242.16,4.64 241.44,5.36 234.85,5.36 234.12,4.64 179.7,4.64 178.74,5.6 178.74,6.62 178.53,6.82 v2(178.53,7.05)
  BOTTOM w0.127: RV61.1 65.52,23.33 65.35,23.51 65.35,24.55 v2(65.69,24.89)
D_MIC_DATA_CPU: length 3.6
  TOP w0.127: RH254.1 207.98,15.97 208.08,16.07 208.08,16.72 208.15,16.79 208.15,17.14 207.98,17.3 207.74,17.55 v2(207.73,17.55)
  BOTTOM w0.127: UH1.BF15 207.73,18.2 v2(207.73,17.55)
D_MIC_DATA_R: length 182.9
  TOP w0.127: v2(161.43,26.47) 161.43,22.79 163.49,20.73 163.49,18.82 171.85,10.46 174.59,10.46 177.11,7.94 178.82,7.94 179.7,7.06 v2(179.7,7.05) ; v2(212.45,7.77) 212.33,7.64 212.12,7.64 211.59,8.17 211.59,9.7 210.31,10.98 207.78,10.98 206.83,11.93 206.83,13.91 RH254.2 ; v2(67.44,24.89) v1(68.27,24.89) 68.39,24.89 70.83,27.33 77.82,27.33 78.37,26.78 78.37,26.17 78.91,25.63 87.26,25.63 89.78,23.11 94.22,23.11 96.11,25 96.46,25 96.82,25.36 96.82,27.17 97.3,27.65 104.37,27.65 104.69,27.33 106.65,27.33 107.48,26.5 v2(107.48,26)
  IN1 w0.127: v2(212.45,7.77) 212.19,8.03 209.01,8.03 208.81,8.23 206.22,8.23 206.07,8.08 206.07,7.41 205.69,7.03 202.69,7.03 202.24,7.47 193.98,7.47 192.41,9.04 185.73,9.04 185.42,8.74 182.05,8.74 181.01,7.7 180.31,7.7 179.7,7.09 v2(179.7,7.05)
  BOTTOM w0.127: v2(67.44,24.89) 67.44,23.79 66.98,23.34 66.64,23.34 RV60.1 ; v2(161.43,26.47) 161.27,26.31 161.27,26.1 161.06,26.1 160.81,25.85 160.66,25.85 160.58,25.77 157.91,25.77 157.91,25.77 157.32,25.77 157.32,25.77 156.9,25.77 156.89,25.77 156.57,25.77 156.49,25.85 151.96,25.85 151.75,25.85 151.5,26.1 151.41,26.1 150.88,26.63 150.03,26.63 148.9,25.5 148.69,25.5 147.29,25.5 146.47,24.69 146.25,24.69 136.71,24.69 136.63,24.6 136.58,24.6 136.18,24.2 134.11,24.2 133.89,24.43 132.05,24.43 131.89,24.59 131.36,25.13 131.03,25.46 124.27,25.46 124.04,25.24 122.56,25.24 121.86,24.54 118.32,24.54 118.3,24.54 117.11,25.74 114.7,25.74 114.43,25.47 108.23,25.47 107.71,26 v2(107.48,26)
