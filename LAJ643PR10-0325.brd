# Allegro board LAJ643PR10-0325.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
EC_PCIE_WAKE#_CPU: length 4.8
  BOTTOM w0.102: 197.37,17.26 197.15,17.48 197.15,18.67 UH1.BE36
  BOTTOM w0.127: RH182.1 196.55,15.26 197.06,15.77 197.29,15.77 197.49,15.97 197.49,17.14 197.37,17.26
EC_PECI: length 3.7
  TOP w0.127: UK1.118 134.82,13.82 134.43,13.43 134.43,13.21 134.07,12.84 v1(133.81,12.84) 133.68,12.71 RK17.1
EC_PME#: length 118
  TOP w0.127: v2(55.73,16.61) 54.64,17.7 RL15.2 ; v2(146.41,26.18) 146.44,26.15 R5178.2 ; v1(60.77,26.17) 60.23,25.63 v2(60.23,25.62)
  IN1 w0.127: v2(60.23,25.62) 60.43,25.42 60.43,22.72 61.32,21.82 61.32,18.76 59.7,17.13 56.25,17.13 v2(55.73,16.61)
  IN2 w0.127: v2(60.23,25.62) 60.23,28.67 60.72,29.16 66.2,29.16 67.56,27.8 81.79,27.8 82.51,27.08 82.51,26.1 83.95,24.67 87.82,24.67 91.01,21.48 94.47,21.48 95.05,22.06 97.56,22.06 98.67,23.17 98.67,24.67 99.04,25.04 v2(99.47,25.04)
  BOTTOM w0.127: UL1.21 55.51,16.83 v2(55.73,16.61) ; v2(146.41,26.18) 146.41,26 145.62,25.21 136.5,25.21 136.41,25.13 136.36,25.13 135.96,24.73 134.33,24.73 134.1,24.96 132.27,24.96 132.11,25.12 131.88,25.34 131.88,25.34 131.55,25.68 131.24,25.98 124.05,25.98 123.83,25.77 122.57,25.77 122.57,25.77 122.35,25.77 121.65,25.07 118.52,25.07 117.32,26.26 116.89,26.26 114.48,26.26 114.22,25.99 108.45,25.99 107.41,27.03 101.35,27.03 101.08,26.77 101.08,26.1 100.64,25.65 100.07,25.65 v2(99.47,25.04)
EC_PME#_EC_R: length 1.9
  TOP w0.127: R5178.1 145.85,25.35 145.24,24.73 UK1.76
EC_RST#: length 5.9
  TOP w0.127: UK1.37 152.5,11.42 153.2,10.72 RK7.1 154.19,10.72 v3(155.16,11.7) 155.16,12.43 CK5.2
EC_RTC_RST: length 44.6
  TOP w0.127: UK1.29 148.44,9.74 v2(148.52,9.83) ; v2(179.26,11.41) 179.68,11.82 180.66,11.82 181.02,12.18 181.02,12.89 181.58,13.45 182.3,13.45 182.49,13.25 QC11.2 182.49,12.05 RC393.1 183.29,11.96 184.1,12.77 RH252.2
  IN2 w0.127: v2(179.26,11.41) 178.95,11.72 174.34,11.72 171.61,14.45 154.56,14.45 150.34,10.23 148.92,10.23 v2(148.52,9.83)
  BOTTOM w0.127: v2(148.52,9.83) 148.52,9.8 v1(148.05,9.33)
EC_SCI#: length 82.2
  TOP w0.127: v2(147.77,13.85) 147.77,13.45 147.49,13.17 146.81,13.17 144.56,10.91 144.56,9.62 144.84,9.34 UK1.20 144.84,7.36 RK14.2
  IN3 w0.127: v2(147.77,13.85) 147.77,13.91 148.23,14.37 150.23,14.37 151.31,15.45 151.99,15.45 153.85,17.31 178.5,17.31 179.79,16.02 179.79,15.05 180.67,14.17 190.05,14.17 190.39,13.82 193.35,13.82 194.86,15.34 197.03,15.34 197.71,16.02 197.71,17.12 198.26,17.68 198.26,19.45 198.39,19.58 198.39,21.27 199.15,22.03 199.15,25.11 199.42,25.39 202.31,25.39 203.05,24.65 203.05,22.58 202.66,22.19 v2(202.33,22.19)
  BOTTOM w0.127: v1(148.19,14.53) 147.77,14.11 v2(147.77,13.85) ; UH1.AU26 202.24,22.19 v2(202.33,22.19)
EC_SMB_CK: length 1.7
  TOP w0.127: PUB01.4 235.1,10.63 235.03,10.7 PRB16.2
EC_SMB_CK1: length 271.8
  TOP w0.127: v2(289.31,36.39) 289.66,36.04 290.04,36.04 290.15,36.15 292,36.15 293,35.14 293,30.7 293,30.7 293,30.49 292.16,29.65 283.58,29.65 281.57,27.64 280.25,27.64 279.48,26.87 279.48,25.01 280.92,23.57 280.92,16.39 280.8,16.27 280.8,12.87 281.85,11.82 v2(282.68,11.82) 282.69,11.83 PR14.2 ; v2(181.32,41.37) 181.09,41.6 180.43,41.6 179.72,42.31 177.83,42.31 v1(177.59,42.56) 177.26,42.88 R5800.1 ; UK1.77 144.84,25.17 RH232.1 145.82,26.16 v2(145.82,26.18) ; PRB16.1 233.31,10.7 v2(233.05,10.97)
  IN2 w0.127: v2(289.31,36.39) 289.03,36.67 286.5,36.67 284.1,39.06 280.33,39.06 279.71,39.69 277.66,39.69 276.38,38.41 271.52,38.41 271.04,38.89 259.47,38.89 259.16,39.2 257.91,39.2 257.52,38.8 257.19,38.8 255.09,38.8 255.06,38.83 254.83,38.83 252.06,38.83 252.06,38.83 251.83,38.83 251.05,39.62 248.68,39.62 248.24,39.18 248.24,38.88 247.76,38.4 247.41,38.4 246.92,38.89 246.33,38.89 245.37,37.92 239.25,37.92 238.62,38.55 236.92,38.55 236.41,38.04 236.19,38.04 223.15,38.04 215.27,45.92 198.88,45.92 198.66,45.92 197.67,46.9 195.28,46.9 195.17,47.01 194.02,47.01 193.85,46.84 192.71,46.84 192.51,47.04 190.35,47.04 186.68,43.37 186.68,42.83 185.07,41.22 181.47,41.22 v2(181.32,41.37)
  IN3 w0.127: v2(282.68,11.82) 281.83,10.97 277.51,10.97 274.72,13.75 274.72,14.56 274.31,14.97 265.31,14.97 264.1,13.76 257.66,13.76 256.82,14.6 246.31,14.6 245.39,13.68 240.71,13.68 240.66,13.73 239.58,13.73 238.33,12.49 234.99,12.49 233.6,11.09 233.18,11.09 v2(233.05,10.97) ; v2(181.32,41.37) 181.79,40.9 181.79,34.57 181.34,34.12 181,34.12 180.12,33.24 178.51,33.24 178.24,33.51 177.79,33.51 175.48,31.19 175.48,29.99 173.05,27.57 171.84,27.57 171.44,27.96 169.53,27.96 169.44,27.87 164.9,27.87 164.86,27.91 163.75,27.91 163.75,27.9 163.74,27.9 163.71,27.87 161.18,27.87 160.6,27.29 150.06,27.29 149.43,26.66 146.13,26.66 145.82,26.35 v2(145.82,26.18)
EC_SMB_CK2: length 550.6
  TOP w0.127: Q7.6 178.36,121.86 177.58,121.86 177.05,122.38 v2(176.87,122.38) ; v2(58.01,46.84) 57.79,46.63 57.79,43.3 55.57,41.08 RU54.2 ; RH234.1 143.14,25.58 144.04,24.69 UK1.79 144.04,21.55 v2(144.48,21.11) ; QC9.6 227.09,12.23 v2(227.45,11.87)
  IN1 w0.127: v2(108.95,74.24) 108.95,74.66 108.95,75.15 109.53,75.73 109.53,79.99 arc(110.09,82.81) 111.69,85.2 112.67,86.19 113.98,87.5 115.18,87.5 118.94,91.26 119.85,91.26 123.26,94.66 126.55,94.66 127.08,95.2 128.55,95.2 128.88,95.53 v2(128.88,95.65) ; v2(283.35,43.55) 283.35,43.58 280.04,46.89 266.06,46.89 264.05,44.87 259.06,44.87 257.76,46.18 251.27,46.18 250.09,47.36 246.31,47.36 245.54,48.13 240.56,48.13 238.68,50.01 238.68,51.75 236.73,53.7 235.92,53.7 234.87,54.75 232.62,54.75 232.11,55.25 232.11,57.14 230.91,58.35 229.73,58.35 229.27,57.89 224.55,57.89 223.77,58.67 223.77,59.02 222.95,59.85 222.5,59.85 221.57,60.78 221.22,60.78 220.12,61.88 219.57,61.88 v2(219.48,61.78) ; v2(105.16,24.97) 104.57,25.56 104.57,26.45 103.69,27.33 101.61,27.33 96.73,32.22 96.73,41.38 94.09,44.02 94.09,46.53 89.75,50.87 v2(88.98,50.87) 87.25,50.87 86.08,49.71 81.53,49.71 80.14,48.32 77.37,48.32 74.17,45.12 68.65,45.12 67.73,46.03 58.05,46.03 58.01,46.07 v2(58.01,46.84)
  IN2 w0.127: v2(108.95,74.24) 104.45,74.24 101.06,70.85 99.32,67.55 98.09,65.11 95.56,61.67 95.54,61.65 95.06,60.99 95.06,57.38 95.61,56.83 95.61,51.63 94.06,50.09 89.76,50.09 v2(88.98,50.87) ; v2(167.72,7.39) 168.53,7.39 171.29,4.63 223.32,4.63 226.92,8.23 226.92,10.48 227.45,11.01 v2(227.45,11.87) 228.12,12.54 239.31,12.54 239.54,12.31 240.86,12.31 241.92,13.37 252.13,13.37 252.49,13 265.32,13 266.2,13.89 273.57,13.89 274.34,13.11 279.11,13.11 280.58,14.58 280.58,18.25 279.86,18.97 279.86,22.34 v2(280.46,22.93)
  IN3 w0.127: v2(176.87,122.38) 176.52,122.04 175.94,122.04 171.61,117.71 171.61,115.54 165.13,109.07 164.57,109.07 163.89,108.38 163.89,106.43 164.56,105.76 167.02,105.76 167.54,105.24 167.54,104.61 168.47,103.68 168.47,103.47 169.65,102.29 169.65,101.21 169.14,100.7 163.24,100.7 162.77,100.23 162.77,99.49 161.95,98.68 160.81,98.68 159.69,97.56 159.69,95.57 158.63,94.5 141.67,94.5 140.24,95.93 132.57,95.93 131.81,95.17 129.37,95.17 v2(128.88,95.65)
  BOTTOM w0.127: v2(219.48,61.78) 220.09,62.39 220.09,63.36 219.63,63.82 QG2.3 ; v2(280.46,22.93) 280.83,23.31 280.83,24.48 279.46,25.86 279.46,29.1 278.45,30.11 278.45,35.92 283.35,40.82 v2(283.35,43.55) ; v2(105.16,24.97) 106.14,23.99 109.59,23.99 110.86,22.73 113.48,22.73 114.66,21.56 117.74,21.56 118.1,21.56 118.1,21.56 118.72,21.56 121.81,21.56 122.17,21.56 124.08,21.56 124.96,20.68 132.2,20.68 132.63,20.25 134.07,20.25 134.33,20.51 135.08,20.51 138.41,20.51 138.67,20.25 140.8,20.25 141.24,20.69 141.95,20.69 142.82,21.55 144.03,21.55 v2(144.48,21.11) 144.48,18.8 141.8,16.12 141.8,10.88 144.25,8.42 149.68,8.42 151.51,10.25 163.57,10.25 163.93,9.89 166.37,9.89 167.72,8.54 v2(167.72,7.39)
EC_SMB_CK2_PD: length 2.5
  TOP w0.127: RU54.1 52.28,41.08 51.76,41.6 51.36,41.6 50.91,42.06 UU4.32
EC_SMB_DA: length 1.9
  TOP w0.127: PUB01.3 235.26,11.03 234.83,11.46 PRB15.2
EC_SMB_DA1: length 270.9
  TOP w0.127: v2(143.28,26.18) 143.88,25.58 RH233.1 144.44,25.06 UK1.78 ; PR15.2 282.78,12.72 v2(282.37,12.31) 281.73,12.31 281.06,12.98 281.06,16.02 v1(281.18,16.14) 281.18,23.69 279.75,25.12 279.75,26.77 280.36,27.38 281.69,27.38 283.7,29.39 292.27,29.39 293.26,30.38 293.26,30.81 293.26,35.25 292.11,36.41 289.99,36.41 v2(289.89,36.51) ; R5799.1 180.77,43.18 181.72,42.22 v2(181.72,41.79) ; PRB15.1 233.53,11.57 v2(233.04,11.57)
  IN2 w0.127: v2(181.72,41.79) 182.03,41.49 184.96,41.49 186.42,42.94 186.42,43.48 190.24,47.31 192.63,47.31 192.82,47.11 193.74,47.11 193.91,47.28 195.28,47.28 195.39,47.17 197.78,47.17 198.77,46.19 215.38,46.19 223.26,38.31 236.3,38.31 236.81,38.82 238.73,38.82 239.37,38.19 244.68,38.19 244.96,38.46 244.96,38.77 245.58,39.39 246.81,39.39 247.03,39.39 247.03,39.39 248.07,39.39 248.57,39.89 251.16,39.89 251.95,39.1 254.14,39.1 254.14,39.1 254.48,39.1 254.48,39.1 255.17,39.1 255.2,39.07 256.86,39.07 257.41,39.07 257.8,39.47 259.27,39.47 259.58,39.16 271.16,39.16 271.64,38.68 276.27,38.68 277.55,39.96 279.82,39.96 280.44,39.33 284.22,39.33 286.61,36.94 289.46,36.94 v2(289.89,36.51)
  IN3 w0.127: v2(282.37,12.31) 281.29,11.23 277.62,11.23 274.99,13.87 274.99,14.67 274.42,15.24 265.2,15.24 263.99,14.03 257.77,14.03 256.93,14.87 246.2,14.87 245.28,13.95 240.82,13.95 240.77,14 239.47,14 238.22,12.76 234.88,12.76 234.51,12.38 233.49,11.36 233.25,11.36 v2(233.04,11.57) ; v2(181.72,41.79) 181.15,41.79 180.85,41.5 180.85,41 181.52,40.34 181.52,34.68 181.23,34.39 180.89,34.39 180.01,33.51 178.62,33.51 178.36,33.78 177.68,33.78 175.21,31.31 175.21,30.1 172.94,27.83 171.95,27.83 171.56,28.23 169.42,28.23 169.33,28.14 165.01,28.14 164.98,28.18 163.64,28.18 163.64,28.17 163.63,28.17 163.59,28.14 161.07,28.14 160.49,27.56 149.95,27.56 149.31,26.93 144.54,26.93 143.79,26.18 v2(143.28,26.18)
EC_SMB_DA2: length 564.7
  TOP w0.127: v2(176.88,121.77) 177.01,121.77 177.42,121.36 181.62,121.36 182,121.73 182,123.07 181.44,123.62 Q7.3 ; RH235.1 141.89,25.49 142.27,25.11 143.29,25.11 143.64,24.76 UK1.80 143.64,21.31 v2(143.85,21.11) ; QC9.3 229.08,13.53 229.22,13.39 v2(229.22,12.97) ; RU55.2 55.72,41.84 57.32,43.44 57.32,46.77 v2(57.42,46.87)
  IN1 w0.127: v2(282.77,43.55) 279.86,46.46 266.24,46.46 264.23,44.44 258.88,44.44 257.58,45.75 251.09,45.75 249.91,46.93 246.13,46.93 245.37,47.69 240.38,47.69 238.24,49.83 238.24,51.57 236.55,53.26 235.74,53.26 234.69,54.31 232.44,54.31 231.68,55.07 231.68,56.96 230.73,57.91 229.91,57.91 229.45,57.45 224.37,57.45 223.34,58.49 223.34,58.84 222.77,59.42 222.32,59.42 221.39,60.35 220.95,60.35 v2(219.91,61.39) ; v2(128.25,95.63) 126.2,95.63 125.67,95.1 122.17,95.1 115,87.93 113.8,87.93 111.38,85.51 arc(109.69,82.98) 109.1,79.99 109.1,75.91 108.39,75.2 108.39,74.2 108.93,73.66 v2(108.95,73.66) ; v2(104.48,24.97) 104.08,25.36 104.08,26.33 103.51,26.9 101.43,26.9 96.3,32.04 96.3,41.2 93.66,43.84 93.66,46.35 89.58,50.43 v2(88.39,50.43) 87.42,50.43 86.26,49.27 81.72,49.27 80.32,47.88 77.55,47.88 74.35,44.69 68.47,44.69 67.55,45.6 57.78,45.6 57.42,45.96 v2(57.42,46.87)
  IN2 w0.127: v2(279.9,23.11) 279.43,22.64 279.43,18.79 280.15,18.07 280.15,14.76 278.94,13.55 274.52,13.55 273.75,14.32 265.85,14.32 264.97,13.44 252.94,13.44 252.57,13.8 237.9,13.8 237.08,12.97 v2(229.22,12.97) 227.94,12.97 226.95,11.98 226.95,11.12 226.48,10.66 226.48,8.41 223.14,5.07 171.47,5.07 170.02,6.52 170.02,7.48 167.32,10.18 157.06,10.18 155.67,8.79 155.67,5.1 v2(155.43,4.86) ; v2(108.95,73.66) 104.48,73.66 101.41,70.59 99.71,67.35 98.46,64.88 96.25,61.87 95.91,61.41 95.89,61.39 95.49,60.85 95.49,57.55 96.04,57.01 96.04,51.45 94.24,49.66 89.17,49.66 v2(88.39,50.43)
  IN3 w0.127: v2(128.25,95.63) 129.14,94.74 131.98,94.74 132.75,95.5 140.06,95.5 141.49,94.07 158.92,94.07 160.13,95.27 160.13,97.32 161.04,98.23 162.12,98.23 163.2,99.31 163.2,100.05 163.42,100.26 169.32,100.26 170.08,101.03 170.08,102.47 168.9,103.65 168.9,103.86 167.97,104.79 167.97,105.42 167.2,106.19 164.74,106.19 164.32,106.61 164.32,108.2 164.75,108.63 165.31,108.63 172.04,115.36 172.04,117.53 176.03,121.52 176.63,121.52 v2(176.88,121.77)
  BOTTOM w0.127: v2(104.48,24.97) 105.88,23.56 109.41,23.56 110.68,22.3 113.3,22.3 114.48,21.13 117.92,21.13 119.24,21.13 119.25,21.13 123.9,21.13 124.78,20.24 132.02,20.24 132.9,19.37 137.75,19.37 138.19,19.81 140.98,19.81 141.42,20.25 142.13,20.25 142.98,21.11 v2(143.85,21.11) 144.05,20.9 144.05,18.98 141.37,16.3 141.37,10.7 142.45,9.61 144.07,7.99 149.86,7.99 151.61,9.74 154.22,9.74 155.66,8.3 155.66,5.09 v2(155.43,4.86) ; v2(279.9,23.11) 280.4,23.61 280.4,24.3 279.03,25.68 279.03,28.93 278.02,29.93 278.02,36.1 282.77,40.85 v2(282.77,43.55) ; v2(219.91,61.39) 220.52,62 220.52,62.23 220.81,62.52 QG2.6
EC_SMB_DA2_PD: length 2.4
  TOP w0.127: RU55.1 52.38,42 51.45,42 50.99,42.46 UU4.33
EC_SPICLK: length 117.6
  TOP w0.127: RC369.2 CC144.1 132.34,9.22 131.32,8.2 131.32,7.11 130.15,5.94 127.64,5.94 127.11,6.47 127.11,7.99 123.11,11.99 117.34,11.99 115.79,13.54 115.79,17.93 116.87,19.01 v1(116.87,22.67) v2(116.87,24.45)
  BOTTOM w0.127: RH243.2 180.8,46.86 180.8,45.26 180.22,44.68 177.74,44.68 175.4,42.34 175.4,41.91 174.49,40.99 174.49,36.42 175.26,35.65 175.26,32.83 172.11,29.68 172.11,29.17 172.1,29.17 172.1,29.05 172.1,29.05 172.1,28.97 169.79,26.67 166.24,26.67 165.04,25.47 164.91,25.47 164.88,25.44 164.04,25.44 162.83,24.22 147.84,24.22 147.24,23.61 146.91,23.61 137.87,23.61 137.41,23.15 136.64,23.15 136.62,23.13 133.67,23.13 133.44,23.36 131.61,23.36 131.53,23.44 125.23,23.44 125.2,23.47 122.96,23.47 121.02,23.47 120.22,23.47 117.86,23.47 v2(116.87,24.45)
EC_SPICLK_R: length 4
  TOP w0.127: RC369.1 133.89,8.3 v1(134.36,8.77) 134.5,8.91 134.5,10.36 134.76,10.62 UK1.126
EC_SPICS#: length 92.4
  TOP w0.127: UK1.128 136.48,9.82 136.62,9.82 137.01,10.21 137.01,11.28 140.01,14.28 140.01,16.04 141.26,17.29 141.26,18.46 140.61,19.11 139.96,19.11 139.78,18.93 139.78,18.23 v2(139.87,18.13)
  IN3 w0.127: v2(139.87,18.13) 139.86,18.12 139.86,18.02 137.98,16.14 136.48,16.14 135.97,16.65 135.97,17.99 135.22,18.74 135.22,23.03 136.5,24.31 149.89,24.31 151.52,25.94 160.71,25.94 161.16,25.49 162.54,25.49 162.78,25.25 163.5,25.25 164.19,25.94 166.61,25.94 166.91,25.64 170.77,25.64 170.8,25.67 172,26.86 173.69,26.86 177.71,30.88 178.37,30.88 181.18,33.69 181.52,33.69 182.22,34.39 182.22,42.99 181.98,43.23 181.98,44.41 v2(183.22,45.65)
  BOTTOM w0.127: RH242.2 184.6,45.65 v2(183.22,45.65)
EC_VCCST_PG: length 14.7
  IN1 w0.127: v2(163.68,91.16) 164.33,90.51 164.84,90.51 165.55,89.8 167.55,89.8 168.17,89.18 169.75,89.18 174.22,84.71 v2(174.31,84.71)
  BOTTOM w0.127: RC21.2 174.32,84.71 v2(174.31,84.71) ; UC1.H13 v2(163.68,91.16)
EC_VCCST_PG_R: length 101.3
  TOP w0.127: v2(148.59,22.42) 148.59,22.86 148.44,23.02 UK1.68
  IN2 w0.127: v2(176.42,42.75) 176.42,50.54 176.74,50.85 176.74,59.95 175.89,60.79 175.89,68.72 180.1,72.92 180.1,77.22 175.79,81.54 175.79,83.62 175.56,83.84 v2(175.56,84.1)
  BOTTOM w0.127: RC20.1 CC156.2 RC21.1 175.56,84.23 v2(175.56,84.1) ; v2(176.42,42.75) 176.86,42.31 179.79,42.31 181.89,40.21 181.89,37.59 179.72,35.42 176.86,35.42 176.4,34.95 176.4,31.93 175.68,31.21 175.68,28.95 175.61,28.88 175.61,28.85 172.04,25.28 171.47,25.28 166.81,25.28 165.61,24.08 165.49,24.08 165.41,24.01 164.76,24.01 163.58,22.83 163.4,22.83 149,22.83 v2(148.59,22.42)
EC_VCIN1_AC_BYPASS: length 168.1
  TOP w0.127: UK1.64 152.14,22.22 v1(152.8,22.89) 153.68,23.77 154.65,23.77 154.94,23.47 158.68,23.47 162.18,19.97 162.18,18.28 171.31,9.15 173.17,9.15 174.07,8.25 174.72,8.25 176.19,6.78 v2(176.19,6.54) ; DG2.1 220.04,64.84 RG393.1 219.39,64.19 RG200.1 219.59,63.42 219.59,62.92 220.59,61.91 220.59,61.21 222.46,59.35 224.58,59.35 225.12,59.89 229.17,59.89 232.25,56.81 232.25,54.77 232.58,54.44 232.58,52.67 231.57,51.67 231.57,49.62 234.37,46.82 v2(234.37,46.26)
  IN3 w0.127: v2(223.83,18.57) 222.7,19.7 222.7,27.68 226.32,31.3 226.32,33.92 233.95,41.56 233.95,46.13 234.08,46.26 v2(234.37,46.26)
  BOTTOM w0.127: PRB43.1 231.16,14.8 226.94,14.8 226.29,15.46 226.29,17.97 225.28,18.98 224.25,18.98 v2(223.83,18.57) 222.85,18.57 222.22,17.94 222.22,13.64 222.04,13.45 222.04,9.23 219.75,6.95 203.02,6.95 202.19,7.78 200.69,7.78 200.15,7.25 181.36,7.25 181.14,7.47 180.59,7.47 180.58,7.47 177.19,7.47 176.97,7.47 176.97,7.47 176.73,7.47 176.19,6.93 v2(176.19,6.54)
ECAGND: length 310.1
  TOP w0.254: v2(135.76,26.7) 135.78,26.73 135.78,26.88 135.91,27.02 137.13,27.02 137.2,26.95 v1(138.27,26.95) 138.34,27.02 149.83,27.02 150.02,26.83 ; 150.02,26.83 150.02,26.96 151.97,28.92 155.78,28.92 v2(156.67,28.03) ; 150.02,26.83 150.02,25.96 150.25,25.73 CK3.2 150.24,25.66 149.43,25.66 LK2.2 148.74,25.74 148.58,25.58 148.58,25.17 148.43,25.02 148.2,25.02 148.04,24.85 UK1.69 ; v2(260.88,39.96) 260.99,39.85 260.99,39.08 261.31,38.77 261.31,37.35 262.13,36.53 PH2.2 ; PH1.2 v2(135.16,96.66)
  IN1 w0.254: v2(135.16,96.66) 134.61,96.11 133.56,96.11 132.69,96.97 129.22,96.97 128.62,97.58 124.37,97.58 123.07,96.28 122.65,96.28 114.8,88.43 113.6,88.43 111.03,85.86 arc(109.24,83.17) 108.6,79.99 108.6,76.65 105.2,73.24 105.2,69.34 99.49,63.64 99.49,55.28 96.54,52.33 96.54,47.91 95.41,46.77 95.41,44.56 98.04,41.93 98.04,32.76 102.16,28.65 117.01,28.65 117.37,28.29 117.53,28.29 117.93,27.89 v2(117.93,27.8)
  IN2 w0.254: v2(260.88,39.96) 260.71,39.8 257.94,39.8 257.94,39.8 257.66,39.8 257.27,39.41 256.72,39.41 255.78,39.41 254.97,40.22 248.43,40.22 247.97,39.76 245.3,39.76 244.86,39.32 244.86,39.17 244.35,38.66 244.2,38.66 244.11,38.57 239.79,38.57 239.03,39.33 236.49,39.33 236.11,38.95 235.79,38.95 235.56,38.72 234.83,38.72 234.6,38.95 234.14,38.95 233.38,39.71 232.55,39.71 232.05,39.2 224.56,39.2 216.26,47.51 195.53,47.51 195.42,47.62 194.41,47.62 190.45,51.57 189.18,51.57 187.06,53.7 187.06,56.81 186.03,57.84 181.08,57.84 180.7,58.21 180.6,58.21 180.32,58.5 180.32,58.6 v2(180.22,58.7)
  BOTTOM w0.254: v2(180.22,58.7) 180.22,58.21 180.3,58.13 180.3,55.73 178.96,54.4 178.96,51.82 179.53,51.25 179.53,51.04 179.63,50.95 179.63,50.55 179.53,50.45 179.53,50.21 179.26,49.93 177.65,49.93 177.3,49.58 176.85,49.58 175.87,50.57 174.62,50.57 173.72,49.66 173.72,45.05 173.72,45.04 173.72,43.34 172.48,42.1 172.48,39.49 172.06,39.07 172.06,37.39 172.54,36.91 172.54,36.55 172.58,36.51 172.58,36.11 172.54,36.07 172.54,35.74 172.54,35.74 172.54,35.39 172.54,33.59 170.9,31.94 170.9,31.61 170.58,31.29 170.58,29.8 169.02,28.25 160.69,28.25 159.84,27.39 157.24,27.39 156.67,27.96 v2(156.67,28.03) ; v2(135.76,26.7) 135.63,26.57 135.63,26.49 135.35,26.21 134.95,26.21 134.72,26.44 132.89,26.44 131.86,27.47 124.66,27.47 123.44,27.47 123.22,27.25 123.18,27.25 118.25,27.25 117.93,27.57 v2(117.93,27.8)
EDP_AUXN: length 196.8
  IN1 w0.135: v2(168.86,102.47) 169.01,102.33 169.32,102.33 169.7,101.95 170,101.95 172.38,99.57 172.38,99.25 172.72,98.91 172.72,96.31 185.46,83.57 185.46,80.81 186.15,80.12 186.15,74.27 185.64,73.76 185.64,61.42 183.75,59.53 183.75,57.38 179.87,53.5 179.87,50.15 178.08,48.36 177.63,48.36 176.87,47.6 176.87,43.85 175.74,42.72 175.74,41.59 175.49,41.34 175.49,35.33 175.14,34.98 175.14,34.57 173.55,32.98 173.55,32.33 169.02,27.8 160.89,27.8 160.22,27.12 151.65,27.12 151.45,27.33 135.17,27.33 133.55,25.71 129.52,25.71 128.53,24.73 123.32,24.73 122.75,24.16 117.59,24.16 115.4,21.97 112.1,21.97 111.41,21.28 100.31,21.28 100.02,20.99 97.18,20.99 96.38,21.79 95.74,21.79 95.07,21.11 90.99,21.11 88.51,23.59 85.77,23.59 84.42,24.94 73.94,24.94 73.3,25.58 73.3,26.05 v2(73.15,26.2)
  BOTTOM w0.076: UC1.B26 167.21,101.06 166.94,101.06 166.9,101.02 166.9,100.88 167.09,100.68 168.04,100.68 168.25,100.9 168.25,102.09 168.43,102.26 168.65,102.26 v2(168.86,102.47)
  BOTTOM w0.127: CV8.1 73.24,26.63 73.24,26.29 v2(73.15,26.2)
EDP_AUXN_C: length 3.4
  BOTTOM w0.127: CV8.2 72.92,28.47 72.92,28.6 72.68,28.84 71.93,28.84 71.67,29.09 71.67,29.61 71.55,29.73 JEDP1.22
EDP_AUXP: length 196.8
  IN1 w0.135: v2(168.86,101.89) 168.86,102 168.92,102.05 169.21,102.05 169.58,101.67 169.88,101.67 170.17,101.39 170.17,101.18 170.45,100.9 170.66,100.9 170.94,100.61 170.94,100.41 171.23,100.12 171.44,100.12 172.1,99.46 172.1,99.14 172.44,98.79 172.44,98.39 172.3,98.24 172.3,97.84 172.44,97.7 172.44,97.29 172.3,97.15 172.3,96.74 172.44,96.6 172.44,96.2 172.85,95.78 172.85,95.58 173.14,95.29 173.34,95.29 173.63,95.01 173.63,94.8 173.92,94.52 174.12,94.52 174.41,94.23 174.41,94.03 174.69,93.74 174.9,93.74 175.18,93.46 175.18,93.25 175.47,92.97 175.67,92.97 175.96,92.68 175.96,92.48 176.24,92.19 176.45,92.19 176.73,91.9 176.73,91.7 177.02,91.41 177.22,91.41 177.51,91.13 177.51,90.92 177.8,90.64 178,90.64 185.18,83.46 185.18,80.7 185.87,80 185.87,74.38 185.37,73.88 185.37,61.54 183.47,59.64 183.47,57.5 179.59,53.62 179.59,50.26 177.97,48.64 177.51,48.64 176.59,47.71 176.59,43.96 175.46,42.84 175.46,41.7 175.21,41.45 175.21,35.45 174.86,35.1 174.86,34.68 173.27,33.09 173.27,32.45 168.9,28.08 160.78,28.08 160.1,27.4 151.77,27.4 151.57,27.61 135.06,27.61 133.44,25.99 129.4,25.99 128.42,25.01 123.2,25.01 122.64,24.44 117.48,24.44 115.28,22.25 111.99,22.25 111.3,21.56 100.19,21.56 99.9,21.27 97.3,21.27 96.5,22.06 95.62,22.06 94.95,21.39 91.11,21.39 88.62,23.87 85.88,23.87 84.54,25.22 74.06,25.22 73.58,25.69 73.58,26.05 v2(73.74,26.2)
  BOTTOM w0.076: v2(168.86,101.89) 168.86,102.08 168.83,102.11 168.49,102.11 168.41,102.03 168.41,100.84 168.1,100.53 167.03,100.53 166.74,100.81 166.74,100.88 UC1.C26
  BOTTOM w0.127: v2(73.74,26.2) 73.49,26.45 73.49,26.73 73.3,26.93 73.3,27.05 CV7.1
EDP_AUXP_C: length 3.4
  BOTTOM w0.127: CV7.2 73.17,28.49 73.17,28.71 72.79,29.09 v4(72.41,29.09) 72.03,29.09 71.93,29.2 71.93,29.62 72.05,29.74 JEDP1.23
EDP_DISP_UTIL: length 3.8
  BOTTOM w0.135: TC1.1 170.61,106.97 168.82,106.97 168.03,106.18 UC1.A33
EDP_HPD: length 160.9
  IN2 w0.127: v2(99.05,21.82) 99.35,22.12 108.89,22.12 112.93,18.08 116.92,18.08 117.93,19.1 121.34,19.1 121.46,19.22 123.34,19.22 124.15,20.03 130.31,20.03 130.55,20.27 131.68,20.27 132.66,19.3 137.07,19.3 137.87,20.1 140.85,20.1 141.41,20.66 146.18,20.66 146.69,21.17 151.11,21.17 152.65,22.71 160.54,22.71 161.16,22.09 175.48,22.09 179.68,26.29 180.24,26.29 182.79,28.85 184.83,28.85 186.16,27.52 187.36,27.52 189.47,29.63 194.92,29.63 195.76,28.79 195.76,27.62 196.03,27.35 198.52,27.35 198.77,27.1 200,27.1 200.11,26.99 200.12,26.99 200.28,26.82 200.4,26.82 200.45,26.76 201.12,26.76 201.16,26.81 201.51,26.81 201.54,26.78 201.91,26.78 201.94,26.81 202.59,26.81 203.42,27.63 203.92,27.63 204.31,27.24 206.14,27.24 207.49,28.6 209.65,28.6 210.04,28.98 v2(210.04,29)
  BOTTOM w0.102: v2(210.04,29) 210.04,28.53 209.39,27.88 209.39,26.94 209.99,26.33 210.76,26.33 211.56,25.53 211.63,25.36 211.63,25.04 UH1.AN6
  BOTTOM w0.127: v2(99.05,21.82) 96.73,19.5 87.51,19.5 83.99,23.02 77.15,23.02 v1(76.13,24.04) 75.29,24.87 RV7.1 74.7,24.87 73.8,25.78 72.95,25.78 72.59,26.14 72.53,26.14 72.27,26.4 72.27,26.63 71.84,27.06 RV6.1
EDP_HPD_PANEL: length 3.1
  BOTTOM w0.127: JEDP1.19 70.05,29.74 v1(70.81,28.98) 71.64,28.15 RV6.2
EDP_TXN0: length 202.6
  IN1 w0.135: v2(88.17,21.2) 88.17,21.39 88.32,21.53 88.53,21.53 91.05,19.01 107.03,19.01 107.32,19.3 111.6,19.3 111.73,19.43 112.73,20.42 115.89,20.42 118.16,22.7 126.64,22.7 127.13,23.19 131.75,23.19 132.78,24.23 136.38,24.23 137.55,25.4 168.67,25.4 174.99,31.71 174.99,32.38 176.57,33.97 176.57,34.39 176.92,34.74 176.92,39.23 177.74,40.04 177.74,41.91 178.05,42.22 178.05,42.84 182.26,47.05 182.26,49.19 181.91,49.54 181.91,50.32 182.11,50.52 182.11,53.62 185.31,56.82 185.31,59 187.08,60.77 187.08,72.74 187.61,73.27 187.61,84.07 186.54,85.14 185.93,85.14 174.7,96.37 174.7,100.18 171.38,103.5 170.24,103.5 169.12,104.62 165.48,104.62 165.1,104.24 165.1,103.91 v2(164.97,103.78)
  BOTTOM w0.076: UC1.E29 v2(164.97,103.78)
  BOTTOM w0.127: v2(88.17,21.2) 87.98,21.2 87.72,20.94 86.83,20.94 84.24,23.52 77.36,23.52 74.67,26.21 74.67,27 CV10.1
EDP_TXN0_C: length 3.5
  BOTTOM w0.127: CV10.2 74.72,28.45 74.72,28.59 74.49,28.82 73.67,28.82 73.18,29.31 73.18,29.74 73.05,29.87 JEDP1.25
EDP_TXN1: length 188.6
  IN1 w0.076: 165.83,101.04 165.77,101.04 165.61,101.2 165.61,102.2 v2(165.62,102.21)
  IN1 w0.135: v2(76.39,26.43) 76.51,26.31 76.51,25.99 76.84,25.66 77.9,25.66 79.2,26.95 84.55,26.95 86.42,25.08 89.05,25.08 90.8,23.33 94.56,23.33 96.07,24.84 96.71,24.84 96.91,25.03 97.59,25.03 99.16,23.46 113.02,23.46 115.24,25.68 118.95,25.68 119.82,26.55 128.26,26.55 128.89,27.18 131.82,27.18 133.88,29.24 168.39,29.24 170.83,31.68 170.83,32.31 172.8,34.28 172.8,36.7 173.64,37.54 173.64,42.77 175.34,44.47 175.34,48.15 176.06,48.87 176.06,50.25 177.43,51.63 177.43,53.21 182.13,57.9 182.13,60.02 184.21,62.1 184.21,78.66 183.22,79.65 183.22,82.05 181.97,83.3 181.97,84.62 170.96,95.63 170.96,98.63 169.75,99.83 167.04,99.83 165.83,101.04
  BOTTOM w0.076: UC1.E28 v2(165.62,102.21)
  BOTTOM w0.127: CV12.1 76.55,26.94 76.55,26.59 v2(76.39,26.43)
EDP_TXN1_C: length 3.7
  BOTTOM w0.127: CV12.2 76.55,28.47 76.55,28.56 76.46,28.64 75.64,28.64 75.19,29.09 74.67,29.62 74.67,29.81 74.55,29.92 JEDP1.28
EDP_TXN2: length 193.3
  IN1 w0.135: v2(87.4,22.26) 87.52,22.38 88.71,22.38 91.35,19.73 106.61,19.73 106.9,20.02 111.31,20.02 111.35,20.06 112.43,21.14 115.59,21.14 117.87,23.42 126.15,23.42 126.68,23.96 129.44,23.96 130.47,24.99 136.02,24.99 137.64,26.61 151.05,26.61 151.31,26.35 160.61,26.35 161.34,27.08 166.37,27.08 167.14,26.31 168.55,26.31 174.27,32.03 174.27,32.68 175.85,34.27 175.85,34.69 176.21,35.04 176.21,39.53 177.01,40.33 177.01,42.34 177.14,42.47 177.14,42.95 181.53,47.34 181.53,48.79 180.73,49.6 180.73,50.29 181.39,50.96 181.39,53.92 184.53,57.05 184.53,59.23 186.36,61.07 186.36,73.17 186.88,73.68 186.88,80.41 186.19,81.1 186.19,83.87 173.59,96.46 173.59,99.66 170.52,102.73 170,102.73 169.07,103.65 167.7,103.65 v2(167.57,103.78)
  BOTTOM w0.076: UC1.B29 v2(167.57,103.78)
  BOTTOM w0.127: CV14.1 78.29,27.02 78.29,25.8 79.77,24.33 84.67,24.33 86.58,22.42 87.24,22.42 v2(87.4,22.26)
EDP_TXN2_C: length 4
  BOTTOM w0.127: CV14.2 78.36,28.47 78.36,28.55 78.27,28.65 77.56,28.65 76.87,29.34 76.4,29.34 76.17,29.57 76.17,29.76 76.05,29.88 JEDP1.31
EDP_TXN3: length 184
  IN1 w0.076: v2(167.57,102.21) 167.81,101.97 167.86,101.97 168.83,101 168.91,101 168.92,100.98
  IN1 w0.135: 168.92,100.98 169.34,100.56 170.04,100.56 171.84,98.76 171.84,95.97 184.67,83.14 184.67,80.55 185.38,79.85 185.38,75.01 184.93,74.56 184.93,61.75 182.99,59.81 182.99,57.67 178.26,52.94 178.26,50.03 176.09,47.87 176.09,44.09 175.02,43.02 175.02,41.98 174.77,41.73 174.77,37.65 174.11,37 174.11,35.46 173.52,34.86 173.52,33.97 171.6,32.05 171.6,31.42 168.7,28.52 135.31,28.52 133.24,26.45 129.18,26.45 128.17,25.44 123.02,25.44 122.54,24.96 115.54,24.96 113.26,22.69 111.8,22.69 111.15,22.03 100.3,22.03 99.97,22.36 98.62,22.36 97.59,23.39 95.67,23.39 94.79,22.52 90.6,22.52 88.81,24.31 86.12,24.31 84.76,25.67 80.57,25.67 80.27,25.97 80.27,26.27 v2(80.12,26.43)
  BOTTOM w0.076: UC1.B28 v2(167.57,102.21)
  BOTTOM w0.127: CV16.1 80.27,26.94 80.27,26.59 v2(80.12,26.43)
EDP_TXN3_C: length 4.5
  BOTTOM w0.127: JEDP1.34 77.55,29.89 77.67,29.77 77.67,29.57 77.9,29.34 78.71,29.34 79.23,28.83 80.19,28.83 80.27,28.75 80.27,28.47 CV16.2
EDP_TXP0: length 202.7
  IN1 w0.135: v2(165.62,103.78) 165.49,103.78 165.38,103.88 165.38,104.13 165.6,104.34 166.22,104.34 166.36,104.2 166.77,104.2 166.91,104.34 167.72,104.34 167.87,104.2 168.27,104.2 168.41,104.34 169.01,104.34 170.12,103.22 171.26,103.22 171.55,102.94 171.55,102.73 171.83,102.45 172.04,102.45 172.32,102.16 172.32,101.96 172.61,101.67 172.82,101.67 173.1,101.39 173.1,101.18 173.39,100.9 173.59,100.9 174.42,100.07 174.42,99.66 174.27,99.52 174.27,99.12 174.42,98.97 174.42,98.57 174.27,98.42 174.27,98.02 174.42,97.87 174.42,96.25 185.81,84.86 186.43,84.86 187.33,83.95 187.33,73.38 186.8,72.85 186.8,60.89 185.03,59.11 185.03,56.94 181.83,53.74 181.83,50.63 181.63,50.43 181.63,49.42 181.98,49.08 181.98,47.16 177.77,42.95 177.77,42.33 177.46,42.02 177.46,40.16 176.64,39.35 176.64,34.85 176.29,34.5 176.29,34.09 174.71,32.5 174.71,31.83 168.56,25.68 137.44,25.68 136.27,24.51 132.67,24.51 131.63,23.47 127.02,23.47 126.53,22.98 118.05,22.98 115.77,20.7 112.61,20.7 111.53,19.62 111.49,19.58 107.21,19.58 106.92,19.29 91.17,19.29 88.65,21.81 88.2,21.81 87.94,21.55 87.81,21.55 v2(87.67,21.7)
  BOTTOM w0.076: v2(165.62,103.78) 165.96,103.44 UC1.D29
  BOTTOM w0.127: v2(87.67,21.7) 87.79,21.58 87.79,21.37 87.61,21.19 86.94,21.19 86.61,21.52 86.61,21.72 86.32,22.01 86.12,22.01 85.83,22.29 85.83,22.5 85.55,22.79 85.34,22.79 84.35,23.78 v4(81.74,23.78) 77.47,23.78 74.93,26.32 74.93,27.17 75.01,27.25 CV9.1
EDP_TXP0_C: length 3.5
  BOTTOM w0.127: CV9.2 74.97,28.51 74.97,28.7 74.59,29.08 v4(74.13,29.08) 73.78,29.08 73.44,29.42 73.44,29.77 73.55,29.88 JEDP1.26
EDP_TXP1: length 188.7
  IN1 w0.076: 165.65,100.85 165.65,100.87 165.64,100.87 165.64,100.94 165.45,101.13 165.45,101.82 165.36,101.91 164.99,101.91 164.88,102.02 164.88,102.11 v2(164.97,102.21)
  IN1 w0.135: v2(76.98,26.43) 76.79,26.24 76.79,26.1 76.96,25.93 77.78,25.93 79.08,27.23 84.66,27.23 86.54,25.36 89.17,25.36 90.92,23.61 94.45,23.61 95.95,25.11 96.6,25.11 96.79,25.31 97.71,25.31 99.28,23.74 112.9,23.74 115.13,25.96 118.83,25.96 119.7,26.83 128.14,26.83 128.77,27.46 131.7,27.46 133.77,29.52 168.28,29.52 170.56,31.8 170.56,32.43 172.52,34.39 172.52,36.82 173.36,37.66 173.36,42.89 175.06,44.59 175.06,48.27 175.78,48.98 175.78,50.37 177.15,51.74 177.15,53.32 181.85,58.02 181.85,60.14 183.93,62.22 183.93,78.55 182.94,79.54 182.94,81.94 181.69,83.19 181.69,84.51 170.68,95.52 170.68,96.32 170.53,96.46 170.53,96.86 170.68,97.01 170.68,97.41 170.53,97.56 170.53,97.96 170.68,98.11 170.68,98.51 169.64,99.55 168.35,99.55 168.2,99.4 167.8,99.4 167.66,99.55 166.93,99.55 166.41,100.07 166.21,100.07 165.92,100.35 165.92,100.56 165.63,100.84 165.65,100.85
  BOTTOM w0.076: UC1.F28 164.66,102.52 v2(164.97,102.21)
  BOTTOM w0.127: CV11.1 76.81,26.93 76.81,26.6 v2(76.98,26.43)
EDP_TXP1_C: length 3.7
  BOTTOM w0.127: CV11.2 76.8,28.49 76.8,28.66 76.56,28.9 75.75,28.9 75.37,29.28 74.92,29.72 74.92,29.8 75.05,29.93 JEDP1.29
EDP_TXP2: length 193.3
  IN1 w0.135: v2(87.4,22.97) 87.4,22.8 87.55,22.66 88.82,22.66 91.47,20.01 106.49,20.01 106.78,20.3 111.19,20.3 111.23,20.34 112.31,21.42 115.47,21.42 117.75,23.7 126.03,23.7 126.57,24.24 129.32,24.24 130.36,25.27 135.9,25.27 137.52,26.89 151.17,26.89 151.43,26.63 160.49,26.63 161.23,27.36 166.49,27.36 167.26,26.59 168.43,26.59 173.99,32.15 173.99,32.8 175.57,34.38 175.57,34.8 175.93,35.15 175.93,39.64 176.73,40.45 176.73,42.45 176.86,42.58 176.86,43.06 181.25,47.46 181.25,48.68 180.45,49.48 180.45,50.41 181.11,51.08 181.11,54.04 184.25,57.17 184.25,59.35 186.08,61.19 186.08,73.28 186.6,73.8 186.6,80.3 185.91,80.99 185.91,83.75 173.31,96.35 173.31,98.44 173.16,98.59 173.16,98.99 173.31,99.14 173.31,99.54 172.73,100.12 172.53,100.12 172.24,100.4 172.24,100.61 171.96,100.89 171.75,100.89 171.47,101.18 171.47,101.38 171.18,101.67 170.98,101.67 170.69,101.96 170.69,102.16 170.4,102.45 169.88,102.45 168.96,103.37 167.68,103.37 167.57,103.26 v2(167.57,102.99)
  BOTTOM w0.076: v2(167.57,102.99) 167.91,103.33 UC1.A29
  BOTTOM w0.127: v2(87.4,22.97) 87.4,22.78 87.3,22.67 86.68,22.67 84.77,24.58 79.87,24.58 78.54,25.91 78.54,27.15 78.65,27.25 CV13.1
EDP_TXP2_C: length 4
  BOTTOM w0.127: JEDP1.32 76.55,29.9 76.43,29.77 76.43,29.68 76.51,29.6 76.97,29.6 77.67,28.9 78.38,28.9 78.62,28.66 78.62,28.49 CV13.2
EDP_TXP3: length 184
  IN1 w0.076: 168.72,100.79 168.71,100.8 168.71,100.88 167.79,101.8 167.41,101.8 167,102.21 v2(166.92,102.21)
  IN1 w0.135: v2(80.7,26.43) 80.55,26.27 80.55,26.08 80.68,25.95 84.87,25.95 86.23,24.59 88.92,24.59 90.72,22.8 94.68,22.8 95.55,23.67 97.7,23.67 98.73,22.64 100.08,22.64 100.42,22.31 111.03,22.31 111.69,22.97 113.15,22.97 115.42,25.24 122.42,25.24 122.9,25.72 128.05,25.72 129.06,26.73 133.12,26.73 135.2,28.8 168.58,28.8 171.32,31.54 171.32,32.16 173.24,34.08 173.24,34.98 173.83,35.57 173.83,37.11 174.49,37.77 174.49,41.85 174.74,42.1 174.74,43.13 175.81,44.21 175.81,47.98 177.98,50.15 177.98,53.06 182.71,57.79 182.71,59.92 184.65,61.86 184.65,74.68 185.1,75.13 185.1,79.73 184.39,80.43 184.39,83.02 174.02,93.4 173.81,93.4 173.53,93.69 173.53,93.89 173.24,94.18 173.04,94.18 172.75,94.46 172.75,94.67 172.46,94.95 172.26,94.95 171.97,95.24 171.97,95.44 171.56,95.85 171.56,96.45 171.42,96.6 171.42,97 171.56,97.15 171.56,97.55 171.42,97.69 171.42,98.1 171.56,98.24 171.56,98.65 169.92,100.29 169.22,100.29 168.72,100.79
  BOTTOM w0.076: v2(166.92,102.21) 166.61,102.52 UC1.C28
  BOTTOM w0.127: CV15.1 80.53,26.93 80.53,26.6 v2(80.7,26.43)
EDP_TXP3_C: length 4.5
  BOTTOM w0.127: CV15.2 80.53,28.49 80.53,28.85 80.3,29.08 v4(79.79,29.08) 79.34,29.08 78.82,29.6 78.01,29.6 77.93,29.68 77.93,29.8 78.05,29.92 JEDP1.35
EN_1.0V_VCCSTG: length 2.8
  TOP w0.127: RC373.2 179.81,107.81 180.32,108.32 v3(180.32,108.68)
  TOP w0.254: UC5.4 179.19,106.92 RC373.2
EN_1.0V_VCCSTU: length 3.5
  TOP w0.127: v1(252.09,36.87) 252.5,36.87 252.58,36.95 RC370.2
  TOP w0.203: UC4.3 253.91,38.05 253.62,37.76 253.62,37.4 253.8,37.22 CC408.1 253.14,36.94 RC370.2
EN_1.8V: length 5.1
  BOTTOM w0.127: PR1805.1 263.68,22.49 v1(263.76,22.41)
  BOTTOM w0.254: PR1804.2 PC1805.1 262.68,23.39 PR1805.1 262.68,22.24 262.51,22.06 262.51,20.87 262.56,20.82 PU1801.7
EN_1.8VS: length 3.1
  TOP w0.127: RC371.2 255.9,36.8 v3(256.21,37.12)
  TOP w0.203: RC371.2 255.07,37.75 254.71,38.11 UC4.5
EN_1V05: length 4.9
  BOTTOM w0.254: PU1001.11 238.72,25.22 238.9,25.03 239.63,25.03 v2(240.07,25.47) 240.3,25.69 PC1001.1 240.77,25.66 PR1005.1 240.77,24.12 240.79,24.09 PR1003.2
EN_2.5V: length 6
  TOP w0.127: PR2501.2 106.53,14.02 v1(106.53,12.7)
  TOP w0.254: PR2501.2 107.42,14.51 107.42,14.51 PR2502.2 108.64,14.51 PR2503.1 109.06,14.51 109.08,14.49 PC2502.1 109.49,14.98 109.47,15.01 PU2501.1
EN_3VS_5VS: length 6.7
  TOP w0.203: U10.5 268.16,43.28 268.81,43.93 269.85,43.93 R5253.2 269.98,43.62 270.2,43.4 v3(270.2,42.62) 270.04,42.45 268.11,42.45 268.08,42.48 U10.3
EN_INVPWR: length 4.6
  TOP w0.127: v3(79.38,33.93) 79.38,33.2 PRP2.2 PRP3.1 PCP4.1 80.65,33.89 PUP1.3
EN_VCCIOP: length 4.3
  BOTTOM w0.127: PRH5.2 182.55,98.32 PRH7.1 PCH13.1 182.55,101.18 v2(182.64,101.27) 182.64,101.53 182.52,101.66 182.52,101.94 182.64,102.07 PUH1.11
ENLDO_3V5V: length 207.7
  IN2 w0.127: v2(254.6,31.19) 254.24,30.83 249.29,30.83 248.08,30.83 247.37,31.54 240.23,31.54 237.81,31.54 237.41,31.15 227.74,31.15 221.79,25.19 221.79,23.21 220.04,21.45 218.13,21.45 217.59,20.91 215.64,20.91 213.67,18.94 210.2,18.94 208.73,17.47 208.73,16.03 207.9,15.2 197.71,15.2 197.57,15.06 194.05,15.06 192.81,13.82 190.5,13.82 189.77,13.09 187.98,13.09 186.77,14.3 183.08,14.3 182.63,14.74 182.63,16.2 181.32,17.52 169.2,17.52 167.94,16.26 154.08,16.26 152.3,14.47 151.73,14.47 150.61,13.36 145.79,13.36 145.2,12.77 135.94,12.77 135.81,12.89 133.07,12.89 131.97,13.99 127.54,13.99 126.97,13.42 125.95,13.42 125.11,12.58 119.62,12.58 119.51,12.47 110.22,12.47 108.69,13.99 104.53,13.99 103.62,13.09 101.91,13.09 98.74,16.25 77.91,16.25 v2(77.47,15.82)
  BOTTOM w0.127: v2(77.47,15.82) 77.01,15.35 76.68,15.35 v1(76.19,14.87) 75.13,13.81 PR306.2 75.13,13.15 74.98,13 PR308.1 ; PU301.11 251.41,30.99 251.58,31.16 251.58,31.77 251.86,32.05 253.87,32.05 254.6,31.32 v2(254.6,31.19)
  BOTTOM w0.254: PR308.1 74.98,12.21 75.01,12.18 PC329.1 75.01,11.45 74.86,11.31 74.86,10.77 75.18,10.45 PU302.5
FAN_SPEED1: length 169.7
  TOP w0.127: v2(273.99,44.94) RE1.2 CE5.1 ; v2(274.18,24.84) v3(274.18,24.13) ; v2(147.93,9.83) 147.92,9.81 147.92,9.62 148.04,9.5 UK1.28
  IN2 w0.127: v2(274.18,24.84) 274.18,20.15 273.2,19.17 272.48,19.17 270.89,17.58 263.18,17.58 262.96,17.36 258.45,17.36 258.08,17.74 236.82,17.74 236.46,17.38 233.22,17.38 233.01,17.17 226.71,17.17 223.43,13.89 223.43,13.43 221.27,11.27 219.82,11.27 219.08,10.53 218.03,10.53 217.09,9.59 210.98,9.59 210.71,9.32 206.39,9.32 206.02,9.69 203.56,9.69 203.27,9.98 198.18,9.98 197.5,9.31 192.48,9.31 192.47,9.3 189.93,9.3 188.97,8.33 182.09,8.33 180,10.43 179.93,10.43 179.68,10.68 179.68,11.7 179.39,11.99 174.46,11.99 171.73,14.72 154.45,14.72 150.37,10.63 148.5,10.63 147.93,10.06 v2(147.93,9.83)
  BOTTOM w0.127: v2(274.18,24.84) 274.6,25.27 274.6,26.25 274.44,26.41 274.44,35.58 273.6,36.42 273.6,43.6 273.99,43.99 v2(273.99,44.94) 273.99,44.95 JFAN1.2
FAN_SPEED2: length 135
  TOP w0.127: UK1.101 134.65,20.62 134.54,20.73 134.54,23.87 133.03,25.38 v3(129.67,25.38) 129.22,24.94 v2(129.22,24.82)
  IN3 w0.127: v2(98.07,28.83) 99.38,27.52 102.05,27.52 103.83,25.75 103.83,25.02 104.29,24.55 111.76,24.55 112.23,25.02 113.74,25.02 115.56,26.83 115.8,26.83 117.22,28.25 118.72,28.25 118.94,28.04 118.94,27.27 119.64,26.57 120.77,26.57 120.98,26.35 127.69,26.35 v2(129.22,24.82)
  BOTTOM w0.127: JFAN2.2 42.6,46.9 42.63,46.92 43.64,46.92 43.96,46.61 43.96,40.66 44.47,40.16 RE3.2 46.02,40.16 CE6.1 46.06,39.84 46.26,39.63 49.13,39.63 50.16,40.66 50.16,42.66 50.55,43.05 51.79,43.05 53.07,41.77 55.85,41.77 56.23,42.15 70.49,42.15 71.81,43.48 80.98,43.48 84.22,46.71 97.65,46.71 99.32,45.04 99.32,40.81 98.88,40.38 98.12,40.38 97.36,39.62 97.36,30.42 98.07,29.71 v2(98.07,28.83)
FB_1.8V: length 4.3
  BOTTOM w0.127: v1(266.1,24.29) PR1803.2
  BOTTOM w0.254: PU1801.1 266.52,21.32 PR1806.1 266.12,21.8 PC1802.2 266.12,23.33 PR1803.2
FB_1V: length 3.6
  BOTTOM w0.254: PUH1.14 182.34,103.42 181.67,102.74 PRH8.1 PRH6.2 181.46,104 PRH4.2
FB_1V05: length 3.6
  BOTTOM w0.254: PU1001.14 237.37,24.86 v2(237.65,24.58) 237.93,24.3 PR1006.2 PR1020.2 238.76,23.83 PR1007.1
FB_2.5V: length 4.2
  TOP w0.127: v1(105.01,13.93) 105.15,14.07 PC2504.2
  TOP w0.254: PR2506.2 105.66,14.87 105.61,14.92 PC2504.2 105.15,15.37 105.16,15.38 PR2507.1 105.35,15.96 PU2501.6
FB_2PH: length 6
  TOP w0.127: PRZ42.1 170.15,135.33 v1(170.31,135.16)
  TOP w0.203: PRZ42.1 168.94,135.28 PCZ21.1 168.94,133.83 v2(168.86,133.75)
  BOTTOM w0.203: PUZ1.34 168.63,133.35 168.86,133.59 v2(168.86,133.75) 168.95,133.84 168.95,134.47 168.98,134.5 PRZ41.1 168.98,135.34 PCZ20.2
FB_3V_LCDVDD: length 4.6
  TOP w0.127: v1(77.09,41.49) RV50.1
  TOP w0.254: CV2.2 RV49.2 RV50.1 76.64,40.54 76.44,40.34 UV1.6
FB_4PH: length 7.3
  TOP w0.203: v2(170.77,123.8) 170.85,123.88 PCZ16.2 171.53,123.74 PCZ19.2
  BOTTOM w0.203: PUZ1.5 169.03,125.46 169.39,125.1 v1(169.39,124.66) 169.94,124.1 170.46,124.1 v2(170.77,123.8) 170.82,123.8 171.07,123.54 PRZ36.1 171.07,122.35 PRZ35.1
FB_+1.0VSDGP: length 5.8
  BOTTOM w0.127: v1(177.56,105.93) 176.55,104.91 PRF4.2
  BOTTOM w0.254: PUF1.6 175.65,103.07 175.65,103.86 PRF6.1 175.61,104.18 PRF4.2 176.6,104.18 PCF2.2
FB_CAL_PD_VDDQ: length 1.5
  TOP w0.356: v2(213.77,96.98) 213.57,97.18 RG47.2
  BOTTOM w0.109: v2(213.77,96.98) 213.64,96.98 UG1.J27
FB_CAL_PU_GND: length 0.6
  BOTTOM w0.356: UG1.H27 v2(213.63,97.76)
FB_CAL_TERM_GND: length 1.3
  TOP w0.457: v2(214.48,96.16) 214.77,96.16 RG49.2
  BOTTOM w0.356: UG1.H25 v2(214.48,96.16)
FB_DDR: length 3.9
  BOTTOM w0.203: PUM1.6 92.45,25.11 92.84,24.71 93.01,24.71 93.34,24.38 v1(93.96,24.38) 94.73,24.38 PRM6.1 PRM9.1
FB_GND_SENSE: length 5.9
  BOTTOM w0.102: UG1.F2 215.68,76.5 215.89,76.29 216.08,76.1 216.08,75.55 216.48,75.15 216.78,75.15 217.42,74.51
  BOTTOM w0.109: 217.83,74.1 217.42,74.51
  BOTTOM w0.132: TG10.1 219.55,72.38 217.83,74.1
FB_VDDQ_SENSE: length 36.7
  TOP w0.127: v2(242.51,61.51) v1(242.51,60.97)
  IN2 w0.254: v2(216.4,74.72) 216.4,73.93 220.77,69.57 222.65,69.57 225.13,67.09 231.46,67.09 234.14,64.42 241.19,64.42 242.02,63.58 242.02,62.01 v2(242.51,61.51)
  BOTTOM w0.254: v2(216.4,74.72) 216.08,75.05 216.08,75.16 215.68,75.55 UG1.F1 ; v2(242.51,61.51) 242.51,61.23 RG45.1 242.69,60.72 PRW15.2
FBA0_VREFC: length 4.8
  BOTTOM w0.381: RG50.2 RG51.2 227.8,127.76 227.78,127.79 RG52.1 CG89.1 225.87,127.79
  BOTTOM w0.406: 225.87,127.79 225.86,127.8 UG4.J14
FBA0_ZQ1: length 4.3
  BOTTOM w0.127: RG58.1 227.01,127.27 226.04,127.27 225.91,127.41 223.79,127.41 UG4.J13
FBA1_VREFC: length 6.1
  BOTTOM w0.127: RG53.2 183.01,127.29 v1(183.47,126.83)
  BOTTOM w0.406: UG5.J14 187.12,127.83 184.81,127.83 CG88.1
  BOTTOM w0.508: CG88.1 RG56.1 RG53.2 182.99,127.81 RG54.2
FBA1_ZQ3: length 4.6
  BOTTOM w0.102: 186.93,127.33 187.03,127.44 187.59,127.44 UG5.J13
  BOTTOM w0.127: RG61.1 v1(185.08,126.83) 186.43,126.83 186.93,127.33
FBA_CLKA0: length 40.2
  TOP w0.132: v2(207.76,100.34) 208.07,100.66 208.07,100.9 208.15,100.97 208.15,101.31 207.94,101.52 207.94,102.24 208.7,103 208.7,104.94 212.31,108.56 215.63,108.56 222.06,114.98 222.06,116.44 v2(221.9,116.6)
  IN1 w0.102: 220.5,127 220.72,127.23 220.72,127.55 221.37,128.2 v2(222.2,128.2)
  IN1 w0.152: 220.5,127 220.45,126.96 220.45,119.46 222.11,117.8 222.11,116.81 v2(221.9,116.6)
  BOTTOM w0.102: UG4.J12 v2(222.2,128.2)
  BOTTOM w0.132: v2(207.76,100.34) 208.16,99.94 UG1.R30 ; v2(221.9,116.6) 222.08,116.41 222.08,115.99 RG63.1
FBA_CLKA0#: length 40.1
  TOP w0.132: v2(208.58,100.34) 208.32,100.6 208.32,100.8 208.4,100.87 208.4,101.41 208.18,101.62 208.18,102.14 208.95,102.9 208.95,104.84 212.42,108.31 215.73,108.31 222.3,114.88 222.3,116.37 v2(222.53,116.6)
  IN1 w0.102: 220.74,126.84 220.79,126.88 220.79,127.01 220.92,127.14 220.92,127.46 221.45,127.99 221.85,127.99 222.2,127.64 v2(222.2,127.4)
  IN1 w0.152: v2(222.53,116.6) 222.4,116.73 222.4,117.93 220.74,119.58 220.74,126.84
  BOTTOM w0.102: v2(222.2,127.4) 221.8,127.8 UG4.J11
  BOTTOM w0.132: RG95.1 222.33,115.95 222.33,116.4 v2(222.53,116.6) ; v2(208.58,100.34) UG1.R31
FBA_CLKA1: length 36.8
  TOP w0.102: 200.55,105.13 200.57,105.12 200.57,105.09 200.99,104.67 200.99,102.18 201.6,101.57 201.6,101.33 201.79,101.14 v2(201.91,101.14)
  TOP w0.132: v2(190.08,115.98) 189.86,115.98 189.69,115.82 189.69,115.59 193.09,112.19 194.45,112.19 200.29,106.35 200.29,105.39 200.55,105.13
  IN1 w0.102: 190.81,126.99 190.81,127.02 190.77,127.06 190.77,127.39 190.05,128.11 189.24,128.11 v2(189.15,128.2)
  IN1 w0.152: v2(190.08,115.98) 190.08,116.2 190.81,116.94 190.81,126.99
  BOTTOM w0.102: UG5.J12 v2(189.15,128.2)
  BOTTOM w0.132: RG96.1 189.65,115.85 189.77,115.98 v2(190.08,115.98) ; v2(201.91,101.14) 202.31,100.74 UG1.AB31
FBA_CLKA1#: length 36.8
  TOP w0.102: 200.38,104.96 200.4,104.94 200.42,104.94 200.78,104.58 200.78,102.09 201.39,101.48 201.39,101.27 201.27,101.14 v2(201.08,101.14)
  TOP w0.132: 200.38,104.96 200.05,105.29 200.05,106.25 194.35,111.95 192.99,111.95 189.45,115.49 189.45,115.92 189.65,116.12 v2(189.65,116.41)
  IN1 w0.102: 190.52,126.99 190.52,127.02 190.57,127.06 190.57,127.32 189.98,127.9 189.41,127.9 189.15,127.64 v2(189.15,127.4)
  IN1 w0.152: 190.52,126.99 190.52,117.06 189.87,116.41 v2(189.65,116.41)
  BOTTOM w0.102: UG5.J11 189.55,127.8 v2(189.15,127.4)
  BOTTOM w0.132: UG1.AC31 v2(201.08,101.14) ; v2(189.65,116.41) 189.65,116.2 189.46,116.01 RG62.1
FBA_CMD0: length 36.8
  TOP w0.102: 208.39,103.21 207.57,102.39 207.57,101.64 207.37,101.44 207.37,100.81 v2(206.91,100.34) ; 221.92,119.09 221.92,120.03 220.99,120.96 220.99,125.96 221.25,126.22 221.82,126.22 v2(222.2,126.6)
  TOP w0.196: 208.39,103.21 208.39,105.31 209.95,106.87 209.95,107.14 212.24,109.43 215.56,109.43 219.66,113.54 219.66,115.33 221.92,117.59 221.92,119.09
  BOTTOM w0.102: UG4.G12 v2(222.2,126.6)
  BOTTOM w0.196: v2(206.91,100.34) 206.51,99.94 UG1.U30
FBA_CMD1: length 35
  TOP w0.102: 207.9,103.2 207.3,102.6 207.3,101.76 206.91,101.36 v2(206.91,101.14) ; v2(221.35,126.64) 221.3,126.64 220.74,126.07 220.74,120.64 221.3,120.07 221.3,119.03
  TOP w0.196: 207.9,103.2 207.9,105.55 209.35,107 209.35,107.39 209.4,107.44 209.4,107.45 211.98,110.04 215.31,110.04 219.06,113.79 219.06,115.58 221.3,117.82 221.3,119.03
  BOTTOM w0.102: v2(221.35,126.64) 221,126.99 UG4.H10
  BOTTOM w0.196: v2(206.91,101.14) 207.31,100.74 UG1.T31
FBA_CMD2: length 37.4
  TOP w0.102: 207.44,103.18 206.5,102.23 206.5,100.12 206.91,99.71 v2(206.91,99.52) ; v2(221.4,127.4) 220.48,126.48 220.48,120.27 220.7,120.05 220.7,118.78
  TOP w0.196: 207.44,103.18 207.44,105.94 208.75,107.25 208.75,107.64 208.79,107.69 208.79,107.7 211.73,110.64 214.91,110.64 218.46,114.19 218.46,115.83 220.7,118.07 220.7,118.78
  BOTTOM w0.102: UG4.H11 v2(221.4,127.4)
  BOTTOM w0.196: UG1.U29 v2(206.91,99.52)
FBA_CMD3: length 32
  TOP w0.102: v2(220.27,128.22) 219.9,127.84 219.9,126.87 220.09,126.68 220.09,118.78
  TOP w0.196: 220.09,118.78 220.09,118.34 217.79,116.04 217.79,114.37 216.29,112.87 v2(216.17,112.87)
  BOTTOM w0.102: UG4.K11 221.8,128.57 221.44,128.22 v2(220.27,128.22)
  BOTTOM w0.196: UG1.R34 208.18,104.88 v2(216.17,112.87)
FBA_CMD4: length 32.5
  TOP w0.102: 219.48,118.96 219.64,119.12 219.64,128.17 v2(220.27,128.8)
  TOP w0.196: v2(217.19,114.7) 217.19,116.29 219.48,118.58 219.48,118.96
  BOTTOM w0.102: v2(220.27,128.8) 220.47,128.6 UG4.K10
  BOTTOM w0.196: v2(217.19,114.7) 217.14,114.66 217.14,112.91 209.9,105.67 209.57,105.67 208.58,104.68 208.58,102.74 UG1.R33
FBA_CMD5: length 37.9
  TOP w0.102: v2(220.02,129.5) 219.39,128.87 219.39,119.63 218.92,119.16
  TOP w0.196: v2(216.18,114.13) 216.18,116.13 218.92,118.88 218.92,119.16
  BOTTOM w0.102: UG4.L12 222.19,128.99 220.81,128.99 220.49,129.31 220.21,129.31 v2(220.02,129.5)
  BOTTOM w0.196: UG1.U32 206.09,101.93 206.09,102.5 206.32,102.73 206.33,102.73 206.34,102.74 206.63,102.74 206.87,102.98 206.87,105.81 207.44,106.38 207.44,106.93 214.64,114.13 v2(216.18,114.13)
FBA_CMD6: length 33.9
  TOP w0.102: v2(216.6,128.2) 217.01,128.61 217.73,128.61 218.82,127.52 218.82,120.48 217.24,118.9
  TOP w0.196: v2(214.58,113.22) 214.45,113.35 214.45,116.11 217.24,118.9
  BOTTOM w0.102: UG4.K4 v2(216.6,128.2)
  BOTTOM w0.196: UG1.U33 206.7,102.34 207.33,102.97 207.33,105.64 208.1,106.41 208.1,106.71 211.97,110.59 v2(214.58,113.22)
FBA_CMD7: length 40.5
  TOP w0.102: 206.91,103 206.06,102.16 206.06,101.77 205.7,101.4 205.7,100.18 205.92,99.96 206.18,99.96 206.46,99.67 206.46,99.05 v2(206.08,98.67) ; v2(217.5,129.19) 217.73,129.19 219.07,127.85 219.07,120.05 218.36,119.34
  TOP w0.196: 218.36,119.34 218.36,119.17 215.31,116.12 215.31,112.28 214.28,111.24 211.94,111.24 211.94,111.24 211.76,111.24 211.48,111.24 207.76,107.52 207.76,106.86 206.91,106.01 206.91,103
  BOTTOM w0.102: UG4.K5 217.5,129.1 v2(217.5,129.19)
  BOTTOM w0.196: UG1.U28 206.48,98.27 v2(206.08,98.67)
FBA_CMD8: length 40.1
  TOP w0.102: 206.04,103.07 205.18,102.21 205.18,101.58 204.9,101.3 204.9,99.27 205.08,99.09 205.55,99.09 205.7,98.94 205.7,98.22 v2(206.08,97.84) ; v2(216.6,127.4) 216.92,127.72 217.33,127.72 217.33,127.72 217.67,127.72 218.31,127.08 218.31,120.94 216.96,119.59 216.23,119.59 215.42,118.78
  TOP w0.196: 206.04,103.07 206.04,106.31 206.56,106.83 206.56,108.02 210.98,112.44 212.44,112.44 213.01,113.01 213.01,116.37 215.42,118.78
  BOTTOM w0.102: UG4.J4 v2(216.6,127.4)
  BOTTOM w0.196: UG1.V28 v2(206.08,97.84)
FBA_CMD9: length 37.2
  TOP w0.102: 206.45,102.91 205.43,101.89 205.43,100.16 v2(206.08,99.52) ; v2(217.5,128.12) 217.75,128.12 218.56,127.31 218.56,120.73 217.04,119.21 216.7,119.21 216.27,118.78
  TOP w0.196: 206.45,102.91 206.45,106.16 207.16,106.87 207.16,107.77 211.23,111.84 211.5,111.84 212.69,111.84 213.78,112.93 213.78,116.29 216.27,118.78
  BOTTOM w0.102: v2(217.5,128.12) 217.17,127.8 UG4.J5
  BOTTOM w0.196: UG1.V29 205.68,99.11 v2(206.08,99.52)
FBA_CMD10: length 39.1
  TOP w0.102: 216.42,120.57 216.77,120.57 217.85,121.65 217.85,125.91 217.47,126.3 216.89,126.3 v2(216.6,126.6) ; 205.35,102.85 204.9,102.4 204.9,101.79 204.62,101.51 204.62,99.2 205.13,98.69 v2(205.2,98.69)
  TOP w0.196: 216.42,120.57 215.5,120.57 211.35,116.42 211.35,113.66 205.95,108.27 205.95,106.83 205.47,106.34 205.47,102.97 205.35,102.85
  BOTTOM w0.102: UG4.H4 v2(216.6,126.6)
  BOTTOM w0.196: UG1.V30 205.64,99.98 205.36,99.98 205,100.34 204.67,100.34 204.43,100.11 204.43,99.46 v2(205.2,98.69)
FBA_CMD11: length 30.3
  TOP w0.102: v2(217.5,127.29) 218.06,126.74 218.06,121.39 216.66,120 215.78,120 214.74,118.95
  TOP w0.196: v2(212.27,113.56) 212.41,113.7 212.41,116.62 214.74,118.95
  BOTTOM w0.102: v2(217.5,127.29) 217.21,127 UG4.H5
  BOTTOM w0.196: UG1.U34 206.48,106.16 206.84,106.52 206.84,108.17 212.22,113.56 v2(212.27,113.56)
FBA_CMD12: length 34.8
  IN1 w0.102: v2(215.8,126.6) 215.38,127.02 213.87,127.02 213.61,127.28 212.97,127.28 212.82,127.43 212.03,127.43
  IN1 w0.203: 212.03,127.43 208.73,124.14 208.73,117.06 207.67,115.99 207.67,112.95 205.15,110.43 205.15,106.24 206.08,105.31 v2(206.08,101.14)
  BOTTOM w0.102: UG4.G3 v2(215.8,126.6)
  BOTTOM w0.196: UG1.U31 v2(206.08,101.14)
FBA_CMD13: length 32.7
  TOP w0.152: RG89.2 212.49,128.21 213.38,128.21 v2(214.2,127.4)
  TOP w0.196: RG89.2 211.54,129.03 209.02,126.5 209.02,114.43 v2(209.39,114.05)
  BOTTOM w0.102: UG4.J2 214.59,127.8 v2(214.2,127.4)
  BOTTOM w0.196: UG1.V34 205.68,106 205.47,106.21 205.47,109.64 208.2,112.37 208.2,112.86 209.39,114.05 v2(209.39,114.05)
FBA_CMD14: length 33.5
  TOP w0.102: 213.44,127.38 213.81,127.02 214.35,127.02 214.58,127.25 214.58,127.78 v2(215,128.2)
  TOP w0.152: RG87.2 212.35,127.38 213.44,127.38
  TOP w0.196: v2(209.45,112.83) 209.55,112.83 209.99,113.28 209.99,126.52 211.54,128.06 RG87.2
  BOTTOM w0.102: UG4.J3 v2(215,128.2)
  BOTTOM w0.196: v2(209.45,112.83) 209.45,112.77 206.07,109.39 206.07,102.93 205.68,102.54 UG1.V33
FBA_CMD15: length 39.3
  IN1 w0.102: 214.34,128.24 214.69,128.59 215.39,128.59 v2(215.8,129)
  IN1 w0.203: 214.34,128.24 211.82,128.24 208.13,124.54 208.13,117.31 207.06,116.25 207.06,113.2 204.54,110.68 204.54,106.16 205.67,105.03 205.67,101.77 205.53,101.63 205.53,100.89 v2(206.08,100.34)
  BOTTOM w0.102: UG4.L3 v2(215.8,129)
  BOTTOM w0.196: UG1.Y32 204.38,101.14 205.03,101.14 205.23,100.94 205.23,100.57 205.46,100.34 v2(206.08,100.34)
FBA_CMD16: length 35.7
  TOP w0.102: 201.54,103.85 202.31,103.08 202.31,100.75 v2(201.91,100.34) ; 189.77,120.24 190.36,120.83 190.36,126.07 190.2,126.23 189.52,126.23 v2(189.15,126.6)
  TOP w0.196: 201.54,103.85 201.54,106.07 195.66,111.95 195.66,112.99 194.92,113.73 193.28,113.73 189.77,117.24 189.77,120.24
  BOTTOM w0.102: UG5.L12 v2(189.15,126.6)
  BOTTOM w0.196: UG1.AA31 202.78,100.34 201.91,100.34 v2(201.91,100.34)
FBA_CMD17: length 36.5
  TOP w0.102: 190.37,120.19 190.37,120.44 190.61,120.68 190.61,126.21 190.18,126.64 v2(189.94,126.64) ; v2(202.76,98.67) 202.37,99.05 202.37,100.16 203.14,100.93 203.14,102.11 202.85,102.39 202.85,103.13 202.11,103.86
  TOP w0.196: 202.11,103.86 202.11,106.35 196.26,112.2 196.26,113.45 195.33,114.38 193.49,114.38 190.37,117.49 190.37,120.19
  BOTTOM w0.102: v2(189.94,126.64) 190.29,127 UG5.K10
  BOTTOM w0.196: v2(202.76,98.67) UG1.AA29
