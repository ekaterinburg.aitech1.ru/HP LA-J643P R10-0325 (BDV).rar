# Allegro board LAJ643PR10-0325.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
INVPWR_B+_R:
  vias: v2(79.33,31.77) v2(79.96,31.77) v2(80.59,31.79) v3(79.68,27.95) v3(80.54,31.2) v3(80.54,29.45)
INVTPWM: length 10.5
  BOTTOM w0.127: JEDP1.17 69.05,29.63 71.07,27.61 71.07,24.87 CV17.1 72.52,23.42 RV5.1 RV4.2 74.08,23.24 v1(74.31,23.01)
IST_TRIG: length 7.9
  BOTTOM w0.127: 167.37,82.8 166.98,82.8 166.91,82.87 166.39,82.87 UC1.E3
  BOTTOM w0.135: TC287.1 172.42,82.64 172.24,82.46 169.39,82.46 169.04,82.8 167.37,82.8
JTAG_RST: length 5.6
  BOTTOM w0.109: 192.24,83.68 192.51,83.68 192.61,83.78 192.63,83.78 192.89,84.04 UG1.AN11
  BOTTOM w0.127: 192.24,83.68 191.84,84.08 191.4,84.08 191.17,83.84 189.89,83.84 v3(189.49,83.44) 189.46,83.41 188.66,83.41 RG43.1
JTAG_TCK_VGA: length 7.1
  TOP w0.127: v2(190.14,81.58) 190.14,81.18 v3(190.28,81.04)
  BOTTOM w0.102: UG1.AM10 193.98,82.98 193.68,82.68 192.24,82.68 192.07,82.52
  BOTTOM w0.127: TG5.1 188.49,81.58 v2(190.14,81.58) 190.35,81.58 190.64,81.87 190.64,82.13 191.03,82.52 192.07,82.52
JTAG_TDI: length 4.4
  TOP w0.127: v2(191.73,82.99) 191.57,82.83 190.96,82.83 190.73,83.06 TG6.1
  BOTTOM w0.102: 192.03,83.19 192.32,83.47 192.92,83.47 193.11,83.66 193.29,83.66 193.67,84.04 UG1.AM11
  BOTTOM w0.127: 192.03,83.19 191.93,83.19 v2(191.73,82.99)
JTAG_TDO: length 2.2
  BOTTOM w0.127: UG1.AP12 192.02,84.84 192.01,84.83 190.3,84.83 TG7.1
JTAG_TMS: length 6.4
  BOTTOM w0.127: TG8.1 186.28,84.2 189.29,84.2 189.39,84.1 190.91,84.1 191.11,84.3 192,84.3 192.26,84.04 UG1.AP11
KBL_ON: length 88.1
  TOP w0.127: UK1.21 145.24,9.42 145.01,9.64 v2(145.01,9.81) ; Q73.2 217.81,12.27 v1(219.66,14.12) 219.66,14.13 219.69,14.15 v2(220.51,14.15)
  IN2 w0.127: v2(220.51,14.15) 219.65,14.15 218.23,12.73 213.43,12.73 212.78,12.08 210.11,12.08 209.69,12.5 201.14,12.5 200.56,11.92 197.74,11.92 197.48,11.65 191.29,11.65 190.46,10.83 189.41,10.83 188.36,9.79 184.88,9.79 182.77,11.89 182.05,11.89 180.66,13.28 174.31,13.28 172.06,15.53 154.12,15.53 152.32,13.73 152.1,13.73 150.52,12.14 150.52,11.93 150.03,11.44 146.23,11.44 145.01,10.22 v2(145.01,9.81)
KBL_ON_GND: length 5
  TOP w0.127: Q73.1 214.05,13.1 v3(213.81,13.35)
  TOP w0.508: Q73.1 216.49,12.34 216.49,11.54 v2(217.25,10.79)
KSI0: length 47
  TOP w0.127: UK1.55 152.13,18.62 152.5,18.25 154.03,18.25 154.22,18.44 154.22,20.06 155.09,20.93 v2(155.09,21.16) ; v2(186.11,11.47) 186.1,11.48 185.55,11.48 C389.2 v3(185.53,10.15)
  BOTTOM w0.127: v2(186.11,11.47) 186.35,11.71 JKB1.12 186.35,13.27 185.75,13.87 183.9,13.87 182.87,14.9 180.73,14.9 180.23,15.4 180.23,16.24 177.72,18.75 175.62,18.75 174.91,19.45 172.47,19.45 172.08,19.07 167.74,19.07 164.93,21.88 163.8,21.88 158.03,21.88 157.56,21.41 157.56,21 157.31,20.75 156.88,20.75 156.01,21.62 155.55,21.62 v2(155.09,21.16)
KSI1: length 29
  TOP w0.127: v3(153.05,19.39) 153.15,19.29 v2(153.15,18.67) 153.14,18.65 152.53,18.65 152.17,19.02 UK1.56
  BOTTOM w0.127: JKB1.1 175.35,13.21 175.2,13.36 174.07,13.36 171.24,16.19 166.55,16.19 164.64,18.1 159.62,18.1 158.28,19.43 155.16,19.43 153.97,18.23 153.59,18.23 v2(153.15,18.67)
KSI2: length 40.2
  TOP w0.127: UK1.57 152.45,19.42 153.74,20.71 v3(154.07,20.71) 154.14,20.65 154.14,20.35 153.79,20 v2(153.79,18.67)
  BOTTOM w0.127: v2(153.79,18.67) 153.79,19.61 154.53,20.34 156.17,20.34 156.56,19.95 158.27,19.95 159.05,20.73 164.6,20.73 167.31,18.02 172.01,18.02 172.35,17.68 172.71,17.68 177.3,17.68 179.18,15.8 179.18,14.97 180.3,13.85 181.84,13.85 182.35,13.35 JKB1.8
KSI3: length 39.1
  TOP w0.127: UK1.58 152.34,19.82 153.68,21.16 v2(154.42,21.16) 154.88,21.63 v3(155.52,21.63)
  BOTTOM w0.127: JKB1.9 183.35,13.31 182.54,14.11 180.4,14.11 179.45,15.07 179.45,15.92 177.42,17.95 172.48,17.95 172.14,18.28 167.41,18.28 164.71,20.99 158.94,20.99 158.17,20.22 156.67,20.22 156.15,20.74 154.84,20.74 v2(154.42,21.16)
KSI4: length 33.7
  TOP w0.127: v2(159.67,19.87) 159.67,20.08 v3(159.34,20.41) 157.94,21.81 155.89,21.81 155.68,22.02 154.15,22.02 152.35,20.22 UK1.59
  BOTTOM w0.127: v2(159.67,19.87) 159.67,19.87 160.08,19.46 160.43,19.46 160.61,19.64 164.57,19.64 166.98,17.23 171.69,17.23 172.02,16.9 172.05,16.9 172.07,16.88 172.13,16.88 172.14,16.87 176.16,16.87 179.35,13.68 JKB1.5
KSI5: length 34.4
  TOP w0.127: v2(160.25,19.87) 160.25,20.18 158.36,22.07 v3(158.26,22.07) 156,22.07 155.79,22.28 154.01,22.28 152.35,20.62 UK1.60
  BOTTOM w0.127: JKB1.6 180.35,13.05 176.26,17.14 172.18,17.14 172.15,17.16 172.13,17.16 171.8,17.5 167.09,17.5 164.68,19.9 160.41,19.9 160.38,19.87 160.26,19.87 v2(160.25,19.87)
KSI6: length 33.5
  TOP w0.127: UK1.61 152.35,21.02 153.88,22.54 155.9,22.54 156.03,22.41 157.23,22.41 157.28,22.46 158.42,22.46 160.86,20.02 v3(160.86,19.33) v2(160.86,18.67)
  BOTTOM w0.127: v2(160.86,18.67) 161.31,19.12 164.36,19.12 166.76,16.71 171.47,16.71 171.81,16.38 171.83,16.38 171.85,16.35 171.91,16.35 171.94,16.33 175.96,16.33 177.35,14.94 JKB1.3
KSI7: length 31.1
  TOP w0.127: v2(161.5,18.67) 161.5,19.91 158.61,22.8 v3(156.74,22.8) 153.67,22.8 152.29,21.42 UK1.62
  BOTTOM w0.127: JKB1.2 176.35,13.2 175.93,13.62 174.18,13.62 171.35,16.45 166.65,16.45 164.44,18.66 161.52,18.66 v2(161.5,18.67)
KSO0: length 39.3
  TOP w0.127: v2(159.08,19.88) v3(159.08,16.99) 159.08,16.48 155.94,13.33 153.38,13.33 152.27,12.22 UK1.39
  BOTTOM w0.127: v2(159.08,19.88) 159.08,20.01 159.54,20.47 164.49,20.47 167.2,17.76 171.91,17.76 172.26,17.41 176.37,17.41 180.19,13.59 181,13.59 181.35,13.24 JKB1.7
KSO1: length 46.5
  TOP w0.127: UK1.40 152.25,12.62 153.22,13.59 155.61,13.59 v3(155.85,13.83) 158.66,16.65 158.66,17.41 158.82,17.57 158.82,19.25 158.66,19.41 158.66,20.5 v2(158,21.16)
  BOTTOM w0.127: v2(158,21.16) 158.35,21.51 164.92,21.51 167.63,18.8 172.19,18.8 172.53,19.14 174.86,19.14 175.51,18.48 177.62,18.48 179.97,16.13 179.97,15.29 180.62,14.64 182.76,14.64 183.75,13.65 185.02,13.65 185.35,13.32 JKB1.11
KSO2: length 49.2
  TOP w0.127: UK1.41 152.19,13.02 153.03,13.86 155.3,13.86 158.4,16.96 v3(158.4,18.68) 158.4,19.82 v2(157.05,21.17)
  BOTTOM w0.127: v2(157.05,21.17) 157.05,21.26 157.92,22.14 161.96,22.14 165.04,22.14 167.85,19.33 171.98,19.33 172.42,19.77 174.97,19.77 175.72,19.01 178.86,19.01 182.72,15.16 182.91,15.16 183.99,14.08 186.66,14.08 187.35,13.39 JKB1.13
KSO3: length 55.9
  TOP w0.127: UK1.42 152.22,13.42 152.92,14.12 154.94,14.12 156.81,15.98 v3(156.81,16.16) 157.84,17.2 v2(157.84,18.67)
  BOTTOM w0.127: JKB1.18 192.35,11.75 192.12,11.52 191.4,11.52 190.72,10.84 189.29,10.84 188.54,10.09 176.11,10.09 175.89,10.09 175.67,10.09 170.62,15.14 166.11,15.14 164.49,16.76 156.06,16.76 155.05,17.77 155.05,18.91 155.31,19.17 157.35,19.17 v2(157.84,18.67)
KSO4: length 58.7
  TOP w0.127: v3(153.55,14.51) 152.94,14.51 152.65,14.22 152.65,14.22 152.25,13.82 UK1.43 150.38,13.82 149.43,14.76 149.43,16.77 147.73,18.47 v2(147.73,18.87)
  BOTTOM w0.127: JKB1.14 188.35,12.76 186.81,14.3 184.41,14.3 183.62,15.09 183.62,15.61 179.95,19.28 175.83,19.28 172.17,22.94 172.17,24.15 171.86,24.46 171.13,24.46 167.16,24.46 165.1,22.4 163.58,22.4 151.26,22.4 v2(147.73,18.87)
KSO5: length 45.8
  TOP w0.127: UK1.44 152.09,14.22 152.78,14.9 155.33,14.9 156.31,15.88 156.31,16.22 157.42,17.33 157.42,19.1 v3(156.63,19.89) 155.82,20.7 v2(155.82,21.16)
  BOTTOM w0.127: JKB1.10 184.35,13.18 184.14,13.39 183.64,13.39 182.65,14.38 180.51,14.38 179.71,15.18 179.71,16.03 177.52,18.21 172.58,18.21 172.25,18.54 167.52,18.54 164.81,21.25 158.83,21.25 158.06,20.48 156.78,20.48 156.1,21.16 v2(155.82,21.16)
KSO6: length 51.4
  TOP w0.127: v2(155.53,18.67) 155.97,19.11 156.99,19.11 157.16,18.94 157.16,17.5 155.88,16.22 155.88,16.01 v3(155.29,15.42) 155.04,15.17 152.67,15.17 152.12,14.62 UK1.45
  BOTTOM w0.127: JKB1.17 191.35,11.84 190.61,11.1 189.18,11.1 188.43,10.35 176,10.35 175.78,10.35 170.73,15.4 166.22,15.4 164.6,17.02 156.57,17.02 155.53,18.07 v2(155.53,18.67)
KSO7: length 44.2
  TOP w0.127: v2(156.74,18.67) 156.74,18.01 v3(156.73,18) 154.16,15.43 152.56,15.43 152.15,15.02 UK1.46
  BOTTOM w0.127: v2(156.74,18.67) 157.74,17.68 164.69,17.68 166.44,15.93 170.94,15.93 175.96,10.91 188.25,10.91 189.35,12.01 JKB1.15
KSO8: length 45.8
  TOP w0.127: UK1.47 152.18,15.42 152.45,15.69 154.01,15.69 155.28,16.95 v3(155.28,17.1) 155.28,17.8 v2(156.15,18.67)
  BOTTOM w0.127: JKB1.16 190.35,11.65 190.06,11.36 189.07,11.36 188.36,10.65 182.81,10.65 182.77,10.61 175.89,10.61 170.84,15.66 166.33,15.66 164.71,17.29 157.11,17.29 156.15,18.25 v2(156.15,18.67)
KSO9: length 34.6
  TOP w0.127: v2(154.72,19.89) 154.84,19.76 v3(154.84,19.15) 154.49,18.79 154.49,17.24 153.19,15.95 152.35,15.95 152.21,15.82 UK1.48
  BOTTOM w0.127: v2(154.72,19.89) 156.26,19.89 156.45,19.69 158.39,19.69 158.89,19.19 160.54,19.19 160.72,19.38 164.46,19.38 166.87,16.97 171.58,16.97 171.92,16.64 171.94,16.64 171.96,16.61 172.02,16.61 172.03,16.61 172.25,16.61 172.25,16.61 176.05,16.61 178.35,14.31 JKB1.4
KSO10: length 62.4
  TOP w0.127: v3(172.09,8.38) 172.11,8.38 v2(173.22,7.27) ; v2(148.61,18.19) 148.61,17.96 149.91,16.66 149.91,16.54 150.22,16.22 UK1.49
  BOTTOM w0.127: v2(148.61,18.19) 148.61,17.75 150.91,15.45 163.95,15.45 165.57,13.83 168.04,13.83 171.6,10.27 171.6,7.96 172.28,7.27 v2(173.22,7.27) 173.64,7.69 174.5,7.69 175.59,8.78 176.43,8.78 176.65,8.78 181.13,8.78 181.13,8.78 189.08,8.78 189.83,9.53 192.81,9.53 193.14,9.86 194.9,9.86 197.35,12.3 JKB1.23
KSO11: length 60.1
  TOP w0.127: v2(171.26,12.49) v3(170.32,13.44) ; v2(149.19,18.1) 150.17,17.12 150.17,16.81 150.36,16.62 UK1.50
  BOTTOM w0.127: JKB1.22 196.35,11.75 194.72,10.12 193.03,10.12 192.7,9.79 189.72,9.79 188.97,9.04 181.24,9.04 181.23,9.04 176.54,9.04 176.54,9.04 176.32,9.04 175.48,9.04 174.39,7.95 171.97,7.95 171.86,8.07 171.86,10.38 171.26,10.98 v2(171.26,12.49) 169.66,14.09 165.68,14.09 164.06,15.72 151.86,15.72 149.48,18.1 v2(149.19,18.1)
KSO12: length 47.3
  TOP w0.127: v3(152.99,16.35) 152.99,16.5 v2(152.53,16.96) 152.47,17.02 UK1.51
  BOTTOM w0.127: JKB1.19 193.35,11.95 191.98,10.58 189.4,10.58 188.65,9.82 181.56,9.82 181.56,9.83 176.21,9.83 176,9.83 176,9.83 175.56,9.83 175.56,9.83 170.51,14.88 166,14.88 164.38,16.5 152.99,16.5 v2(152.53,16.96)
KSO13: length 51
  TOP w0.127: UK1.52 152.9,17.42 v2(152.94,17.38) 153.28,17.38 v3(153.76,17.86)
  BOTTOM w0.127: v2(152.94,17.38) 152.91,17.41 152.29,17.41 152.11,17.23 152.11,16.76 152.63,16.24 164.27,16.24 165.9,14.62 170.4,14.62 175.46,9.56 176.11,9.56 176.32,9.56 181.45,9.56 188.76,9.56 189.51,10.31 192.08,10.31 193.34,11.57 194.21,11.57 194.35,11.7 JKB1.20
KSO14: length 57.1
  TOP w0.127: v1(171.89,12.74) 171.96,12.66 v2(171.96,12.19) ; UK1.53 150.44,17.82 149.34,18.91 v2(149.34,19.29)
  BOTTOM w0.127: v2(149.34,19.29) 149.34,18.61 151.97,15.98 164.17,15.98 165.79,14.36 170.24,14.36 171.96,12.63 v2(171.96,12.19) 171.53,11.75 171.53,11.36 171.91,10.98 173.67,10.98 175.35,9.3 176.21,9.3 176.43,9.3 176.43,9.3 181.34,9.3 181.34,9.3 188.87,9.3 189.62,10.05 192.6,10.05 192.92,10.38 194.17,10.38 195.35,11.56 JKB1.21
KSO15: length 64.9
  TOP w0.127: v3(173.67,7.72) 173.78,7.61 v2(173.78,7.11) ; v2(149.93,19.31) 149.93,18.73 150.44,18.22 UK1.54
  BOTTOM w0.127: v2(149.93,19.31) 149.54,19.7 149.17,19.7 148.15,18.68 148.15,17.84 150.8,15.19 163.84,15.19 165.46,13.57 167.93,13.57 171.33,10.17 171.33,7.85 172.33,6.85 173.52,6.85 v2(173.78,7.11) 174.11,7.43 174.53,7.43 174.61,7.43 175.7,8.52 176.54,8.52 176.76,8.52 181.02,8.52 181.02,8.52 189.19,8.52 189.94,9.27 192.92,9.27 193.25,9.59 195.01,9.59 195.52,10.1 196.73,10.1 198.35,11.72 JKB1.24
KSO16: length 72
  TOP w0.127: v2(174.36,7.01) 174.75,7.01 v3(175.02,6.75) ; v2(149.78,13.83) 149.17,14.43 149.17,16.66 145.28,20.55 143.77,20.55 143.24,21.08 UK1.81
  BOTTOM w0.127: JKB1.25 199.35,12 197.19,9.84 195.62,9.84 195.12,9.33 193.36,9.33 193.03,9.01 190.05,9.01 189.3,8.26 180.91,8.26 180.91,8.26 176.86,8.26 176.65,8.26 175.8,8.26 174.56,7.01 v2(174.36,7.01) 173.93,6.59 172.23,6.59 171.07,7.74 171.07,10.06 167.82,13.31 165.35,13.31 163.75,14.91 150.86,14.91 v2(149.78,13.83)
KSO17: length 75.1
  TOP w0.127: v2(194.31,8.89) v3(194.31,8.06) ; UK1.82 142.84,23.06 143.01,22.89 143.01,20.98 143.67,20.32 145.14,20.32 148.91,16.55 148.91,14.31 149.19,14.03 v2(149.19,13.78)
  BOTTOM w0.127: JKB1.26 200.35,11.6 198.98,10.22 198.28,10.22 197.63,9.58 195.73,9.58 195.04,8.89 v2(194.31,8.89) 193.86,8.44 192.6,8.44 192.29,8.74 190.16,8.74 189.41,7.99 180.8,7.99 180.8,8 176.97,8 176.97,7.99 176.76,7.99 175.91,7.99 174.91,6.99 174.91,6.41 174.66,6.16 171.97,6.16 170.81,7.32 170.81,9.95 167.71,13.05 165.25,13.05 163.64,14.65 151.19,14.65 149.95,13.41 149.43,13.41 149.19,13.64 v2(149.19,13.78)
LAN_ACT#: length 76.9
  TOP w0.127: v2(11.23,57.1) 11.73,57.1 v1(11.89,57.26) 11.98,57.35 11.98,60.18 RL31.2
  IN1 w0.135: v2(11.23,57.1) 11.23,56.86 14.62,53.47 14.62,51.39 15.43,50.58 15.43,48.35 17.89,45.89 26.2,45.89 27.08,45 27.29,45 28.41,43.88 34.25,43.88 35.41,42.72 35.41,36.56 35.2,36.35 35.2,25.25 35.33,25.12 35.33,22.43 35.94,21.82 39.57,21.82 40.08,21.31 42.42,21.31 42.67,21.56 47.38,21.56 47.89,21.05 51.16,21.05 v2(52.68,19.53)
  BOTTOM w0.127: v2(52.68,19.53) 52.87,19.34 UL1.27
LAN_ACT#_R: length 10.1
  TOP w0.508: RL31.1 11.64,60.93 DM16.3 9.23,60.93 8.95,61.21 v1(6.35,61.21) 4.58,61.21 v2(3.94,61.85)
  BOTTOM w0.254: v2(3.94,61.85) 3.05,61.85 LED4.1
LAN_DISABLE_N: length 3.1
  BOTTOM w0.102: UH1.BF41 194.72,17.65 193.88,16.82 193.88,16.65
  BOTTOM w0.127: TH124.1 193.83,15.81 193.83,16.6 193.88,16.65
LAN_LINK#: length 76.9
  TOP w0.127: v1(10.65,56.53) RL30.2 11.1,57.58 v2(11.23,57.71)
  IN1 w0.135: v2(11.23,57.71) 10.8,57.27 10.8,56.91 14.35,53.36 14.35,51.28 15.16,50.47 15.16,48.23 17.78,45.62 26.09,45.62 26.97,44.74 27.18,44.74 28.3,43.61 34.14,43.61 35.14,42.61 35.14,36.67 34.93,36.46 34.93,25.14 35.07,25.01 35.07,22.32 35.83,21.55 39.46,21.55 39.96,21.05 42.54,21.05 42.78,21.29 47.26,21.29 47.77,20.78 51.05,20.78 51.59,20.24 51.59,19.4 v2(52.66,18.34)
  BOTTOM w0.127: UL1.25 52.87,18.54 v2(52.66,18.34)
LAN_LINK#_R: length 9.7
  TOP w0.508: LED5.1 2.99,60.35 v1(4.78,60.35) 6,60.35 7.35,59 DM16.2 10.22,58.44 9.73,57.96 RL30.1
LAN_MDIN0: length 14
  TOP w0.102: v2(52.5,24.75) 52.5,24.66 52.3,24.45 52.16,24.45 51.41,25.2 51.41,25.41 51.49,25.49 51.71,25.49 51.84,25.62 51.84,25.74 v2(51.72,25.86)
  BOTTOM w0.102: v2(51.72,25.86) DM12.3 52.56,25.43 52.43,25.3 51.64,25.3 51.57,25.22 51.57,24.9 51.17,24.5 TSL1.12 ; v2(52.5,24.75) 53.35,24.75 53.98,24.12 53.98,23.54 54.71,22.81 UL1.2
LAN_MDIN1: length 17.8
  TOP w0.102: v2(54.18,25.44) 53.66,25.44 53.19,25.91 53.19,27.51 52.17,28.52 51.59,28.52 51.2,28.14 51.2,27.86 v2(51.11,27.76)
  BOTTOM w0.102: v2(51.11,27.76) DM12.6 50.26,28.32 50.34,28.4 51.08,28.4 51.17,28.48 51.17,28.73 51.1,28.8 49.86,28.8 49.25,28.2 48.34,28.2 48.25,28.11 48.25,27.61 48.14,27.5 TSL1.9 ; v2(54.18,25.44) 54.92,25.44 55.91,24.44 UL1.5
LAN_MDIN2: length 20.2
  TOP w0.102: v2(57.22,23.56) 57.17,23.61 57.17,25.28 51.47,30.97 51.47,31.97 v2(51.72,32.21)
  BOTTOM w0.102: TSL1.6 47.97,30.5 48.21,30.73 51.06,30.73 51.68,31.35 51.68,31.63 51.77,31.73 52.43,31.73 52.56,31.86 DM13.3 v2(51.72,32.21) ; v2(57.22,23.56) 57.05,23.4 57.05,22.7 56.71,22.36 UL1.7
LAN_MDIN3: length 25.1
  TOP w0.102: v2(51.11,34.11) 51.55,33.67 51.55,33.43 52.3,32.68 52.3,30.89 57.96,25.23 57.96,22.78 57.79,22.61 57.79,21.93 58.4,21.32 58.64,21.32 v2(58.81,21.14)
  BOTTOM w0.102: v2(58.81,21.14) 58.71,21.24 58.49,21.24 58.19,20.94 UL1.10 ; v2(51.11,34.11) DM13.6 50.26,34.44 50.36,34.54 51.13,34.54 51.24,34.65 51.24,34.84 51.11,34.97 49.86,34.97 49.09,34.2 48.31,34.2 48.19,34.08 48.19,33.58 48.11,33.5 TSL1.3
LAN_MDIP0: length 14
  TOP w0.102: v2(52.51,24.1) 52.46,24.15 52.03,24.15 51.11,25.07 v2(51.11,25.86)
  BOTTOM w0.102: TSL1.11 48.12,25.5 48.21,25.4 48.21,25.08 48.49,24.81 51.04,24.81 51.26,25.02 51.26,25.21 51.18,25.3 50.36,25.3 50.26,25.4 DM12.4 v2(51.11,25.86) ; UL1.1 54.31,22.45 54.41,22.55 54.41,22.69 53.68,23.42 53.68,23.99 53.22,24.44 52.88,24.44 52.83,24.39 52.83,24.1 52.7,23.97 52.57,23.97 52.51,24.03 v2(52.51,24.1)
LAN_MDIP1: length 17.8
  TOP w0.102: v2(54.18,24.85) 54.03,24.7 53.89,24.7 53.8,24.8 53.8,25.06 53.72,25.13 53.53,25.13 52.88,25.78 52.88,27.39 52.05,28.22 51.72,28.22 51.51,28.01 51.51,27.86 51.6,27.76 v2(51.72,27.76)
  BOTTOM w0.102: v2(54.18,24.85) 54.18,24.75 54.24,24.69 54.39,24.69 54.56,24.85 54.56,25.08 54.61,25.13 54.79,25.13 55.61,24.32 55.61,22.53 55.51,22.43 UL1.4 ; TSL1.8 49.13,28.5 49.73,29.11 51.23,29.11 51.47,28.86 51.47,28.49 51.57,28.4 52.33,28.4 52.56,28.16 DM12.1 v2(51.72,27.76)
LAN_MDIP2: length 20.2
  TOP w0.102: v2(51.11,32.21) 51.17,32.15 51.17,30.84 56.86,25.15 56.86,23.79 v2(56.63,23.56)
  BOTTOM w0.102: v2(56.63,23.56) 56.75,23.45 56.75,22.83 56.31,22.39 UL1.6 ; v2(51.11,32.21) DM13.4 50.26,31.85 50.36,31.75 51.31,31.75 51.37,31.68 51.37,31.48 50.93,31.04 48.34,31.04 48.22,31.15 48.22,31.4 48.12,31.5 TSL1.5
LAN_MDIP3: length 25.1
  TOP w0.102: v2(51.72,34.11) 51.87,34.26 52.05,34.26 52.17,34.14 52.17,33.96 51.86,33.65 51.86,33.55 52.61,32.81 52.61,31.02 v5(57.7,25.93) 58.27,25.36 58.27,22.66 58.09,22.48 58.09,22.06 58.53,21.62 58.71,21.62 v2(58.81,21.73)
  BOTTOM w0.102: v2(58.81,21.73) 58.63,21.55 58.36,21.55 58.16,21.34 UL1.9 ; TSL1.2 48.96,34.5 49.74,35.28 51.24,35.28 51.55,34.97 51.55,34.59 51.59,34.54 52.46,34.54 52.56,34.44 DM13.1 v2(51.72,34.11)
LAN_PWR_EN: length 97
  TOP w0.127: v2(141.05,21.11) 141.24,21.29 UK1.86 ; v2(71.16,22.36) 68.86,22.36 68.36,21.86 68.36,20.85 68.06,20.55 66.95,20.55 v3(66.29,19.89) 61.82,15.42 v2(61.49,15.42)
  BOTTOM w0.127: v2(61.49,15.42) 60.29,15.42 59.91,15.04 UL2.4 ; v2(71.16,22.36) 71.16,21.69 71.61,21.24 72.24,21.24 72.49,21.49 74.14,21.49 74.93,22.29 83.97,22.29 87.28,18.98 97.27,18.98 100.15,21.86 100.15,24.29 100.69,24.83 101.75,24.83 102.36,25.44 104.63,25.44 104.67,25.4 105.45,25.4 106.43,24.42 109.77,24.42 111.03,23.16 113.66,23.16 114.83,21.99 117.57,21.99 118.28,21.99 118.28,21.99 118.54,21.99 118.54,21.99 119.6,21.99 119.6,21.99 121.63,21.99 121.63,21.99 122.35,21.99 124.26,21.99 125.14,21.11 132.38,21.11 132.81,20.68 133.89,20.68 134.15,20.94 135.26,20.94 135.26,20.94 136.13,20.94 138.59,20.94 138.85,20.68 140.62,20.68 v2(141.05,21.11)
LAN_WAKE#: length 8.4
  TOP w0.127: v2(191.95,15) 192.08,14.86 192.08,14.35 191.04,13.31 190.94,13.31 190.56,12.93 190.56,12.57 RH211.2 v1(189.95,11)
  BOTTOM w0.127: v2(191.95,15) 191.95,16.64 192.58,17.27 192.87,17.27 193.1,17.51 UH1.BG44
LANGND: length 48.3
  TOP w0.127: v2(19.74,47.38) v3(20.38,47.38)
  IN2 w0.508: v2(19.74,47.38) 19.52,47.16 16.28,47.16 15.62,47.82 15.62,51.75 10.54,56.83 JRJ45.9
  BOTTOM w0.508: v2(19.74,47.38) 23.33,47.38 24.88,45.82 26.4,45.82 28.43,43.8 34.64,43.8 CL3.1 35.35,43.69 36.32,42.71 36.55,42.71 36.91,42.35 36.91,42.12 37.05,41.98 37.05,41.23 DL1.2 37.55,41.12 38.69,42.26 39.86,42.26 40.89,43.3 CL2.1
  vias: v2(8.13,79.75) v2(12.04,78.84) v2(11.99,63.59) v2(12.32,76.32) v2(12.32,67.23) v2(12.33,65.38)
LDO1_CAP: length 3.6
  TOP w0.203: UA1.39 291.31,22.63 v2(290.97,22.97)
  BOTTOM w0.127: v1(290.43,24.9) CA16.2
  BOTTOM w0.356: v2(290.97,22.97) 290.93,23.01 290.4,23.01 290.4,23.75 CA16.2
LDO2_CAP: length 2.8
  TOP w0.152: 299.13,22.73 299.09,22.73 298.6,22.23 UA1.21
  TOP w0.203: v2(299.68,23.03) 299.61,22.96 299.36,22.96 299.13,22.73
  TOP w0.381: CA17.2 299.9,23.25 v2(299.68,23.03)
LDO3_CAP: length 5.6
  TOP w0.127: v1(303.12,20.05) 301.96,20.05 301.3,20.71 CA18.2
  TOP w0.203: 299.42,21.11 299.16,21.11 298.94,21.34 298.57,21.34 298.48,21.43 UA1.19
  TOP w0.381: 299.42,21.11 300.91,21.11 CA18.2
LDO_3V_VCCIOP:
  vias: v2(183.14,105.08)
LED1/GPO: length 3.4
  TOP w0.127: v2(52.68,18.94) 52.97,18.94 53.44,19.41 RL56.1 53.95,19.71 54.26,19.4 v1(54.49,19.4)
  BOTTOM w0.127: UL1.26 v2(52.68,18.94)
LG_DDR: length 5.7
  TOP w0.127: v2(89.24,33.17) v1(89.24,32.34)
  IN1 w0.508: v2(89.24,33.17) 89.24,28.85 v2(89.62,28.47)
LG_GT: length 5.9
  TOP w0.254: 116.79,95.78 117.17,95.4 PUG1.5
  TOP w0.508: v2(113.75,97.09) 113.75,96.78 114.76,95.78 v1(115.28,95.78) 116.79,95.78
  BOTTOM w0.508: PQG1.8 113.87,96.97 v2(113.75,97.09)
LG_PH1: length 12.2
  IN3 w0.508: v2(150.2,125.25) 150.75,125.8 150.75,129.18 151.26,129.69 152.99,129.69 153.34,130.05 153.34,132.46 v2(153.37,132.48)
  BOTTOM w0.127: PQZ1.8 149.65,126.46 149.47,126.29 v1(148.89,126.29)
  BOTTOM w0.508: PQZ1.8 v2(150.2,125.25)
LG_PH2: length 10.8
  IN3 w0.508: v2(142.58,125.25) 143.13,125.8 143.13,129.31 143.49,129.66 145.24,129.66 145.72,130.15 145.72,132.46 v2(145.75,132.48)
  BOTTOM w0.508: PQZ2.8 v2(142.58,125.25)
LG_PH3: length 11
  IN3 w0.508: v2(138.13,132.48) 138.13,130.71 138.1,130.68 138.1,129.97 137.85,129.72 135.95,129.72 135.51,129.28 135.51,125.93 v2(134.83,125.25)
  BOTTOM w0.508: PQZ3.8 134.96,125.37 v2(134.83,125.25)
LG_PH4: length 11.1
  IN3 w0.508: v2(127.36,125.17) 128.16,125.97 128.16,129.25 128.59,129.68 130.15,129.68 130.76,130.29 v2(130.76,132.48)
  BOTTOM w0.508: PQZ4.8 127.61,126.44 127.61,125.42 v2(127.36,125.17)
LG_VCCSA: length 10
  IN3 w0.508: v2(161.12,130.33) 161.12,129.82 160.86,129.56 159.97,129.56 159.47,129.06 159.47,125.25 v2(160.74,123.98)
  BOTTOM w0.254: v2(161.12,130.33) 160.85,130.59 PUA1.5
  BOTTOM w0.508: PQA1.8 160.31,124.4 v2(160.74,123.98)
LGATE_1.35VSDGPUP: length 16
  IN3 w0.762: 243.15,50.15 243.15,49.83 246.18,46.8 257.24,46.8 257.48,47.04
  vias: v2(242.5,51.18) v2(242.89,51.62) v2(257.96,48.26) v2(257.95,47.67)
LID_SW#: length 228.3
  TOP w0.127: v2(191.93,80.23) 191.61,80.23 v1(191.22,79.84) 190.83,79.46 190.83,77.79 181.96,68.92 180.22,68.92 179.87,68.57 v2(179.32,68.57) ; v2(205.16,128.48) 204.65,128.99 R5287.2 ; v2(138.3,19.12) 138.3,18.7 138.05,18.45 138.05,17.58 137.76,17.29 137.76,17.28 137.28,16.8 137.28,16.09 137.07,15.88 137.07,15.23 136.86,15.02 UK1.115
  IN1 w0.127: v2(205.16,128.48) 204.69,128.95 203.16,128.95 197.92,134.19 195.31,134.19 194.07,135.43 185.87,135.43 184.49,134.05 184.49,128.92 182.27,126.7 182.27,124.22 177.96,119.91 174.3,119.91 171.76,117.37 171.76,115.16 172.78,114.14 172.78,111.75 175.78,108.76 176.98,108.76 178.24,107.5 178.24,104.02 179.82,102.44 180.05,102.44 180.57,101.91 180.57,99.67 178.9,98 178.9,95.21 186.17,87.95 187.82,87.95 190.74,85.02 190.74,81.42 v2(191.93,80.23)
  IN3 w0.127: v2(179.32,68.57) 179.13,68.76 177.65,68.76 176.17,67.29 176.17,50.94 175.9,50.67 175.9,49.93 176.22,49.61 180.18,49.61 183.65,46.14 183.65,42.66 183.32,42.34 183.32,39.71 185.35,37.68 185.35,29.91 181.45,26 172.36,26 171.13,24.77 166.55,24.77 166.29,25.04 164.51,25.04 163.86,24.39 162.42,24.39 162.18,24.63 160.8,24.63 160.35,25.08 151.88,25.08 150.24,23.44 137.71,23.44 136.09,21.81 136.09,19.54 136.62,19 137.45,19 137.72,19.26 138.15,19.26 v2(138.3,19.12)
LID_SW#_OUT: length 263
  TOP w0.127: v2(204.61,135.81) 204.61,133.86 203.53,132.77 203.53,130.25 204.21,129.57 204.21,128.79 204.96,128.04 205.31,128.04 205.58,128.31 205.58,129.17 R5287.1 205.57,129.68 205.59,129.7 R5242.2 205.59,130.61 205.57,130.63 C394.1 C393.1 206.07,131.72 206.78,131.01 D3.3 207.4,131.39 207.4,132.18 v1(208.15,132.93) 208.59,133.37 U7.3 ; v2(101.59,26.26) 101.16,25.83 101.16,23.01 102.76,21.42 106.79,21.42 107.11,21.1 108.76,21.1 108.88,21.22 U4019.1
  IN1 w0.127: v2(174.85,134.39) 175.26,134.39 175.82,133.83 175.82,132.67 177.22,131.28 179.94,131.28 181.72,133.07 181.72,134.46 182.34,135.08 182.34,136.13 182.8,136.59 196.76,136.59 199.72,133.63 203.19,133.63 204.61,135.06 v2(204.61,135.81)
  IN2 w0.127: v2(119.77,27.8) 119.77,28.09 118.67,29.19 114.53,29.19 113.85,29.88 106.61,29.88 103.65,26.92 102.25,26.92 v2(101.59,26.26) ; v2(174.85,134.39) 172.8,134.39 171.48,133.07 171.48,121.17 170.64,120.33 170.64,114.73 167.56,111.64 167.56,108.4 168.23,107.73 169.09,107.73 170.88,105.94 170.88,101.9 171.13,101.65 171.13,93.25 170.25,92.36 170.25,84.38 172.04,82.59 172.04,73.65 174.27,71.41 174.27,57.3 174.77,56.8 v2(174.83,56.8)
  IN3 w0.127: v2(174.83,56.8) 174.84,56.8 174.84,50.03 173.63,48.82 173.63,44.36 174.03,43.95 174.03,43.46 175.65,41.85 175.65,37.2 172.61,34.16 171.29,34.16 169.75,35.7 169.75,36.03 168.73,37.05 155.1,37.05 152.61,34.56 152.61,31.02 152.41,30.82 149.88,30.82 149.27,30.21 148.8,30.21 148.42,29.83 132.44,29.83 130.89,28.28 130.89,27.46 130.45,27.02 121.26,27.02 121.02,27.25 120.14,27.25 119.77,27.62 v2(119.77,27.8)
LPC_AD0: length 66.6
  TOP w0.127: v2(147.29,16.67) 147.29,16.16 145.98,14.86 144.22,14.86 143.65,14.29 143.65,13.04 140.84,10.22 UK1.10 140.84,6.64 v1(140.8,6.6)
  IN3 w0.127: v2(147.29,16.67) 147.84,17.23 149.89,17.23 152.97,20.31 158.48,20.31 158.65,20.48 160.46,20.48 160.7,20.24 164.59,20.24 165.01,19.82 172.24,19.82 172.38,19.96 176.68,19.96 176.82,19.82 182.01,19.82 183.94,21.75 187.44,21.75 188.26,20.93 191.16,20.93 191.71,21.49 192.14,21.49 192.71,22.06 193.3,22.06 194.31,21.05 195.14,21.05 v2(195.46,20.74)
  BOTTOM w0.127: UH1.BB39 195.63,20.56 v2(195.46,20.74)
LPC_AD1: length 66.5
  TOP w0.127: UK1.8 140.04,9.95 143.22,13.14 143.22,14.47 144.07,15.31 145.72,15.31 146.67,16.26 v2(146.67,16.67)
  IN3 w0.127: v2(195.8,22.49) 195.79,22.49 195.17,23.11 195.01,23.11 194.2,22.29 192.52,22.29 192.18,21.96 187.85,21.96 187.62,22.18 183.76,22.18 181.83,20.25 177,20.25 176.86,20.39 172.2,20.39 172.06,20.25 165.19,20.25 164.77,20.67 160.88,20.67 160.64,20.91 158.47,20.91 158.3,20.74 152.79,20.74 149.71,17.66 147.66,17.66 v2(146.67,16.67)
  BOTTOM w0.127: UH1.AW37 196.49,22.19 196.19,22.49 v2(195.8,22.49)
LPC_AD2: length 68.2
  TOP w0.127: v2(146.07,16.68) 146.07,16.27 145.57,15.77 143.64,15.77 142.79,14.92 142.79,13.24 139.64,10.09 UK1.7
  IN3 w0.127: v2(146.07,16.68) 147.48,18.09 147.91,18.09 148.56,18.74 150.19,18.74 153.24,21.8 158.99,21.8 159.44,21.35 160.82,21.35 161.06,21.11 164.95,21.11 165.37,20.68 168.51,20.68 169.02,21.2 176.66,21.2 177.18,20.68 181.65,20.68 183.58,22.61 187.8,22.61 188.03,22.39 190.93,22.39 192.49,23.94 192.82,23.94 193.1,23.66 194.68,23.66 194.82,23.52 195.5,23.52 v2(195.97,23.05)
  BOTTOM w0.127: v2(195.97,23.05) 196.07,23.05 196.75,22.37 UH1.AV37
LPC_AD3: length 73.3
  TOP w0.127: v2(146.27,18.08) 144.83,16.63 143.23,16.63 141.93,15.33 141.93,13.47 138.84,10.38 UK1.5
  IN3 w0.127: v2(195.69,21.35) 196.25,21.35 196.54,21.65 196.54,22.31 197,22.77 197,23.4 196.8,23.6 195.96,23.6 195.51,24.04 195.51,24.22 195.34,24.39 194.12,24.39 193.7,24.82 192.68,24.82 190.68,22.82 188.21,22.82 187.52,23.51 183.86,23.51 181.47,21.12 177.36,21.12 176.84,21.63 169.2,21.63 168.98,21.86 166.62,21.86 166.29,21.54 161.24,21.54 161,21.78 159.62,21.78 159.17,22.23 153.06,22.23 150.58,19.75 147.96,19.75 146.3,18.08 v2(146.27,18.08)
  BOTTOM w0.127: v2(195.69,21.35) 196.02,21.02 UH1.BA38
LPC_FRAME#: length 71.2
  TOP w0.127: UK1.4 138.44,10.59 141.5,13.65 141.5,15.51 143.06,17.07 144.65,17.07 145.65,18.07 v2(145.65,18.07)
  IN2 w0.127: v2(181.25,21.55) 181.28,21.52 182.54,21.52 182.92,21.9 186.16,21.9 186.9,21.16 186.9,20.59 188.93,18.56 192.17,18.56 192.35,18.74 192.95,18.74 194.63,17.06 v2(195.79,17.06)
  IN3 w0.127: v2(145.65,18.07) 145.65,18.22 146.27,18.85 146.45,18.85 147.78,20.18 150.4,20.18 152.88,22.66 159.34,22.66 159.79,22.21 161.18,22.21 161.42,21.97 166.11,21.97 166.44,22.29 169.16,22.29 169.38,22.07 177.02,22.07 177.53,21.55 v2(181.25,21.55)
  BOTTOM w0.127: UH1.BE38 195.86,18.45 195.86,17.13 v2(195.79,17.06)
LX_1.8V: length 1
  BOTTOM w0.127: 262.21,20.5 262.12,20.59 262.12,21.44 v1(262.1,21.46)
LX_1.35VSDGPUP:
  vias: v1(262.16,55.53) v2(241.56,50.68) v2(241.56,50.12) v2(252.43,54.51) v2(253.32,54.51)
LX_1V05:
  vias: v1(234.43,28.1) v2(233.67,26.77) v2(234.28,26.78) v2(239.4,28.5) v2(239.98,28.5)
LX_2.5V: length 2.4
  TOP w0.127: PU2501.3 108.37,17.86 107.92,18.31 v1(107.92,19.02)
LX_3V: length 1.5
  BOTTOM w0.127: 251.27,23.84 252.35,23.84 252.54,23.65 v1(252.72,23.65)
LX_3V_LCDVDD: length 2.2
  TOP w0.127: v1(72.2,36.69) 71.42,37.47 LV3.1
LX_5V:
  vias: v1(74.15,5.74) v2(73.7,6.83) v2(73.82,7.47)
LX_7237: length 0.7
  TOP w0.127: v2(85.93,39.9) v1(86.61,39.9)
  vias: v2(85.93,39.27) v2(85.93,38.63)
LX_+1.0VSDGP: length 2.2
  BOTTOM w0.127: PLF1.1 176.3,96.57 v1(175.95,96.57)
LX_DDR: length 1.5
  BOTTOM w0.127: v1(88.94,28.93) 88.94,29.19 PCM4.2
  vias: v2(90.51,29.94) v2(90.53,29.33) v2(90.63,32.31) v2(91.14,36.98) v2(91.14,36.35) v2(91.14,35.71) v2(91.17,32.54) v2(91.78,36.98) v2(91.78,36.35) v2(91.78,35.71) v2(91.78,32.54) v2(91.78,31.9) v2(92.28,36.73) v2(92.28,36.09) v2(92.41,32.41) v2(92.41,31.77)
LX_GT: length 11
  TOP w0.127: PCG5.2 115.13,94.21 114.57,94.77 v1(114.42,94.77)
  TOP w0.254: v2(116.69,94.4) PUG1.7
  TOP w0.457: v2(116.69,94.4) 115.93,94.4 PCG5.2
  IN3 w0.508: v2(112.6,90.12) 112.6,90.45 113.11,90.96 114.03,90.96 114.71,91.64 114.71,93.19 115.92,94.4 v2(116.69,94.4)
  BOTTOM w0.508: v2(112.6,90.12) PQG1.2
LX_GT_R: length 1.4
  TOP w0.508: PRG2.1 111.97,97.05 v2(111.33,97.05)
  vias: v1(108.34,96.2)
LX_PH1:
  vias: v2(151.55,132.13)
LX_PH1_R:
  vias: v1(153.09,125.64) v2(152.93,125.12)
LX_PH2:
  vias: v2(143.93,132.13)
LX_PH2_R: length 1.5
  BOTTOM w0.127: PQZ2.5 147.45,125.92 v1(147.74,125.63)
  vias: v2(145.69,125.05)
LX_PH3_R:
  vias: v2(139.22,125.07)
LX_PH4: length 1.2
  BOTTOM w0.127: v1(127.02,133.31) 127.54,132.79 PCZ66.2
LX_PH4_R: length 4.5
  TOP w0.508: PRZ89.1 126.26,125.05 126.83,124.48 128.35,124.48 v2(128.86,124.99)
  vias: v1(125.57,124.93)
LX_VCCIOP: length 2.6
  BOTTOM w0.254: 185.23,103.87 185.45,103.65 185.45,101.9 185.51,101.84 PUH1.6
  vias: v1(185.15,110.28) v2(184.59,107.33) v2(185,106.89)
LX_VCCSA: length 10.7
  TOP w0.127: PRA3.1 v1(157.97,120.08)
  TOP w0.508: v2(158.89,123.09) 157.97,122.16 PRA3.1
  IN1 w0.508: v2(158.89,123.09) 159.35,123.54 159.35,129.23 158.89,129.69 v2(158.58,129.69)
MAINPWON: length 199.1
  TOP w0.127: v2(137.68,18.64) 136.9,19.42 UK1.104 ; v2(275.75,25.06) 275.97,24.85 v3(275.97,24.35)
  IN1 w0.127: v2(275.75,25.06) 275.66,25.16 275.21,25.16 274.79,25.57 273.83,25.57 272.64,26.76 265.57,26.76 264.68,27.65 257.19,27.65 256.07,28.77 v2(256.07,29.28)
  IN2 w0.127: v2(275.75,25.06) 275.91,24.91 275.91,21.73 277.07,20.57 277.07,17.13 275.61,15.67 265.38,15.67 264.39,14.68 257.57,14.68 256.57,15.68 238.03,15.68 236.56,14.21 232.11,14.21 231.06,15.26 228.41,15.26 224.55,11.4 224.55,10 220.86,6.31 203.14,6.31 202.27,7.17 199.78,7.17 198.99,6.38 178.61,6.38 177.27,7.72 171.58,7.72 167.73,11.57 156.39,11.57 154.43,9.6 154.43,6.76 154.21,6.54 v2(154.21,5.18)
  BOTTOM w0.127: v2(256.07,29.28) 256.07,30.05 255.58,30.55 PR311.1 ; v2(137.68,18.64) 137.95,18.64 138.32,18.27 138.32,17.52 138.83,17.01 138.83,10.77 143.36,6.24 153.38,6.24 154.21,5.41 v2(154.21,5.18)
MCT1: length 4.3
  TOP w0.127: v2(36.5,35.61) 36.53,35.58 RL58.1 37.85,34.78 v1(37.55,34.48)
  BOTTOM w0.127: v2(36.5,35.61) 36.61,35.5 TSL1.24
MCT2: length 3.4
  TOP w0.127: v2(36.92,32.5) 36.95,32.54 RL59.1 v1(37.85,31.4)
  BOTTOM w0.127: TSL1.21 v2(36.92,32.5)
MCT3: length 3.1
  TOP w0.127: v2(36.92,29.5) 36.93,29.49 RL60.1 v1(37.85,28.56)
  BOTTOM w0.127: TSL1.18 v2(36.92,29.5)
MCT4: length 3.6
  TOP w0.127: v1(38.17,25.31) 37.72,25.75 RL61.1 36.99,26.57 v2(36.92,26.5)
  BOTTOM w0.127: TSL1.15 v2(36.92,26.5)
ME_FLASH_EN: length 92.7
  TOP w0.127: v2(148.61,13.82) 148.61,16.48 146.25,18.84 141.49,18.84 140.65,19.68 138.4,19.68 137.39,20.69 137.39,20.72 136.7,21.42 UK1.99 ; RH118.1 212.63,11.63 QH2.2 208.13,11.63 v2(208.01,11.5)
  BOTTOM w0.127: v2(148.61,13.82) 148.61,13.63 149.1,13.15 150.19,13.15 v1(150.82,13.78) 151.43,14.39 163.53,14.39 165.14,12.79 167.6,12.79 170.55,9.84 170.55,7.21 171.86,5.9 174.77,5.9 175.17,6.3 175.17,6.88 176.02,7.73 176.86,7.73 176.86,7.73 177.08,7.73 180.69,7.73 180.69,7.73 181.25,7.73 181.47,7.51 200.04,7.51 200.58,8.05 202.29,8.05 203.13,7.21 205.3,7.21 207.35,9.26 207.35,10.84 v2(208.01,11.5)
MUTE_LED: length 99.1
  TOP w0.127: QA3.1 288.37,12.22 v1(284.38,8.23) 282.92,6.77 279.5,6.77 278.54,5.81 277.82,5.81 v2(277.37,5.36) ; R5238.1 C391.1 201,7.02 v2(200.62,6.65)
  IN1 w0.127: v2(277.37,5.36) 276.96,5.77 276.55,5.77 275.95,5.17 260.46,5.17 259.86,5.77 249.31,5.77 248.91,6.17 244.17,6.17 243.25,7.09 240.42,7.09 239.87,6.53 234.88,6.53 232.5,8.91 232.5,9.6 231.07,11.03 228.2,11.03 225.9,8.73 225.9,8.39 224.84,7.32 222.32,7.32 220.8,5.8 201.47,5.8 v2(200.62,6.65)
MUTE_LED_IN: length 7.3
  TOP w0.127: v1(290.08,16.66) 290.27,16.66 290.28,16.65
  TOP w0.135: 290.28,16.65 290.61,16.65 290.86,16.9 290.86,17.28 291.32,17.74 291.32,19.17 291.58,19.43 UA1.47 ; QA3.2 289.13,14.23 RA37.1 289.51,15.26 289.93,15.68 289.93,16.52 v1(290.08,16.66)
MUX_AMSEL: length 59.2
  TOP w0.127: v2(43.54,39.38) 43.32,39.16 43.32,38.8 RU57.2 43.72,38.9 43.72,39 43.89,39.17 44.65,39.17 44.74,39.26 UU4.16 ; v2(59.15,46.46) 58.64,45.96 58.64,43.17 56.05,40.57 56.05,38.91 v2(55.37,38.22) ; v2(34.88,58.34) 34.79,58.43 34.35,58.43 v1(34.24,58.33) 34.24,57.88 33.57,57.2 33.57,56.45 RT800.2
  IN2 w0.127: v2(55.37,38.22) 55.6,38.46 55.6,39.09 55.47,39.22 55.03,39.22 54.86,39.05 52.19,39.05 51.8,39.44 50.89,39.44 50.41,38.96 46.77,38.96 46.37,38.57 44.35,38.57 v2(43.54,39.38) ; v2(59.15,46.46) 58.75,46.07 55.05,46.07 54.52,46.6 52.45,46.6 52.45,46.6 52.08,46.6 51.02,47.66 50.92,47.76 50.04,48.08 49.77,48.18 49.03,48.45 48.15,48.74 47.99,48.97 47.99,49.19 47.6,49.57 47.53,49.64 47.53,49.64 47.3,49.8 47.3,49.8 47.14,49.87 46.62,50.12 46.62,50.12 45.5,50.66 45.5,50.66 44.47,51.16 42.85,52.11 42.5,52.33 41.32,53.08 40.78,53.45 37.63,55.61 37.62,55.61 37.29,55.85 36.62,55.85 34.88,57.59 v2(34.88,58.34)
MUX_AMSEL_R: length 2.6
  TOP w0.127: UT11.22 32.55,54.37 33.36,55.17 RT800.1 RT809.1
MUX_CAD_SNK: length 2.8
  TOP w0.127: UT11.29 28.93,53.18 28.55,53.55 RT860.1 27.68,53.66 27.28,54.07 RT859.1
MUX_DP_EQ0: length 10.9
  TOP w0.127: UT11.14 33.61,50.78 34.47,50.78 v2(34.49,50.76) ; v2(29.21,47.18) 29.21,46.96 v1(28.92,46.67)
  IN1 w0.127: v2(29.21,47.18) 29.76,47.72 31.45,47.72 v2(34.49,50.76)
  BOTTOM w0.127: RT813.2 28.91,46.64 28.81,46.75 28.34,46.75 28.08,47 RT817.1
  BOTTOM w0.135: RT817.1 RT818.1 ; RT813.2 29.37,46.75 29.37,47.03 v2(29.21,47.18)
MUX_DP_EQ1: length 5.2
  TOP w0.127: v1(27.56,46.82) 27.56,45.96 RT814.2 RT840.1 RT838.1 28.85,46.06 29.05,46.26 29.52,46.26 30.55,47.3 UT11.2
MUX_EN: length 72.3
  TOP w0.127: v2(45.09,36.56) 45.09,37.82 RU58.2 44.51,38.91 44.76,38.91 45.14,39.29 UU4.17 ; RT801.2 33.08,57.91 33.12,57.87 v2(33.64,57.87)
  IN1 w0.127: v2(33.64,57.87) 33.86,58.08 33.86,58.59 33.32,59.13 33.04,59.13 32.23,59.95 30.54,59.95 30.09,59.49 29.71,59.49 29.7,59.49 29.2,59.49 28.21,58.49 24.38,58.49 20.47,54.58 20.47,49.07 21.02,48.52 22.93,48.52 24.46,50.05 26.39,50.05 27.02,50.68 27.02,51.9 27.8,52.67 34.85,52.67 35.26,52.26 35.26,49.23 34.94,48.92 33.74,48.92 33.23,48.41 33.23,47.19 33.48,46.94 34.84,46.94 38.43,43.35 38.43,37.8 39.71,36.53 45.05,36.53 v2(45.09,36.56)
  BOTTOM w0.127: v2(33.64,57.87) v1(34.23,57.87)
MUX_EN_R: length 5
  TOP w0.127: UT11.23 32.15,54.73 32.47,55.04 RT810.1 32.74,55.65 32.93,55.83 32.93,56.49 33.3,56.86 v1(33.3,57.43) 33.22,57.52 32.66,57.52 RT801.1
MUX_HPD: length 13.9
  TOP w0.127: v2(28.44,51.94) 28.47,51.98 UT11.32
  BOTTOM w0.127: RT839.2 27.36,51.31 27.07,51.01 27.07,50.8 RT1115.1 26.62,50.86 26.62,51.01 26.05,51.59 25.42,51.59 24.4,50.57 23.13,50.57 22.5,51.2 19.3,51.2 DT2.2 ; RT839.2 28.09,51.59 28.44,51.94 v2(28.44,51.94) ; RT839.2 RT803.2
MUX_I2C_CLK: length 4.4
  TOP w0.127: UU4.27 49.14,39.59 49.48,39.25 51.45,39.25 51.76,38.95 51.76,37.83 T163.1
MUX_I2C_DATA: length 5.7
  TOP w0.127: T164.1 52.49,38.62 51.6,39.52 49.69,39.52 49.54,39.66 UU4.28
MUX_I2C_EN: length 13
  TOP w0.127: v2(34.47,51.99) 34.46,51.98 UT11.17
  IN1 w0.127: v2(28.63,47.17) 28.63,47.29 29.32,47.99 31.34,47.99 34,50.65 34,51.52 v2(34.47,51.99)
  BOTTOM w0.127: v2(34.47,51.99) v1(34.47,52.6)
  BOTTOM w0.135: v2(28.63,47.17) 28.63,47.33 28.91,47.61 29.13,47.61 29.27,47.74 RT856.2 29.1,47.95 28.5,47.95 28.22,48.23 RT857.1 28.08,48.49 RT858.1
MUX_POL: length 50.7
  TOP w0.127: v2(35.37,58.04) 35.02,57.68 v1(35.02,57.14) 35.02,56.47 RT799.2 ; v2(47.1,38.51) 47.02,38.6 RU61.2 45.54,38.79 UU4.18 ; v2(55.18,38.78) 55.79,39.38 55.79,40.68 58.3,43.2 58.3,46.36 v2(58.59,46.66)
  IN2 w0.127: v2(35.37,58.04) 35.24,57.91 35.24,57.6 36.72,56.13 37.36,56.13 39.3,54.79 40.95,53.66 40.95,53.66 41.46,53.31 42.64,52.55 42.99,52.34 43.15,52.24 44.54,51.43 44.6,51.4 46.38,50.54 47.25,50.12 47.43,50.04 47.7,49.85 48.26,49.29 48.26,49.06 48.37,48.95 49.12,48.7 51.07,47.99 52.19,46.87 54.65,46.87 55.19,46.34 58.27,46.34 v2(58.59,46.66) ; v2(55.18,38.78) 52,38.78 51.62,39.16 51.03,39.16 49.97,38.09 47.52,38.09 v2(47.1,38.51)
MUX_POL_R: length 3.3
  TOP w0.127: UT11.21 32.95,54.28 33.59,54.91 34.17,54.91 34.63,55.37 RT808.1 RT799.1
MUX_SS_EQ0: length 20
  TOP w0.127: UT11.11 34.37,49.58 v2(34.41,49.54)
  IN1 w0.127: v2(34.41,49.54) 34.68,49.54 34.99,49.86 34.99,52.15 34.74,52.41 27.91,52.41 27.28,51.79 27.28,50.57 v2(25.86,49.15)
  BOTTOM w0.127: v1(25.58,51.2) 25.58,49.43 v2(25.86,49.15)
  BOTTOM w0.135: RT846.1 RT845.1 26.87,47.94 26.57,48.23 26.57,48.44 26.56,48.46 RT841.2 26.19,48.82 v2(25.86,49.15)
MUX_SS_EQ1: length 3.6
  TOP w0.127: RT847.2 RT849.1 RT848.1 30.69,46.11 30.41,46.39 v1(30.41,46.7) 30.95,47.25 UT11.3
MUX_USB3_EQ0: length 3.1
  TOP w0.127: UT11.38 v2(28.71,49.58) v1(28.2,49.58)
  BOTTOM w0.127: RT850.2 28.69,49.99
  BOTTOM w0.135: 28.69,49.99 28.71,49.98 v2(28.71,49.58) 28.76,49.63 RT852.1 RT851.1
MUX_USB3_EQ1: length 3.5
  TOP w0.127: UT11.35 28.76,50.78 v2(28.71,50.73)
  BOTTOM w0.127: RT853.2 27.79,50.61 28.01,50.82 28.61,50.82 v2(28.71,50.73)
  BOTTOM w0.135: RT854.1 RT855.1 28.88,50.9 v2(28.71,50.73)
NMI_DBG#: length 5.4
  TOP w0.127: UK1.106 134.42,18.62 133.75,19.29 133.75,19.33 133.34,19.74 RK21.2 133.3,20.32 v1(132.95,20.67) 132.66,20.97 DK2.1
NMI_DBG#_CPU: length 75.4
  TOP w0.127: v2(194.07,25.89) 193.46,26.5 190.31,26.5 188.55,28.26 188.22,28.26 v1(188.08,28.4) 186.63,29.85 185.9,29.85 RH195.2 185.88,30.37 186.66,30.37 v2(187.23,29.8) ; v2(132.92,21.53) 131.57,22.88 DK2.2
  IN2 w0.127: v2(132.92,21.53) 132.93,21.53 136.03,21.53 136.22,21.72 138,21.72 138.6,22.32 138.6,22.69 138.86,22.95 141.81,22.95 142.1,22.66 146.04,22.66 146.71,21.98 150.77,21.98 152.31,23.52 160.88,23.52 161.5,22.9 175.15,22.9 179.35,27.1 179.86,27.1 182.41,29.65 187.08,29.65 v2(187.23,29.8)
  BOTTOM w0.127: UH1.AM45 193.48,25.3 v2(194.07,25.89)
NVDD_PWM3: length 19.6
  IN2 w0.254: v2(218.43,59.6) 218.62,59.41 220.82,59.41 222.41,57.82 222.41,52.56 224.8,50.17 226.2,50.17 v2(226.98,50.95)
  BOTTOM w0.254: PRV21.1 227.01,52.4 226.97,52.44 v1(226.97,52.91) 226.97,53.42 226.88,53.51 PUV1.22 ; v2(218.43,59.6) 218.76,59.6 PUV2.5
  BOTTOM w0.381: v2(226.98,50.95) 226.98,51.86 PRV21.1
NVVDD_BST2:
  vias: v1(230.76,54.39)
NVVDD_BST3: length 1.3
  BOTTOM w0.127: PUV2.4 218.75,57.67 v1(218.03,58.39)
NVVDD_BST3_R: length 1.4
  BOTTOM w0.127: PRV24.2 220.38,55 v1(220.79,54.58)
NVVDD_EN: length 8.6
  TOP w0.127: v2(221.09,57.67) 220.66,57.67 v1(220.38,57.96)
  IN1 w0.254: v2(221.09,57.67) 222.22,57.67 222.78,57.11 222.78,56.29 223.54,55.54 v2(223.99,55.54)
  BOTTOM w0.254: PRV14.1 223.3,55.24 PCV17.1 223.6,55.54 v2(223.99,55.54) 224.11,55.54 224.37,55.79 PUV1.3 ; PUV2.1 v2(221.09,57.67)
NVVDD_FB: length 6
  BOTTOM w0.254: 229.69,59.04 230.04,59.38 PCV20.2 ; 229.69,59.04 230.17,58.56 v1(230.34,58.56) 231.22,58.56 PRV22.2 231.27,58.59 231.8,59.13 PRV38.2 ; 229.69,59.04 228.31,59.04 227.88,58.61 PUV1.11
NVVDD_ILIM: length 3.2
  TOP w0.254: v2(228.94,58.51) 228.7,58.75 v1(228.21,58.75) 227.51,58.05 PRV26.1
  BOTTOM w0.254: v2(228.94,58.51) 228.82,58.62 228.54,58.62 228.38,58.46 PUV1.12
NVVDD_ISEN2: length 4.2
  TOP w0.127: v2(230.68,56.79) 231.05,57.16 231.38,57.16 v1(231.39,57.16)
  TOP w0.254: PRV32.2 231.26,56.21 v2(230.68,56.79)
  BOTTOM w0.203: PUV1.14 229.75,56.79 229.79,56.75 230.64,56.75 v2(230.68,56.79) 230.79,56.9 PRV35.1
NVVDD_LG1: length 25.2
  IN3 w0.762: 208.12,57.72 208.45,57.39 208.45,54.22 208.01,53.77 208.01,52.52 209.55,50.98 221.49,50.98 224.71,54.2 225.73,54.2
  vias: v2(207.48,58.75) v2(207.48,58.16) v2(226.17,52.63) v2(226.4,53.19)
NVVDD_LG2: length 32.1
  IN1 w0.762: 227.31,52.5 226.62,51.81 224.97,51.81 224.26,51.1 222.45,51.1 221.41,52.14 204.53,52.14 202.52,54.15 201.08,54.15 200.45,54.79 200.45,57.5 200.14,57.81
  vias: v2(199.45,58.62) v2(199.45,58.04) v2(227.92,53.21) v2(228.42,52.92)
NVVDD_LG3:
  vias: v1(216.27,59.47)
NVVDD_LX1: length 21.3
  IN3 w0.762: 224.79,52.49 222.01,49.71 208.92,49.71 206.67,51.96 206.67,53.04
  vias: v2(205.3,53.38) v2(205.88,53.38) v2(225.08,53.22) v2(225.7,53.17)
NVVDD_LX1_1: length 2.3
  TOP w0.508: v2(202.65,62.58) v1(203.24,62.58) PRV3.1
NVVDD_LX2: length 37.5
  IN1 w0.762: 231.26,52.45 231.26,50 229.83,48.56 221.4,48.56 220.36,49.6 202.2,49.6 198.7,53.1
  vias: v2(197.24,53.34) v2(197.82,53.34) v2(230.55,53.82) v2(230.92,53.36)
NVVDD_LX2_1: length 3.3
  TOP w0.127: PRV17.1 193.89,62.04 v3(193.48,61.63)
  TOP w0.508: v2(194.96,61) 195.38,61.42 PRV17.1
NVVDD_LX3: length 10.3
  IN1 w0.508: v2(220.53,56.75) 219.53,57.75 218.71,57.75 216.34,55.38 216.34,54.29 215.44,53.39 v2(213.11,53.39)
NVVDD_LX3_1: length 2.5
  TOP w0.508: PRV30.1 v1(214.23,62.65) v2(214.85,62.65)
NVVDD_PHASE1: length 39
  IN3 w0.203: v2(204.87,64.04) 206.99,64.04 207.56,63.48 213.33,63.48 213.64,63.79 216.19,63.79 217.07,62.9 217.07,59.09 217.66,58.5 217.66,56.19 218.71,55.15 221.39,55.15 223.58,57.33 225.6,57.33 225.76,57.49 228.31,57.49 228.45,57.36 229.5,57.36 229.8,57.67 230.6,57.67 232.13,56.14 v2(232.89,56.14)
  BOTTOM w0.203: PRV36.2 v2(232.89,56.14) ; v2(204.87,64.04) PLV1.2
NVVDD_PHASE2: length 46.7
  IN3 w0.203: v2(197.17,63.84) 201.1,63.84 201.77,64.52 207.01,64.52 207.7,63.82 213.18,63.82 213.49,64.13 216.39,64.13 217.42,63.1 217.42,59.23 218.01,58.65 218.01,56.34 218.85,55.49 221.25,55.49 223.43,57.68 225.46,57.68 225.61,57.84 228.46,57.84 228.59,57.7 229.35,57.7 229.66,58.01 230.74,58.01 231.83,56.92 v2(232.89,56.92)
  BOTTOM w0.203: PRV35.2 232.33,56.92 v2(232.89,56.92) ; PLV2.2 v2(197.17,63.84)
NVVDD_PHASE3: length 31.1
  IN3 w0.203: v2(213.01,64.48) 216.53,64.48 217.77,63.24 217.77,59.38 218.35,58.79 218.35,56.48 218.99,55.84 221.1,55.84 223.29,58.02 225.31,58.02 225.47,58.18 228.6,58.18 228.73,58.05 229.21,58.05 229.52,58.36 230.89,58.36 231.73,57.52 v2(232.9,57.52)
  BOTTOM w0.203: PLV3.2 212.61,64.08 v2(213.01,64.48) ; PRV31.1 232.39,57.52 v2(232.9,57.52)
NVVDD_PSI: length 40
  TOP w0.102: v2(210.98,80.22) 210.98,80.09 210.5,79.61 210.5,79.31 210.43,79.24 210.43,78.32 210.53,78.22 210.53,77.71 210.67,77.57 210.67,76.83 212,75.49 213.69,75.49 214.35,74.83 214.35,74.57 214.74,74.18
  TOP w0.127: 214.74,74.18 214.74,72.86 216.44,71.16 218.84,71.16 219.26,70.75 222.97,70.75 226.53,67.18 v1(226.53,63.03) 226.53,62.77 RG37.2 225.25,62.06 224.44,61.25 224.44,60.72 224.24,60.52 223.14,60.52 v2(223.01,60.65)
  BOTTOM w0.127: v2(210.98,80.22) 210.68,80.56 UG1.M7 ; PRV8.2 221.96,56.57 221.96,56.72 221.55,57.13 221.55,58.19 222.34,58.98 222.69,58.98 222.76,59.05 222.76,59.18 223.01,59.44 v2(223.01,60.65)
NVVDD_PSI_R: length 4.6
  TOP w0.127: v2(224.02,56.12) 223.8,56.12 223.7,56.02 v1(223.36,56.02)
  TOP w0.254: PRV5.2 225.08,55.43 224.76,55.74 PRV12.1 224.09,56.19 v2(224.02,56.12)
  BOTTOM w0.254: PUV1.4 224.19,56.29 v2(224.02,56.12) 223.99,56.09 PRV8.1
NVVDD_PVCC: length 7.2
  TOP w0.127: v1(227.82,52.32) 228.11,52.03 228.33,52.03 v2(228.35,52.06)
  TOP w0.254: PRV33.2 229.43,53.36 PRV34.1 228.97,52.06 v2(228.35,52.06)
  BOTTOM w0.254: v2(228.35,52.06) 228.27,52.06 227.82,51.61 PCV28.1 227.58,51.66 227.58,52.45 227.38,52.64 PUV1.21
NVVDD_PWM_VID: length 32.1
  TOP w0.127: v1(221.96,58.96) 222.1,58.82 222.29,58.82 v2(222.57,58.54)
  IN3 w0.254: v2(209.4,80.21) 209.4,78.66 208.82,78.08 208.82,76.52 212.9,72.44 214.17,72.44 219.04,67.57 219.04,63.72 219.39,63.37 219.39,62.59 220.85,61.13 220.85,60.44 222.57,58.72 v2(222.57,58.54)
  BOTTOM w0.254: PRV37.2 222.23,56.91 221.94,57.2 221.94,58.12 222.36,58.54 v2(222.57,58.54) ; UG1.P6 v2(209.4,80.21)
NVVDD_REFADJ: length 1.9
  BOTTOM w0.254: PUV1.6 224.17,57.29 223.75,57.71 PRV11.2
NVVDD_REFIN: length 5.1
  TOP w0.127: v2(224.56,58.63) 224.33,58.86 v1(223.89,58.86)
  TOP w0.254: v2(224.56,58.63) 224.24,58.3 PCV15.1 223.45,57.91 PRV13.1
  BOTTOM w0.254: PRV10.1 224.54,58.69 224.56,58.66 v2(224.56,58.63) 224.56,58.52 224.97,58.12 225.86,58.12 PUV1.7
NVVDD_RGND: length 13.2
  TOP w0.254: v2(227.38,58.88) 227.29,58.98 226.97,58.98 v1(226.75,58.76) PRV20.2 226.02,57.74 225.27,56.99 PCV9.2 PCV15.2 223.46,56.99 PRV15.2
  IN1 w0.254: v2(224.98,61.13) 227.23,58.88 v2(227.38,58.88)
  BOTTOM w0.254: PCV16.2 224.86,61.25 v2(224.98,61.13) ; PRV19.2 229.13,60.45 PCV20.1 228.89,59.43 227.92,59.43 v2(227.38,58.88) PUV1.10
NVVDD_SNUB1: length 3.2
  TOP w0.127: v3(202.9,59.92) PRV3.2
  TOP w0.508: PRV3.2 204.93,59.36 204.83,59.26 PCV8.1
NVVDD_SNUB2: length 3.5
  TOP w0.127: v3(193.6,59.38) PRV17.2
  TOP w0.508: PCV19.1 196.03,60.03 PRV17.2
NVVDD_SNUB3: length 3.2
  TOP w0.127: v3(214.34,59.98) PRV30.2
  TOP w0.508: PRV30.2 212.37,59.28 PCV27.1
NVVDD_TON: length 2.6
  BOTTOM w0.254: PUV1.9 226.88,58.64 226.3,59.22 225.63,59.22 PRV16.2
NVVDD_TSNS/ISEN3: length 4.1
  TOP w0.127: v1(230.17,57.82) 230.17,57.38 v2(229.99,57.21)
  TOP w0.254: v2(229.99,57.21) 229.51,56.73 PRV28.2
  BOTTOM w0.203: PUV1.13 229.91,57.29 v2(229.99,57.21) 230.3,57.21 230.79,57.71 PRV31.2
NVVDD_UG1: length 13.6
  IN3 w0.762: 223.04,54.33 220.96,52.25 212.55,52.25 211.71,53.08 210.7,53.08
  vias: v2(209.28,53.26) v2(209.87,53.26) v2(223.93,54.55) v2(224.3,54.98)
NVVDD_UG2: length 33.4
  IN1 w0.762: 229.47,54.18 229.47,52.6 229.99,52.08 229.99,50.53 229.3,49.83 221.92,49.83 220.89,50.87 203.34,50.87 201.81,52.4
  vias: v2(201.41,53.22) v2(202,53.22) v2(229.97,55.2) v2(230.54,55.2)
NVVDD_UG3: length 6.1
  IN1 w0.508: v2(216.78,53.36) 218.2,53.36 219.38,54.54 v2(219.38,56.7)
  BOTTOM w0.508: PRV23.1 217.02,53.36 v2(216.78,53.36)
NVVDD_VCC/ISEN1: length 4.6
  TOP w0.254: v2(230.16,56.29) 229.66,56.29 v1(229.12,55.76) 228.89,55.53 PRV33.1
  BOTTOM w0.203: PUV1.15 v2(230.16,56.29) 230.98,56.29 231.14,56.14 PRV36.1
NVVDD_VID: length 1.8
  BOTTOM w0.254: PUV1.5 223.45,56.79 PRV37.1
NVVDD_VREF: length 10.6
  TOP w0.254: PCV9.1 225.15,58.65 v2(225.16,58.66) 225.16,59.04 v1(225.47,59.34) 225.57,59.44 229.05,59.44 229.81,58.69 229.81,58.28 PRV28.1
  BOTTOM w0.254: PUV1.8 226.38,58.57 226.12,58.83 225.74,58.83 225.57,58.66 v2(225.16,58.66) 225.16,58.75 224.45,59.47 PRV7.1
NVVDDS_PSI: length 18
  BOTTOM w0.109: 210.32,75.78 210.32,78.14 209.97,78.49 209.33,78.49 UG1.P4
  BOTTOM w0.127: 210.32,75.78 210.32,75.58 210.52,75.38 210.69,75.38 212.14,73.93 212.14,73.76 213.18,72.73 v1(213.45,72.73) 214.31,72.73 214.98,72.06 215.65,72.06 218.13,69.58 218.13,68.71 218.5,68.34 218.5,68.16 218.99,67.67 218.99,67.18 219.41,66.76 RG39.2
ON/OFF#: length 228.9
  TOP w0.127: v2(14.79,122.01) 14.5,122.01 13.61,121.12 12.9,121.12 12.45,120.67 12.85,120.28 14.48,120.28 Q80.1 15.05,120.83 v3(16.41,119.47) ; v2(127.99,6.84) 127.82,7.01 127.82,8.46 127.66,8.61 127.66,11.03 127.82,11.19 127.82,12.16 130.28,14.62 v3(130.64,14.62) 130.76,14.74 132.95,14.74 133.12,14.91 v3(133.82,14.91) 134.14,14.91 134.64,15.42 UK1.114
  IN3 w0.127: v2(14.79,122.01) 15.03,122.25 15.83,122.25 16.59,121.49 16.59,120.36 16.83,120.11 16.83,119.57 17.56,118.85 17.56,117.37 18.37,116.56 18.37,85.2 18.28,85.11 18.28,83.42 19,82.7 19,78.77 19.13,78.64 19.13,73.56 20.03,72.66 20.03,70.26 19.49,69.72 19.49,67.96 20.77,66.68 21.28,66.68 22.97,64.98 22.97,64.48 23.16,64.29 23.16,58.92 23.8,58.28 26.67,58.28 27.78,57.16 27.78,56.04 28.62,55.2 30.6,55.2 31.63,54.17 32.38,54.17 33.42,53.12 35.04,53.12 35.96,52.21 35.96,50.82 39.57,47.22 41.04,47.22 41.9,46.36 41.9,44.66 42.35,44.21 43.19,44.21 43.37,44.38 45.84,44.38 46.31,43.91 49.65,43.91 50.23,43.33 50.23,40.91 52.13,39 52.13,37.62 52.43,37.32 52.43,36.05 53.66,34.82 53.66,31.37 53.38,31.09 53.38,29.25 58.53,24.1 60.29,24.1 60.79,23.6 60.79,21.17 62.12,19.84 62.12,19.57 66.68,15.01 72.78,15.01 73.96,13.83 80.14,13.83 83.86,10.1 86.89,10.1 88.16,8.84 89.76,8.84 92.5,6.09 127.59,6.09 127.99,6.49 v2(127.99,6.84)
ON/OFF#_R: length 11.5
  TOP w0.127: v3(13.27,124.31) Q80.3 13.02,122.04 11.43,122.04 10.37,120.98 8.71,120.98 8.34,121.35 D1.3 9.57,121.77 v2(9.67,121.66)
  BOTTOM w0.127: JPWR1.3 10.75,122.85 9.67,121.76 v2(9.67,121.66)
PBTN_OUT#: length 71.5
  TOP w0.127: v2(165.11,23.59) 165.11,23.34 v1(165.54,22.91) 165.74,22.71 165.74,20.68 172.92,13.49 173.08,13.49 173.82,12.75 175.47,12.75 178.07,10.15 181.85,10.15 185.83,14.13 185.83,14.93 RH48.2 ; v2(139.35,18.61) 139.35,18.05 139.48,17.92 139.48,17.17 139.06,16.75 139.06,14.62 136.66,12.22 UK1.122 134.55,12.22 134,11.67 R295.1
  IN3 w0.127: v2(139.35,18.61) 139.35,18.99 139.74,19.39 140.94,19.39 141.51,18.82 143.69,18.82 144.69,19.82 146.05,19.82 147.38,21.15 150,21.15 152.48,23.63 159.75,23.63 160.2,23.18 161.58,23.18 161.82,22.94 164.46,22.94 v2(165.11,23.59)
PBTN_OUT#_R: length 11.8
  TOP w0.127: RH47.1 186.82,16.1 RH48.1 185.04,16.63 v2(185.04,16.96) 185.21,17.13 v1(185.53,17.13)
  IN2 w0.127: v2(192.6,18.31) 192.42,18.13 187.77,18.13 186.61,16.96 v2(185.04,16.96)
  BOTTOM w0.127: UH1.BE46 192.3,18.61 v2(192.6,18.31)
PC_BEEP: length 2.3
  TOP w0.127: CA29.2 292.92,25.85 v1(293.34,25.44) 293.34,25.01
  TOP w0.135: 293.34,25.01 293.62,24.73 UA1.34
PC_BEEP_R: length 3.7
  TOP w0.127: v1(286.02,28.39) 286.44,27.98 287.46,27.98 287.69,27.75 CA28.2 CA27.2 RA19.1
PCH_BKL_PWM: length 130.2
  IN2 w0.127: v2(190.61,23.54) 190.33,23.26 188.46,23.26 187.95,23.77 184.42,23.77 184.27,23.92 181.03,23.92 177.32,20.21 168.84,20.21 168.09,19.46 152.06,19.46 149.97,17.37 142.6,17.37 140.66,15.43 135.96,15.43 133.98,17.41 131.55,17.41 130.92,16.78 127.65,16.78 127.17,16.3 121.3,16.3 120.88,15.88 118.87,15.88 117.99,15.01 115.33,15.01 114.17,16.17 112.18,16.17 110.48,17.87 108.18,17.87 107.88,18.17 102.22,18.17 101.6,18.79 86.99,18.79 84.02,21.75 v2(71.8,21.75)
  BOTTOM w0.127: v2(190.61,23.54) 190.62,23.54 191.18,22.98 UH1.AU48 ; RV4.1 73.38,22.21 72.93,21.75 v2(71.8,21.75)
PCH_CPU_24M_CLK_N: length 97.7
  IN3 w0.127: v2(204.43,46.81) 204.2,47.04 204.2,48.44 203.23,49.4 200.64,49.4 199.42,50.62 194.62,50.62 190.96,54.27 190.96,68.91 189.46,70.41 189.46,73.02 186.99,75.5 186.99,80.23 185.7,81.52 185.7,83.07 171.43,97.34 171.43,99.96 171.78,100.32 171.78,102.83 171.07,103.54 171.07,104.54 v2(170.32,105.29)
  BOTTOM w0.089: 168.86,104.77 168.84,104.77 168.81,104.74 168.46,104.74 168.15,105.05 167.87,105.05 167.47,104.65 165.83,104.65 165.74,104.74 165.74,104.86 165.82,104.94 UC1.D31 ; 212.3,43.41 212.3,43.4 212.27,43.36 212.27,43.18 212.55,42.9 212.55,41.59 211.67,40.71 211.62,40.65 211.62,39.48 UH1.C6
  BOTTOM w0.127: 168.86,104.77 169.37,104.77 169.69,105.09 170.12,105.09 v2(170.32,105.29) ; v2(204.43,46.81) 204.2,46.58 204.2,46.07 205.31,44.96 211.44,44.96 212.3,44.09 212.3,43.41
