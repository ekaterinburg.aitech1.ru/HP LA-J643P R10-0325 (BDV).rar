# Allegro board LAJ643PR10-0325.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SA1_CHB_DIM2: length 12.1
  TOP w0.127: v1(171.94,33.73) 171.72,33.94 171.72,34.42 v2(171.55,34.59) 170.85,34.59 170.38,35.06 169.94,35.06 169.56,35.44 169.56,36.12 169.14,36.54 RD23.1 168.44,36.88 168.67,37.11 RD20.2
  BOTTOM w0.127: JDIMM2.260 169.28,30.44 170.25,31.42 170.57,31.74 170.57,32.08 171.65,33.15 171.65,34.49 v2(171.55,34.59)
SA2_CHA_DIM1: length 6.3
  TOP w0.127: v1(146.99,38.2) RD2.2
  TOP w0.381: RD2.2 147.02,39.16 RD6.1 146.64,39.9 146.4,39.66 145.86,39.66 v2(145.85,39.67)
  BOTTOM w0.356: v2(145.85,39.67) 146.42,39.67 147.28,40.53 JDIMM1.166
SA2_CHB_DIM2: length 4.5
  TOP w0.127: RD21.2 v1(147.66,28.7)
  TOP w0.305: v2(145.37,28.09) 145.88,28.6 RD24.1 145.9,28.7 RD21.2
  BOTTOM w0.305: v2(145.37,28.09) 145.78,28.5 JDIMM2.166
SATA_LED#: length 315.6
  TOP w0.127: v2(65.76,21.87) 65.7,21.8 65.7,21.44 64.58,20.32 64.58,19.29 61.66,16.36 60.63,16.36 56.95,12.69 54.59,12.69 53.77,13.5 53.2,13.5 52.77,13.93 46.42,13.93 45.31,12.81 43.18,12.81 40.39,10.03 v1(40.39,8.79) 40.39,7.68 v2(40.62,7.45)
  IN2 w0.127: v2(279.18,38.99) 278.75,39.42 277.91,39.42 277.8,39.32 277.8,37.91 276.75,36.86 260.06,36.86 259.94,36.98 258.54,36.98 256.08,34.52 252.31,34.52 252.02,34.81 248.09,34.81 247.09,33.81 239.29,33.81 239.1,34 226.14,34 223.88,31.74 223.38,31.74 219.69,28.05 219.69,26.6 218.66,25.58 217.73,25.58 216.74,24.59 213.97,24.59 213.62,24.94 211.93,24.94 211.04,25.83 205.74,25.83 205.41,25.5 198.71,25.5 198.02,26.2 198.02,26.66 197.86,26.82 195.74,26.82 194.14,28.42 189.54,28.42 v2(188.65,27.53) 188.1,26.98 185.94,26.98 184.61,28.31 183.03,28.31 180.48,25.76 179.91,25.76 175.71,21.56 160.94,21.56 160.32,22.17 152.87,22.17 151.33,20.63 146.91,20.63 145.69,19.42 142.74,19.42 140.97,17.65 135.65,17.65 134.54,18.76 132.43,18.76 131.46,19.73 130.77,19.73 130.53,19.49 124.76,19.49 123.68,18.41 122.65,18.41 121.88,17.64 120.74,17.64 120.32,17.22 118.2,17.22 117.91,16.93 116.69,16.93 116.07,17.54 112.71,17.54 108.67,21.58 100,21.58 99.55,21.13 98.53,21.13 97.54,20.14 87.55,20.14 84.58,23.1 73.33,23.1 72.51,23.92 67.26,23.92 65.7,22.37 65.7,21.93 v2(65.76,21.87)
  BOTTOM w0.127: RH170.1 188.33,28.39 188.65,28.08 v2(188.65,27.53) 189.8,26.37 UH1.AK48 ; v2(279.18,38.99) 279.18,40.58 282.59,43.98 291.31,43.98 292.32,42.97 292.32,42.01 293.75,40.58 302.89,40.58 303.41,41.1 307.4,41.1 307.88,41.58 307.88,42 308.13,42.25 JIO1.8 ; D513.2 38.82,5.65 v2(40.62,7.45)
SATA_PRX_C_DTX_N0: length 10.6
  BOTTOM w0.127: JHDD1.8 247.65,16.58 247.81,16.74 247.81,16.93 248.57,17.69 v4(253.87,17.69) 254.93,17.69 255.69,18.46 255.69,18.91 C379.2
SATA_PRX_C_DTX_P0: length 10.5
  BOTTOM w0.127: JHDD1.7 248.15,16.56 248.06,16.65 248.06,16.82 248.68,17.44 255.03,17.44 v4(255.55,17.95) 255.95,18.36 255.95,19.12 C378.2
SATA_PRX_DTX_N0: length 102.1
  IN1 w0.135: v2(193.02,39.2) 192.97,39.2 192.7,39.47 192.7,39.59 192.98,39.88 199.37,39.88 200.36,40.86 200.36,43.86 200.99,44.49 209.62,44.49 210.16,45.04 214.05,45.04 214.77,44.32 219.14,44.32 222.47,41 228.41,41 228.94,41.53 231.33,41.53 232.07,42.28 233.44,42.28 234.1,42.95 236.62,42.95 237.06,43.39 241.68,43.39 242.5,44.21 248.51,44.21 249.28,43.44 253.94,43.44 255.03,42.35 256.47,42.35 256.71,42.11 258.85,42.11 259.3,41.65 259.3,41.56 v2(259.06,41.32)
  BOTTOM w0.127: UH1.C45 192.6,39.37 192.85,39.37 v2(193.02,39.2) ; v2(259.06,41.32) 259.29,41.1 259.29,41.03 257.33,39.06 255.62,39.06 254.77,38.22 254.77,35.25 255.34,34.68 255.34,32.52 257.27,30.59 257.27,25.24 255.57,23.53 255.57,20.54 C379.1
SATA_PRX_DTX_P0: length 102.2
  IN1 w0.135: v2(259.77,41.32) 259.59,41.51 259.59,41.76 258.96,42.39 256.83,42.39 256.59,42.63 255.15,42.63 254.05,43.72 249.4,43.72 248.63,44.49 242.39,44.49 241.56,43.67 236.94,43.67 236.5,43.23 233.99,43.23 233.32,42.56 231.96,42.56 231.21,41.81 228.83,41.81 228.29,41.28 222.58,41.28 219.26,44.6 214.88,44.6 214.17,45.32 210.05,45.32 209.5,44.77 200.87,44.77 200.08,43.98 200.08,40.98 199.26,40.16 192.87,40.16 192.64,39.93 v2(192.45,39.93)
  BOTTOM w0.127: v2(192.45,39.93) UH1.C46 ; C378.1 255.82,20.59 255.82,23.43 257.53,25.13 257.53,30.7 255.6,32.63 255.6,34.79 255.03,35.35 255.03,38.11 255.73,38.81 257.43,38.81 259.54,40.92 259.54,41.09 v2(259.77,41.32)
SATA_PTX_C_DRX_N0: length 10.1
  BOTTOM w0.127: JHDD1.10 246.65,16.62 246.53,16.75 246.53,16.98 246.69,17.14 247.39,17.14 248.37,18.13 v4(252.26,18.13) 253.51,18.13 254.04,18.66 254.04,19.06 C380.2
SATA_PTX_C_DRX_P0: length 10.1
  BOTTOM w0.127: C382.2 253.79,19.01 253.79,18.77 253.4,18.38 v4(250.87,18.38) 248.27,18.38 247.28,17.4 246.58,17.4 246.27,17.09 246.27,16.72 246.15,16.6 JHDD1.11
SATA_PTX_DRX_N0: length 100.5
  IN1 w0.135: v2(257.62,42.92) 257.43,43.11 257.43,43.41 257.06,43.78 255.11,43.78 254.45,44.44 250.55,44.44 249.37,45.62 242.83,45.62 242.55,45.9 240.24,45.9 238.73,44.39 236.45,44.39 236.25,44.18 233.92,44.18 233.05,43.31 231.65,43.31 231.04,42.7 228.33,42.7 227.68,42.04 222.91,42.04 219.63,45.32 215.44,45.32 214.73,46.03 209.75,46.03 209.26,45.55 199.68,45.55 198.16,44.03 197.8,44.03 v2(197.66,44.17)
  BOTTOM w0.089: UH1.B38 196.24,39.99 195.97,40.25 195.97,40.38 195.61,40.74 195.61,41.07 195.51,41.17 195.51,44.35 195.84,44.68 196.53,44.68 197.23,43.97 197.47,43.97 v2(197.66,44.17)
  BOTTOM w0.127: C380.1 253.97,20.63 253.97,22.55 256.84,25.41 256.84,30.41 254.9,32.35 254.9,34.42 253.65,35.67 253.65,39.74 254.78,40.87 255.92,40.87 257.4,42.35 257.4,42.7 v2(257.62,42.92)
SATA_PTX_DRX_P0: length 100.4
  IN1 w0.135: v2(256.91,42.92) 257.15,43.17 257.15,43.29 256.95,43.5 254.99,43.5 254.33,44.16 250.44,44.16 249.25,45.34 242.71,45.34 242.44,45.62 240.36,45.62 238.84,44.11 236.57,44.11 236.36,43.9 234.03,43.9 233.16,43.03 231.77,43.03 231.16,42.42 228.45,42.42 227.79,41.76 222.79,41.76 219.52,45.04 215.33,45.04 214.61,45.76 209.87,45.76 209.38,45.27 199.8,45.27 198.28,43.75 197.83,43.75 v2(197.66,43.58)
  BOTTOM w0.089: v2(197.66,43.58) 197.47,43.78 197.15,43.78 196.45,44.49 195.92,44.49 195.7,44.27 195.7,41.25 195.8,41.15 195.8,40.82 196.16,40.46 196.16,40.33 196.32,40.17 196.36,40.16 196.48,40.03 196.48,39.65 196.24,39.41 UH1.C38
  BOTTOM w0.127: C382.1 253.71,20.53 253.71,22.65 256.58,25.52 256.58,30.31 254.64,32.25 254.64,34.31 253.39,35.56 253.39,39.85 254.67,41.13 255.81,41.13 257.14,42.46 257.14,42.7 v2(256.91,42.92)
SD_CD#: length 18.6
  IN3 w0.127: v2(44.78,16.26) 44.42,16.26 43.9,16.78 43.9,18.03 41.84,20.09 41.84,22.26 41.33,22.76 37.84,22.76 37.31,23.29 36.17,23.29 35.01,24.45 35.01,25.42 JCR2.4
  BOTTOM w0.127: v2(44.78,16.26) 44.78,16.26 UR1.30
SD_CLK: length 2.1
  BOTTOM w0.127: UR1.17 40.21,19.43 v2(39.92,19.71) 39.45,20.19 RR6.1
SD_CLK_R: length 14.1
  BOTTOM w0.127: RR6.2 38.93,21.64 38.91,21.61 CR12.1 v1(37.43,21.61) 37.28,21.61 35.35,23.55 35.35,30.85 JCR2.7
SD_CMD: length 1.8
  BOTTOM w0.127: RR7.1 40.98,19.98 41.01,19.95 UR1.19
SD_CMD_R: length 9.8
  IN3 w0.127: JCR2.3 36.56,22.13 37.52,22.13 37.66,22.27 38.72,22.27 38.85,22.14 38.85,21.72 38.98,21.6 39.36,21.6 39.49,21.72 39.49,22.14 39.61,22.27 v2(40.98,22.27)
  BOTTOM w0.127: RR7.2 v2(40.98,22.27)
SD_D0: length 2.7
  BOTTOM w0.127: RR5.2 38.16,19.5 38.51,19.5 v2(38.68,19.34) 38.99,19.02 38.99,18.4 39.14,18.26 UR1.16
SD_D0_R: length 19.2
  TOP w0.127: v2(35.57,19.93) 35.57,20.13 v1(35.57,20.97) 35.57,21.91 35.36,22.12 35.36,31.85 35.19,32.03 35.19,35.93 JCR2.9
  BOTTOM w0.127: RR5.1 35.66,19.84 v2(35.57,19.93)
SD_D1: length 2.3
  BOTTOM w0.127: RR4.2 38.11,19.07 38.66,18.52 38.66,18.31 39.12,17.86 UR1.15
SD_D1_R: length 21.2
  TOP w0.127: v2(36.3,19.4) 36.17,19.54 36.17,20.43 36,20.6 36,22.09 35.8,22.3 35.8,32.07 35.62,32.24 35.62,36.93 34,38.56 JCR2.10
  BOTTOM w0.127: v2(36.3,19.4) 36.63,19.07 RR4.1
SD_D2: length 2.1
  BOTTOM w0.127: UR1.21 41.81,19.79 42.5,20.48 RR9.1
SD_D2_R: length 11.9
  IN1 w0.127: JCR2.1 34.98,20.68 39.1,20.68 39.6,20.18 43.3,20.18 v2(43.46,20.34)
  BOTTOM w0.127: RR9.2 42.58,21.64 43.46,20.75 v2(43.46,20.34)
SD_D3: length 1.9
  BOTTOM w0.127: RR8.1 41.74,20.35 41.41,20.02 v2(41.41,19.71) UR1.20
SD_D3_R: length 14.8
  IN1 w0.127: JCR2.2 35.08,21.11 39.28,21.11 39.78,20.61 42.72,20.61 42.96,20.85 43.65,20.85 v2(44.13,20.37)
  BOTTOM w0.127: v2(44.13,20.37) 44.13,20.89 v1(43.66,21.37) 42.91,22.12 42.07,22.12 41.74,21.79 RR8.2
SD_RCOMP_1P8: length 3.4
  TOP w0.127: v1(212.53,20.79) 213.29,20.79 213.44,20.64 RH22.1 213.01,20.47 212.49,19.95 v2(212.49,19.36)
  BOTTOM w0.102: v2(212.49,19.36) 212.49,18.91 UH1.BE5
SD_RCOMP_3P3: length 1.5
  TOP w0.127: v2(212.34,18.23) 212.37,18.26 RH23.1
  BOTTOM w0.127: UH1.BE4 212.72,18.61 v2(212.34,18.23)
SD_WP: length 30.6
  TOP w0.127: v2(44.78,16.87) 43.26,18.39 v1(43.26,18.74) 40.76,21.24 40.76,21.89 38.51,24.14 36.65,24.14 36.23,24.57 36.23,32.25 36.05,32.42 36.05,37.11 34.89,38.28 34.89,39.88 JCR2.11
  BOTTOM w0.127: v2(44.78,16.87) 44.57,16.66 UR1.29
SERIRQ: length 80.8
  TOP w0.127: v2(193.48,11.06) RH64.2 RH65.2 ; v2(145,18.06) 145,18.03 144.47,17.5 142.88,17.5 141.06,15.69 141.06,13.85 138.04,10.83 UK1.3
  IN1 w0.127: v2(193.48,11.06) 192.73,10.32 185.07,10.32 184.76,10.01 181.52,10.01 180.48,8.98 177.49,8.98 175.17,6.66 175.17,6.28 174.74,5.85 169.27,5.85 v2(169.08,6.04)
  BOTTOM w0.127: v2(169.08,6.04) 169.07,6.05 169.07,9.22 166.98,11.31 164.52,11.31 162.92,12.91 152.16,12.91 150.24,11 144.73,11 144.58,11.15 142.79,12.94 142.79,15.56 145,17.77 v2(145,18.06)
SIZE_SEL: length 14.3
  TOP w0.102: v2(197.32,20.48) 197,20.48 196.38,19.86 196.38,15.85 196.13,15.6
  TOP w0.127: 196.13,15.6 195.94,15.41 195.94,14.99 v1(195.34,14.39) 195.12,14.39 195,14.27 194.65,14.27 194.45,14.08 194.45,13.55 195.14,12.86 195.14,11.69 195.01,11.57 RH255.1
  TOP w0.135: RH255.1 RH256.1
  BOTTOM w0.127: UH1.BA33 197.95,20.97 197.47,20.48 v2(197.32,20.48)
SKTOCC#: length 2.8
  BOTTOM w0.127: TC102.1 125.32,105.87 127.57,105.87 UC1.BR33
SLP_LAN#: length 2.9
  BOTTOM w0.127: TH131.1 195.13,15.83 195.13,17.21 195.38,17.45 UH1.BF40
SLP_WLAN#: length 135.5
  TOP w0.135: v2(301.13,5.21) 301.13,5.27 v3(301.88,6.01) 302.07,6.21 QWL3.2
  IN1 w0.127: v2(193.17,15.17) 199.24,15.17 199.98,14.43 199.98,12.34 197.06,9.42 197.06,9.39 196.36,8.69 196.36,8.21 196.84,7.73 202.35,7.73 202.74,7.35 205.64,7.35 205.81,7.52 205.81,8.19 206.11,8.49 208.92,8.49 209.12,8.29 214.25,8.29 215.89,6.64 221.27,6.64 222.21,7.58 224.73,7.58 225.64,8.5 225.64,8.84 228.09,11.29 231.18,11.29 232.76,9.71 232.76,9.02 234.21,7.58 239.62,7.58 239.85,7.35 243.36,7.35 244.28,6.43 249.02,6.43 249.42,6.03 259.97,6.03 260.57,5.43 275.84,5.43 276.44,6.03 277.39,6.03 v2(278.09,5.32)
  IN2 w0.127: v2(278.09,5.32) 278.73,5.96 280.97,5.96 282.3,4.63 300.56,4.63 v2(301.13,5.21)
  BOTTOM w0.102: 193.6,16.7 193.6,16.81 194.46,17.66 194.46,18.92 UH1.BD42
  BOTTOM w0.127: v2(193.17,15.17) 193.17,15.91 193.6,16.34 193.6,16.7
SM_INTRUDER#: length 9.4
  TOP w0.127: v2(192.69,20.32) 192.69,20.38 193.63,21.32 v1(193.65,21.32) ; RH6.2 187.73,17.47 187.77,17.47 187.96,17.65 v2(188.04,17.65)
  IN3 w0.127: v2(188.04,17.65) 188.04,18.46 189.63,20.04 191.41,20.04 191.95,20.58 192.44,20.58 v2(192.69,20.32)
  BOTTOM w0.127: UH1.BB44 v2(192.69,20.32)
SM_PG_CTRL: length 153.4
  TOP w0.127: v2(95.79,22.91) v3(95.79,22.32)
  IN2 w0.127: v2(95.79,22.91) 95.48,22.6 90.65,22.6 88.05,25.2 85.15,25.2 82.01,28.33 67.79,28.33 66.42,29.7 59.73,29.7 58.93,28.9 57.11,28.9 56.18,29.83 56.18,32.43 57.02,33.28 62.66,33.28 63.36,33.98 63.36,39.91 63.77,40.32 67.25,40.32 69.1,42.17 78.23,42.17 78.44,42.37 80.78,42.37 83.15,44.75 84.94,44.75 87.32,47.13 87.32,51.73 94.36,58.76 94.36,61.22 94.99,62.08 95.01,62.1 97.49,65.48 98.7,67.87 100.49,71.27 101.8,72.58 v2(101.8,73.1)
  BOTTOM w0.127: PRM12.1 95.46,22.58 v2(95.79,22.91) ; UC2.4 121.25,85.53 RC43.2 121.42,82.61 121.77,82.26 121.77,78.09 118.6,74.91 109.93,74.91 109.52,74.5 109.52,72.61 107.13,70.23 104.67,70.23 v2(101.8,73.1)
SM_RCOMP0: length 5.2
  BOTTOM w0.203: 166.48,80.72 166.4,80.8 165.8,80.8 164.33,82.26 UC1.G1
  BOTTOM w0.381: RC3.2 167.37,79.83 166.48,80.72
SM_RCOMP1: length 5.7
  BOTTOM w0.127: v1(164.39,78.29) 164.99,78.89 RC4.2
  BOTTOM w0.203: 165.44,79.91 165.44,80.29 163.47,82.25 UC1.H1
  BOTTOM w0.381: 165.44,79.91 RC4.2
SM_RCOMP2: length 5.7
  BOTTOM w0.203: 166.02,80.14 163.86,82.29 163.86,82.64 163.34,83.17 UC1.J2
  BOTTOM w0.381: RC5.2 166.35,79.81 166.02,80.14
SMB_CK2: length 7.6
  TOP w0.127: v1(181.79,125.26) R5284.1 180.39,124.77 v2(180.16,124.55) 180.16,124.54 180.16,122.89 Q7.1
  BOTTOM w0.127: v2(180.16,124.55) 180.19,124.58 180.19,126.05 180.68,126.54 UC3.8
SMB_DA2: length 6.8
  TOP w0.127: Q7.4 179.43,123.62 179.56,123.75 v2(179.56,124.5) 179.58,124.52 R5285.1 178.87,125.26 v1(178.33,124.71)
  BOTTOM w0.127: v2(179.56,124.5) 179.73,124.68 179.73,126.16 180.03,126.46 UC3.7
SMBALERT#: length 133
  TOP w0.127: R5236.1 91.94,14.79 v1(92.4,14.79) 92.42,14.79 92.69,14.53 v2(92.69,14.31)
  IN2 w0.127: v2(114.32,13.73) 114.85,13.19 117.71,13.19 119.13,14.62 125.12,14.62 125.72,15.22 127.88,15.22 128.03,15.07 131.53,15.07 131.91,15.44 133.4,15.44 133.78,15.07 134.58,15.07 135.68,13.97 142.76,13.97 144.06,15.27 149.64,15.27 150.78,16.41 152.73,16.41 153.99,17.67 167.82,17.67 169.29,19.13 180.86,19.13 184.03,15.97 187.1,15.97 187.73,15.34 188.95,15.34 189.96,16.35 191.95,16.35 192.13,16.17 193.53,16.17 194.1,15.6 197.35,15.6 197.48,15.74 203.04,15.74 v2(203.36,16.05)
  BOTTOM w0.127: v2(92.69,14.31) 92.69,14.32 93.09,14.72 94.45,14.72 96.63,12.54 98.42,12.54 98.65,12.32 98.65,9.77 100.06,8.36 113.19,8.36 114.94,10.11 114.94,10.52 114.56,10.91 114.56,13.49 v2(114.32,13.73) ; RH95.2 203.56,15.59 203.36,15.79 v2(203.36,16.05) 203.36,16.24 202.78,16.82 202.78,18.53 UH1.BE25
SMBUS_CLK: length 83.3
  TOP w0.127: v2(176.26,14.51) 176.49,14.51 176.71,14.73 176.71,18.22 176.2,18.73 176.2,24.18 173.84,26.54 171,26.54 170.58,26.96 170.58,27.59 174.18,31.19 v1(174.18,32.23) 174.18,33.73 173.08,34.83 173.08,35.33 v2(172.1,36.31) ; QC8.1 RC377.1 203.71,12.47 203.35,12.84 v2(203.35,13.51)
  IN2 w0.127: v2(203.35,13.51) 202.89,13.97 200.27,13.97 200.04,13.74 200.04,13.32 199.6,12.88 197.35,12.88 197.08,12.61 190.89,12.61 190.24,11.96 187.49,11.96 186.35,13.1 182.19,13.1 180.78,14.51 v2(176.26,14.51)
  IN3 w0.127: v2(173.19,44.12) 173.58,43.72 173.58,38.27 172.1,36.79 v2(172.1,36.31)
  BOTTOM w0.127: JDIMM2.253 167.53,37.17 168.08,36.62 171.79,36.62 v2(172.1,36.31) ; JDIMM1.253 169.03,49.34 170.93,47.43 170.93,45.43 172.24,44.12 v2(173.19,44.12)
SMBUS_DAT: length 85.5
  TOP w0.127: RC376.1 206.08,16.22 QC8.4 205.24,15.03 206.14,14.14 v2(206.14,13.72) ; v2(176.26,15.18) 176.26,18.07 175.72,18.6 175.72,24.05 173.66,26.11 170.82,26.11 170.15,26.78 170.15,27.77 173.75,31.37 173.75,33.52 172.64,34.63 172.64,34.87 v2(171.95,35.55)
  IN2 w0.127: v2(206.14,13.72) 205.42,14.44 198.01,14.44 197.2,13.63 197.2,13.34 196.9,13.04 190.71,13.04 190.06,12.39 187.69,12.39 186.54,13.54 182.37,13.54 180.82,15.09 176.35,15.09 v2(176.26,15.18)
  IN3 w0.127: v2(173.15,43.47) 173.15,38.45 171.65,36.95 171.65,35.85 v2(171.95,35.55)
  BOTTOM w0.127: v2(171.95,35.55) 170.94,35.55 170.68,35.29 170.68,34.75 171.18,34.25 171.18,33.54 170.67,33.03 169.58,33.03 167.78,31.23 JDIMM2.254 ; JDIMM1.254 169.27,42.98 169.98,43.68 171.77,43.68 171.99,43.47 v2(173.15,43.47)
SNB_1.8V: length 2.3
  BOTTOM w0.127: PR1802.2 v1(264.16,17.48)
  BOTTOM w0.508: PR1802.2 264.34,18.52 PC1806.1
SNB_1.35VSDGPUP: length 1
  BOTTOM w0.127: PCW6.1 v1(261.31,59.68)
SNB_2.5V: length 2.7
  TOP w0.127: v1(111.71,20.6) 111.71,20.5 111.42,20.2 111.08,20.2 110.53,19.66 PR2505.2
  TOP w0.508: PR2505.2 109.79,19.66 PC2503.1
SNB_CHG: length 4.4
  TOP w0.127: PRB21.2 256.66,8.65 v1(256.85,8.65)
  TOP w0.508: PRB21.2 254.27,6.26 PCB18.1
SNB_DDR: length 2.6
  TOP w0.127: PCM14.1 v1(95.97,30.69)
  TOP w0.508: PCM14.1 94.01,30.69 PRM3.2
SNB_GT: length 3.2
  TOP w0.127: v1(108.45,96.76) 108.67,96.54 PRG2.2
  TOP w0.508: PCG7.1 110.65,95.7 PRG2.2
SNB_INVPWR: length 2.6
  TOP w0.127: PRP6.1 v1(86.5,37.44)
  TOP w0.508: PRP6.1 86.5,35.83 86.12,35.45 PCP7.1
SNB_PH4: length 1.8
  TOP w0.127: PRZ89.2 v1(124.44,129.21)
SNDW2_CLK: length 3.9
  BOTTOM w0.102: 208.16,17.03 208.15,17.03 208.15,18 208.35,18.19 208.35,18.92 UH1.BD12
  BOTTOM w0.127: 208.16,17.03 208.16,15.93 TH121.1
SNDW2_DATA: length 4.5
  BOTTOM w0.102: 208.38,17.03 208.38,17.63 208.34,17.66 208.34,17.92 208.54,18.11 208.54,18.53 UH1.BE12
  BOTTOM w0.127: TH120.1 208.38,15.17 208.38,17.03
SNUB_1V05: length 3.9
  TOP w0.127: v1(230.67,25.73) PR1013.2
  TOP w0.508: PR1013.2 232.35,25.74 PC1003.1
SNUB_VCCIOP: length 3.1
  TOP w0.127: 181.97,110.85 181.48,110.35 v1(180.34,110.35)
  TOP w0.508: 181.97,110.85 181.53,111.29 181.42,111.29 PCH2.1
SPK_DET#: length 132.7
  TOP w0.127: v2(193.29,27.17) v3(191.41,27.17) 190.74,27.17 RH191.1
  IN2 w0.127: v2(278.29,38.95) 278.29,38.01 276.86,36.59 259.49,36.59 256.88,33.98 252.08,33.98 251.8,34.27 248.32,34.27 247.31,33.27 239.51,33.27 239.51,33.27 239.06,33.27 238.87,33.46 227.3,33.46 218.89,25.04 217.95,25.04 216.96,24.05 216.59,24.05 216.02,23.49 210.83,23.49 210.8,23.51 209.46,23.51 209.44,23.49 208.52,23.49 207.27,22.24 205.12,22.24 v2(205,22.36)
  IN3 w0.127: v2(205,22.36) 204.54,22.82 204.54,24.38 203.26,25.66 200.22,25.66 199.95,25.92 196.78,25.92 196.52,26.18 196.52,26.59 196.19,26.92 193.54,26.92 v2(193.29,27.17)
  BOTTOM w0.102: v2(193.29,27.17) 192.79,26.66 192.79,25.84 192.33,25.38 192.07,25.38 UH1.AM47
  BOTTOM w0.127: JSPK1.5 298.73,41.58 298.29,41.13 293.94,41.13 292.84,42.23 292.84,43.2 291.53,44.51 282.38,44.51 278.29,40.42 v2(278.29,38.95)
SPK_L+_CONN: length 4.3
  TOP w1.016: RA33.2 294.02,43.23 296.56,43.23 296.87,42.92 DA9.3
  vias: v2(299.48,44.68) v2(300.06,44.68) v3(299.76,45.22)
SPK_L-_CONN: length 4.3
  TOP w1.016: DA9.2 297.63,40.78 294.15,40.78 RA32.2
  vias: v2(300.9,44.68) v2(301.47,44.68) v3(300.94,43.27)
SPK_OUT_L+: length 27.5
  IN3 w1.016: 292.41,43.05 292.41,42.28 295.77,38.92 295.77,30.54 292.32,27.09 289.98,27.09 287.6,24.71 287.6,22.71 288.31,21.99
  vias: v2(290.38,21.38) v2(290.78,43.11) v2(290.94,21.38) v2(291.37,43.11) v3(290.33,42.67)
SPK_OUT_L-: length 25.9
  IN3 w1.016: 287.72,20.77 287.41,21.09 287.41,21.1 286.33,22.18 286.33,25.23 289.45,28.36 291.79,28.36 294.5,31.06 294.5,38.14 292.26,40.38
  vias: v2(290.12,20.75) v2(290.68,20.75) v2(290.78,41.15) v2(291.37,41.15) v3(290.31,40.75)
SPK_OUT_R+: length 41.9
  IN3 w1.016: 289.11,18.13 288.93,17.94 284.88,17.94 282.63,20.19 282.63,26.89 281.19,28.34 278.64,28.34 276.61,30.37 276.61,35.09 280.9,39.38 286.39,39.38 287.47,40.46 289.95,40.46
  vias: v2(289.84,19.1) v2(290.4,19.1) v2(290.72,39.36) v2(291.3,39.36) v3(290.76,38.78)
SPK_OUT_R-: length 34.8
  IN3 w1.016: 288.04,19.21 285.41,19.21 283.9,20.72 283.9,27.42 281.71,29.61 279.25,29.61 277.99,30.87 277.99,34.51 281.2,37.72 287.74,37.72 288.64,38.62
  vias: v2(289.04,39.36) v2(289.63,39.36) v2(289.97,19.99) v2(290.53,19.99) v3(290.58,36.98)
SPK_R+_CONN: length 9.4
  TOP w1.016: DA8.3 297.54,39.13 RA31.2 ; 302.61,43.76 302.61,42.89 v3(300.94,41.22) 299.52,39.8
  vias: v2(302.25,44.66) v2(302.86,44.66)
SPK_R-_CONN: length 12.6
  TOP w1.016: RA30.2 294.42,36.64 297.59,36.64 DA8.2 ; 299.43,37.45 v3(300.97,38.99) 304.04,42.06 304.04,43.72
  vias: v2(303.73,44.68) v2(304.32,44.68)
SPOK: length 321.9
  TOP w0.127: v2(188.19,13.64) 188.19,14.15 DH3.1 ; QS1.5 18.1,80.4 17.91,80.58 17.91,81.22 17.64,81.49 v1(15.93,81.49) 14.52,81.49 v2(14.2,81.17)
  IN2 w0.127: v2(253.38,33.02) 253.38,32.47 252.66,31.75 248.91,31.75 248.46,31.75 247.75,32.46 239.84,32.46 238.73,32.46 238.54,32.65 227.83,32.65 220.65,25.48 220.65,24.17 219.46,22.97 218.41,22.97 217.79,22.36 216.84,22.36 215.88,21.39 213.68,21.39 213.27,20.98 211.87,20.98 211.07,20.18 210.27,20.18 208.21,18.12 208.21,15.89 207.79,15.47 197.59,15.47 197.46,15.33 193.94,15.33 192.7,14.09 190.73,14.09 190.57,14.25 188.6,14.25 188.19,13.84 v2(188.19,13.64) 187.9,13.64 186.98,14.56 185.05,14.56 181.83,17.79 169.09,17.79 167.97,16.67 154.12,16.67 152.27,14.82 151.5,14.82 151.08,14.4 144.31,14.4 143.09,13.17 133.17,13.17 132.08,14.26 127.43,14.26 126.86,13.69 125.84,13.69 125.31,14.22 119.12,14.22 117.75,12.85 110.22,12.85 108.81,14.26 104.41,14.26 103.51,13.36 102.02,13.36 98.85,16.52 77.56,16.52 v2(76.85,15.81) 76.63,15.81 74.91,17.54 66.24,17.54 60.63,23.14 58.85,23.14 58.56,23.42 58.56,23.57 53.47,28.66 53.47,34.9 52.28,36.09 52.28,37.11 51.56,37.82 46.95,37.82 46.58,38.19 46.48,38.3 42.61,38.3 41.86,39.05 41.41,39.05 39.86,39.05 38.35,40.56 38.35,43.07 35.57,45.85 34.44,45.85 33.23,47.06 31.69,47.06 30.03,48.73 24.26,48.73 18.4,54.6 15.37,54.6 12.75,57.22 12.75,60.79 15.86,63.9 15.86,66.03 16.52,66.7 16.52,69.61 16.22,69.92 16.22,74.66 15.31,75.57 15.31,78.14 14.6,78.85 14.6,80.77 v2(14.2,81.17)
  BOTTOM w0.127: PR309.2 74.21,13.63 76.38,15.81 v2(76.85,15.81) ; v2(253.38,33.02) 252.95,33.46 PR314.2 252.65,33.46 252.65,34.19 PR303.2
SPOK#: length 1
  TOP w0.127: RS40.2 v1(17.33,77.79)
SPOK_3V: length 4.4
  BOTTOM w0.127: v1(253.59,32.5) 253.54,32.54 PR314.1
  BOTTOM w0.254: PR314.1 252.48,32.38 250.15,32.38 249.9,32.13 PU301.9
SPOK_5V: length 6.3
  BOTTOM w0.127: PU302.4 74.35,9.09 74.07,9.37 74.07,11.73 PR309.1 74.21,11.88 73.73,12.35 73.73,14.04 v1(74.22,14.54)
SRN_R: length 31.9
  TOP w0.254: v2(247.9,5.44) 247.9,5.56 247.11,6.35 245.98,6.35 v1(244.99,5.36) 244.33,4.7 240.98,4.7 240.32,5.36 PRB22.2
  IN3 w0.254: v2(268.26,7.2) 268.01,7.2 265.96,5.16 260.6,5.16 259.95,5.81 249.18,5.81 249.07,5.92 248.38,5.92 v2(247.9,5.44)
  BOTTOM w0.254: PRB08.3 268.59,6.87 v2(268.26,7.2)
SRP_R: length 30.5
  TOP w0.254: PRB20.2 241.64,5.09 244.09,5.09 245.75,6.75 247.35,6.75 v1(248.07,6.03) 248.58,5.52 v2(248.58,5.44)
  IN3 w0.254: v2(268.17,6.61) 266.26,4.71 260.31,4.71 259.69,5.32 248.7,5.32 v2(248.58,5.44)
  BOTTOM w0.254: PRB08.2 267.91,6.87 v2(268.17,6.61)
SSD1_IF: length 197.3
  TOP w0.127: v2(66.3,22.14) 66.15,22.29 65.48,22.29 65.28,22.09 65.28,21.39 64.32,20.43 64.32,19.4 61.55,16.63 60.52,16.63 56.85,12.96 54.69,12.96 53.88,13.76 53.31,13.76 52.88,14.19 46.31,14.19 45.2,13.08 43.07,13.08 39.29,9.29 34.68,9.29 34.19,8.81 22.76,8.81 v1(22.57,8.62) 21.62,8.62 21.42,8.41 21.42,7.81 21.63,7.6 22,7.6 R5219.1 22.15,6.63 Q79.1
  IN2 w0.127: v2(193.84,27.37) 193.5,27.71 192.82,27.71 192.38,27.27 189.25,27.27 188.33,26.35 187.33,26.35 186.77,25.79 186.28,25.79 185.49,26.58 185.49,27.04 184.5,28.04 183.15,28.04 180.6,25.49 180.02,25.49 175.82,21.29 168.39,21.29 167.68,20.57 161.54,20.57 160.21,21.91 152.98,21.91 151.44,20.37 147.02,20.37 145.8,19.15 142.85,19.15 141.08,17.38 135.54,17.38 134.43,18.49 127.83,18.49 126.87,17.52 124.47,17.52 123.85,18.14 122.76,18.14 121.99,17.37 120.85,17.37 120.43,16.95 118.31,16.95 118.02,16.66 115.2,16.66 114.62,17.25 112.62,17.25 110.01,19.87 87.44,19.87 84.47,22.83 73.22,22.83 72.4,23.65 67.77,23.65 66.3,22.19 v2(66.3,22.14)
  BOTTOM w0.127: UH1.AJ43 193.84,27.37 v2(193.84,27.37)
STRAP0: length 12.6
  BOTTOM w0.102: UG1.J2 212.84,76.2 212.84,75.31
  BOTTOM w0.127: RG124.1 219.43,68.03 RG122.2 218.8,68.41 218.39,68.82 218.39,69.88 v1(218.11,70.17) 217.18,71.09 217.18,72.09 216.42,72.85 215.3,72.85 212.84,75.31
STRAP1: length 31.9
  TOP w0.102: v2(213.55,80.2) 213.94,79.81 216.44,79.81 216.49,79.86 217.14,79.86 217.51,79.48 217.51,78.38 217.37,78.24 217.37,77.57 218.71,76.23 218.71,75.8 219.8,74.71 219.8,74.52
  TOP w0.127: v2(231.41,62.91) 231.3,63.02 v1(231.3,64.29) 231.3,66.49 224.17,73.62 220.45,73.62 219.8,74.28 219.8,74.52
  BOTTOM w0.109: v2(213.55,80.2) 213.18,80.57 UG1.J7
  BOTTOM w0.127: RG125.1 231.93,62.42 231.93,63.43 RG123.2 231.41,63.18 v2(231.41,62.91)
STRAP2: length 28.4
  TOP w0.102: 218.13,74.2 217.69,74.65 217.69,74.74 215.89,76.53 215.09,76.53 214.85,76.77 214.85,77.56 214.05,78.36 214.05,78.84 v2(213.54,79.35)
  TOP w0.127: 218.13,74.2 218.66,73.68 219.66,73.68 220.24,73.1 223.95,73.1 229.59,67.46 v1(229.59,64.04) 229.59,63.42 v2(229.48,63.31)
  BOTTOM w0.109: UG1.J6 213.18,79.79 213.54,79.43 v2(213.54,79.35)
  BOTTOM w0.127: RG126.1 230.1,62.42 230.1,63.55 RG118.2 229.74,63.56 v2(229.48,63.31)
STRAP3: length 28.1
  TOP w0.102: v2(213.58,78.55) 213.58,78.32 214.61,77.29 214.61,76.67 214.99,76.3 215.79,76.3 217.4,74.69 217.4,74.56 217.94,74.02
  TOP w0.127: 217.94,74.02 218.55,73.41 219.55,73.41 220.13,72.84 223.84,72.84 229.11,67.57 v2(229.11,65.09)
  BOTTOM w0.102: UG1.J5 v2(213.58,78.55)
  BOTTOM w0.127: RG127.1 228.43,62.98 RG133.2 229.06,63.45 229.06,63.61 229.59,64.14 229.59,64.62 229.13,65.09 v2(229.11,65.09) v1(229.11,65.67)
STRAP4: length 30.6
  TOP w0.102: 216.94,74.28 216.26,74.28 215.96,74.58 215.96,75.47 215.6,75.83 214.7,75.83 v2(213.57,76.95)
  TOP w0.127: 216.94,74.28 218.33,72.89 219.34,72.89 219.91,72.32 223.62,72.32 228.43,67.51 228.43,65.24 v2(228.27,65.09)
  BOTTOM w0.109: v2(213.57,76.95) UG1.J3
  BOTTOM w0.127: v2(228.27,65.09) 227.54,65.09 226.23,66.39 v1(225.77,66.39) 224.88,66.39 224.15,65.66 224.15,64.45 224.53,64.07 RG134.2 225.44,63.91 RG128.1
STRAP5: length 10.2
  BOTTOM w0.127: RG129.1 220.51,70.69 RG135.2 217.99,70.69 217.53,71.15 v1(217.53,71.34) 217.53,72.11 216.53,73.11 215.41,73.11 213.18,75.34 UG1.J1
SUS_STAT#: length 2.6
  BOTTOM w0.127: TH4950.1 196.19,15.91 196.19,18.24 UH1.BF38
SUSACK#: length 79
  TOP w0.127: UK1.15 142.84,9.1 142.5,9.44 142.5,10.29 145.18,12.97 v2(145.18,13.92)
  IN1 w0.127: v2(170.46,6.71) 170.22,6.95 168.32,6.95 168.15,6.77 168.15,4.93 168.44,4.63 177.28,4.63 178.3,5.65 178.3,6.69 178,6.99 178,7.33 178.62,7.96 180.9,7.96 181.94,9 185.19,9 185.49,9.3 193.28,9.3 195.85,11.87 v2(195.85,13.68)
  BOTTOM w0.127: v2(145.18,13.92) 146.21,12.89 150.41,12.89 151.65,14.13 163.43,14.13 165.03,12.52 167.5,12.52 170.29,9.73 170.29,6.88 v2(170.46,6.71) ; v2(195.85,13.68) 196.17,13.36 197.5,13.36 197.64,13.49 RH177.1
SUSACK#_R: length 4.4
  BOTTOM w0.102: UH1.BE35 197.35,18.97 197.35,17.59 197.52,17.41
  BOTTOM w0.127: 197.52,17.41 197.73,17.21 197.73,15.87 197.64,15.79 RH177.2
SUSCLK: length 132.2
  TOP w0.127: v2(306.87,10.26) 309.11,10.26 v1(309.16,10.31) 310,11.15 RWL5.2
  IN1 w0.127: v2(306.87,10.26) 306.87,8.43 304.59,6.14 301.1,6.14 299.86,4.89 283.43,4.89 275.07,13.25 274.57,13.25 273.68,14.15 265.41,14.15 264.69,13.43 253.6,13.43 253.05,13.98 248.27,13.98 247.63,13.34 243.9,13.34 243.12,12.56 236.87,12.56 236.42,13.01 231.07,13.01 230.29,12.23 228.57,12.23 227.99,12.81 225.52,12.81 224.74,12.03 222.18,12.03 221.75,11.6 210.18,11.6 204.69,17.09 204.69,17.36 203.77,18.28 194.14,18.28 192.77,19.65 v2(192.35,19.65)
  BOTTOM w0.127: UH1.BE45 192.35,19.07 v2(192.35,19.65)
SUSP#: length 434.8
  TOP w0.127: v2(271.49,44.79) 271.49,44.39 R5253.1 270.64,43.54 v3(270.64,40.38) 269.55,39.29 267.51,39.29 267.41,39.39 262.92,39.39 261.67,40.65 260.36,40.65 255.61,35.89 RC371.1 ; UC6.4 111.59,86.78 110.53,85.72 110.53,83.02 109.53,82.02 109.53,74.53 v2(110.19,73.88) ; v2(184.08,98.3) 182.2,100.18 182.2,101.62 182.75,102.17 182.75,103.99 182.45,104.29 182.45,106.46 181.37,107.54 RC373.1 ; PRP2.1 v2(78.29,32.79) ; RK27.1 132.64,14.25 133.08,13.81 133.66,13.81 v2(133.97,14.13) 134.47,14.62 UK1.116
  IN2 w0.127: v2(110.19,73.88) 109.39,74.67 104.28,74.67 100.71,71.11 98.94,67.75 97.72,65.34 95.22,61.94 95.2,61.91 94.63,61.13 94.63,58.65 87.59,51.62 87.59,46.93 85.12,44.46 83.24,44.46 80.89,42.1 78.55,42.1 78.35,41.9 77.22,41.9 76.75,41.43 76.75,34.32 v2(78.29,32.79) ; v2(95.3,20.57) 95.13,20.4 90.56,20.4 87.38,23.59 83.5,23.59 81.29,25.8 79.45,25.8 v2(79.09,26.16) ; v2(271.49,44.79) 271.49,45.48 270.36,46.61 266.17,46.61 264.9,45.34 264.9,43.66 263.58,42.35 260.57,42.35 260.3,42.62 259.49,42.62 258.53,43.58 249.6,43.58 249.29,43.89 240.01,43.89 239.29,44.61 239.29,47.46 236.23,50.52 231.79,50.52 230.45,49.17 224.38,49.17 221.42,52.13 197.36,52.13 197.31,52.18 196.3,52.18 192.91,55.57 192.65,55.84 192.65,70.14 193.52,71.01 193.52,73.54 191.19,75.87 191.19,76.65 v2(191.42,76.88)
  IN3 w0.127: v2(78.29,32.79) 78.29,32.51 77.55,31.77 77.55,28.53 78.8,27.28 78.8,26.45 v2(79.09,26.16) ; v2(95.3,20.57) 91.66,16.94 91.66,14.58 94.91,11.33 100.66,11.33 102.73,13.4 102.73,14.29 102.99,14.55 103.75,14.55 104.67,15.47 111.9,15.47 112.55,14.82 113.68,14.82 113.92,15.07 113.92,15.45 114.24,15.77 115.26,15.77 115.78,15.24 119.72,15.24 120.17,14.8 125.01,14.8 125.71,15.49 127.46,15.49 128.69,14.26 131.69,14.26 132.14,13.81 133.66,13.81 v2(133.97,14.13) ; v2(184.08,98.3) 185.08,97.29 185.08,91.89 189.67,87.31 v2(189.67,84.78) 191.71,84.78 192.95,83.54 192.95,82.84 192.66,82.55 190.97,82.55 190.74,82.32 190.74,77.92 191.42,77.25 v2(191.42,76.88)
  BOTTOM w0.127: v2(95.3,20.57) 95.3,21.8 95.09,22.02 94.65,22.02 94.43,22.24 PRM11.1 ; v2(189.67,84.78) 189.61,84.84 181.1,84.84 178.24,81.98 174.39,81.98 159.15,66.74 114.82,66.74 110.19,71.38 v2(110.19,73.88) ; v2(184.08,98.3) 184.05,98.32 PRH5.1
SW1_2PH: length 89.3
  TOP w0.127: v2(120.81,124.79) 121.29,125.27 v1(121.29,130.83) 121.29,132.99 123.98,135.68 158.07,135.68 158.93,136.55 162.34,136.55 162.77,136.12 164.24,136.12 v2(164.29,136.17)
  TOP w0.254: PRZ52.2 164.97,135.49 v2(164.29,136.17)
  IN3 w0.127: v2(120.81,124.79) 120.96,124.64 120.96,123.8 121.75,123.01 123.32,123.01 125.05,121.28 125.05,117.22 119.82,111.99 118.2,111.99 116.95,110.73 116.95,109.4 112.25,104.7 112.25,100.99 v2(112.13,100.87)
  BOTTOM w0.127: v2(112.13,100.87) 111,100.87 PLG1.2
  BOTTOM w0.254: PRZ66.2 165.12,135.99 164.48,135.99 v2(164.29,136.17)
SW1_4PH: length 29.2
  TOP w0.127: v2(167.06,119.81) 167.07,119.81 v1(167.56,119.33)
  TOP w0.254: PRZ48.1 167.72,120.47 v2(167.06,119.81)
  IN3 w0.152: v2(148.93,119.4) 148.93,118.31 149.81,117.42 164.67,117.42 v2(167.06,119.81)
  BOTTOM w0.254: v2(167.06,119.81) 167.72,120.47 PRZ59.1 ; PLZ1.2 152.1,120.42 151.85,120.17 149.69,120.17 v2(148.93,119.4)
SW2_4PH: length 28.8
  TOP w0.127: v2(165.94,119.91) v1(165.94,119.26)
  TOP w0.254: PRZ51.1 v2(165.94,119.91)
  IN3 w0.152: v2(147.78,119.4) 148.28,119.9 149.29,119.9 149.51,119.68 149.51,118.64 150.22,117.93 164.46,117.93 165.94,119.41 v2(165.94,119.91)
  BOTTOM w0.254: PLZ2.2 144.48,120.55 144.86,120.17 147.02,120.17 v2(147.78,119.4) ; PRZ67.1 v2(165.94,119.91)
SW3_4PH: length 44
  TOP w0.127: v2(164.17,119.91) v1(164.17,119.31)
  TOP w0.254: PRZ53.1 v2(164.17,119.91)
  IN3 w0.152: v2(133.43,119.66) 133.23,119.45 131.91,119.45 131.48,119.89 131.48,120.39 132.01,120.93 163.15,120.93 v2(164.17,119.91)
  BOTTOM w0.254: v2(133.43,119.66) 133.94,120.17 136.61,120.17 136.86,120.42 PLZ3.2 ; PRZ70.1 v2(164.17,119.91)
SW4_4PH: length 39.9
  TOP w0.127: v1(162.46,119.29) 163.09,119.91 v2(163.28,119.91)
  TOP w0.254: v2(163.28,119.91) 163.28,119.97 PRZ54.1
  IN3 w0.152: v2(132.16,120.17) 132.42,120.42 162.77,120.42 v2(163.28,119.91)
  BOTTOM w0.254: v2(163.28,119.91) 162.59,120.6 PRZ73.1 ; PLZ4.2 129.24,120.55 129.62,120.17 v2(132.16,120.17)
SW_1PH: length 3.4
  TOP w0.127: v2(158.93,119.72) v1(158.93,118.79)
  TOP w0.254: v2(158.93,119.72) PRZ3.2
  BOTTOM w0.254: PLA1.2 158.96,119.75 v2(158.93,119.72)
SWTRAP: length 1.8
  TOP w0.127: RK34.2 147.64,25.12 UK1.70
SYS_PEX_RST_MON#: length 33.1
  TOP w0.102: v2(208.58,81.04) 209,80.62 209,79.98 209.3,79.68 209.3,78.8 210.07,78.03 210.07,77.43 210.2,77.3 210.2,76.63 211.81,75.02 213.49,75.02 213.88,74.64 213.88,74.3 214.22,73.96
  TOP w0.127: 214.22,73.96 214.22,72.64 216.64,70.22 222.58,70.22 v1(222.74,70.06) 223.09,69.71 223.19,69.71 226.01,66.89 226.01,63.47 225.25,62.72 223.31,62.72 RG34.2
  BOTTOM w0.127: UG1.R8 v2(208.58,81.04)
SYS_PWROK: length 131.7
  TOP w0.127: v2(216.55,23.01) 216.81,23.27 216.81,23.48 CH72.2 217.87,23.51 217.87,21.25 218.87,20.25 222.74,20.25 224.27,18.72 224.27,16.02 v3(223.01,14.76) 222.49,14.24 v2(222.49,9.99) ; v2(146,21.08) 146.04,21.11 UK1.74 146.04,24.83 146.23,25.03 146.69,25.03 CK15.1
  BOTTOM w0.102: v2(216.55,23.01) 216.26,23.01 215.22,21.97 214.55,21.97 213.95,22.58 213.54,22.58 UH1.AU3
  BOTTOM w0.127: v2(146,21.08) 146.95,20.13 146.95,17.8 146.54,17.39 145.6,17.39 143.48,15.27 143.48,13.23 144.35,12.36 150.63,12.36 151.87,13.6 163.21,13.6 164.81,12 167.28,12 169.76,9.52 169.76,6.22 170.35,5.64 223.02,5.64 224.02,6.64 224.02,8.18 222.49,9.71 v2(222.49,9.99)
SYS_RESET#: length 5.1
  TOP w0.102: CLRP3.2 215.12,20.39 RH213.2 215.12,21.87 215.08,21.91 v2(215.08,22.35) 215.32,22.35 v1(215.6,22.63) CH71.2
  BOTTOM w0.102: v2(215.08,22.35) 214.57,22.35 214.08,22.83 UH1.AU2
SYSON: length 255.5
  TOP w0.127: RK23.1 CK9.1 ; CK9.1 137.25,25.23 137.64,24.84 UK1.95 ; CK9.1 137.97,25.59 138.45,26.07 v2(138.45,26.18) ; RC370.1 253.13,35.35 253.29,35.19 255.28,35.19 260.47,40.38 261.56,40.38 262.81,39.13 267.3,39.13 267.4,39.03 v3(272.41,39.03) 273.72,39.03 274.34,39.65 275.13,39.65 v2(275.6,39.18) ; PR2502.1 107.84,13.18 108.13,12.88 112.13,12.88 113.33,14.08 113.33,15.08 v2(113.5,15.26) ; v2(190.19,8.18) 186.55,8.18 184.84,9.89 177.91,9.89 175.32,12.49 173.71,12.49 172.97,13.23 172.81,13.23 165.48,20.57 165.48,22.32 164.69,23.11 164.69,23.63 164.38,23.94 164.38,26.48 164.29,26.57 164.29,26.57 v2(164.31,26.57)
  IN2 w0.127: v2(275.45,25.93) 274.6,25.08 274.6,24.38 274.45,24.23 274.45,20.14 276,18.6 276,17.58 275.19,16.77 263.51,16.77 263.23,16.48 258.19,16.48 257.84,16.84 237.66,16.84 236.76,15.93 235.71,15.93 235.28,16.36 227.05,16.36 224.28,13.59 224.28,13.13 221.6,10.46 220.15,10.46 219.28,9.59 219.28,9.04 218.72,8.48 218.04,8.48 217.74,8.78 211.32,8.78 211.05,8.52 206.06,8.52 205.69,8.89 202.19,8.89 201.82,8.52 199.14,8.52 198.4,7.78 190.59,7.78 v2(190.19,8.18)
  IN3 w0.127: v2(113.5,15.26) 113.5,15.47 114.07,16.04 115.91,16.04 116.09,16.22 121.78,16.22 122.34,15.66 124.51,15.66 124.91,16.06 127.34,16.06 128.87,14.53 132.79,14.53 133.33,15.07 134.5,15.07 135.01,15.58 135.01,17.6 134.27,18.34 134.27,23.81 135.98,25.52 138.2,25.52 138.45,25.77 v2(138.45,26.18) 138.45,26.25 138.91,26.71 139.12,26.71 141.09,24.74 149.71,24.74 151.34,26.37 160.88,26.37 161.33,25.92 162.72,25.92 162.96,25.68 163.32,25.68 164.04,26.4 164.27,26.4 164.29,26.43 164.29,26.57 v2(164.31,26.57)
  BOTTOM w0.127: v2(275.45,25.93) 275.45,28.78 276.16,29.49 276.16,38.62 v2(275.6,39.18)
TBT_CIO_PLUG_EVENT#: length 4.8
  BOTTOM w0.102: 189.79,27.33 189.79,27.21 190.22,26.79 191.7,26.79 191.76,26.73 UH1.AJ47
  BOTTOM w0.135: 189.79,27.33 189.79,28.24 188.98,29.06 188.97,29.06 TH4964.1
TBT_FORCE_PWR: length 6.7
  BOTTOM w0.102: 189.48,27.63 189.48,26.98 189.86,26.6 191.62,26.6 191.72,26.51 192.08,26.51 UH1.AJ46
  BOTTOM w0.135: 189.48,27.63 189.48,27.83 187.99,29.32 TH4963.1
TBTC_ADCIN1: length 2.7
  TOP w0.203: UU4.6 42.39,44.06 42.23,44.22 41.82,44.22 RU72.1
  TOP w0.508: RU72.1 RU66.2
TBTC_ADCIN2: length 7.1
  TOP w0.127: RU67.2 37.97,42.95 RU73.1 37.98,43.26 38.24,43.53 41.81,43.53 42.89,42.46 UU4.10
TBTC_I2C_IRQ2Z: length 111.6
  TOP w0.127: UU4.34 51.45,42.86 51.52,42.92 52.22,42.92 RU51.2 52.54,42.62 52.99,43.07 v2(54.87,43.07) ; UK1.89 140.04,21.99 v2(139.15,21.11)
  IN1 w0.127: v2(54.87,43.07) 55.03,43.23 56.24,43.23 57.68,44.68 65.35,44.68 68.12,41.91 68.12,31.41 70.62,28.91 85.41,28.91 87.24,27.09 90.03,27.09 91.37,25.74 94.36,25.74 96.15,27.54 98.27,27.54 99.97,25.84 101.93,25.84 v2(102.54,26.44)
  BOTTOM w0.127: v2(102.54,26.44) 102.86,26.77 106.02,26.77 107.59,25.21 110.1,25.21 111.14,24.17 114.29,24.17 115.94,22.51 117.35,22.51 118.32,22.51 118.54,22.51 118.54,22.51 119.82,22.51 121.42,22.51 122.57,22.51 124.48,22.51 125.36,21.63 127.57,21.63 128.31,22.37 132.68,22.37 133.84,21.2 135.37,21.2 139.05,21.2 v2(139.15,21.11)
TESTMODE: length 11.3
  BOTTOM w0.109: RG42.1 187.83,80.66 188.45,81.27 189.34,81.27 189.44,81.17 190.71,81.17 190.99,81.44 190.99,81.72 v2(191.38,82.12) 192,82.12 192.16,81.96 194.11,81.96 194.38,82.23 194.38,82.56 194.62,82.81 195.73,82.81 195.93,83.01 195.93,83.66 195.71,83.87 195.71,83.91 UG1.AK11
THERM_C_D+: length 374
  TOP w0.127: v2(97.21,22.97) 97.21,22.98 96.54,23.66 95.5,23.66 94.44,22.59 89.56,22.59 87.04,25.11 75.86,25.11 75.34,25.63 73.92,25.63 72.37,24.08 64.64,24.08 62.54,21.98 62.54,21.8 60.19,19.44 60.19,19.25 v1(59.55,18.62) 59.01,18.07 v2(58.68,18.07)
  IN3 w0.127: v2(58.68,18.07) 57.62,19.13 57.62,21.3 57.17,21.75 55.58,21.75 54.1,23.23 50.98,23.23 50.15,24.05 50.15,34.34 49.37,35.12 49.37,35.55 49.01,35.91 45.15,35.91 44.27,36.79 39.01,36.79 38.06,37.74 38.06,43.32 34.82,46.56 34.11,46.56 32.55,48.12 32.55,48.87 31.81,49.62 30,49.62 29.34,50.28 24.78,50.28 20.99,54.07 20.99,61.71 19.34,63.35 18.81,63.35 17.99,64.18 17.99,65.93 18.7,66.64 18.7,69.8 18.24,70.25 18.24,73.3 17.39,74.15 17.39,84.6 18.1,85.31 18.1,115.33 16.52,116.91 16.52,119.44 16.25,119.71 16.25,121.06 v2(16.16,121.15) ; v2(180.21,120.57) 180.21,118.55 188.08,110.68 188.08,103.93 187.31,103.16 187.31,94.35 188.95,92.72 188.95,88.79 193.49,84.25 193.49,82.01 192.13,80.66 191.76,80.66 191.28,80.18 191.28,78.15 192.17,77.26 192.17,76.83 192.96,76.04 192.96,71.43 v2(193.08,71.31)
  BOTTOM w0.127: QC12.2 14.88,121.01 QC12.1 15.65,121.66 v2(16.16,121.15) ; v2(193.08,71.31) 192.52,71.31 192.24,71.03 192.24,70.17 191.78,69.72 186.52,69.72 185.49,70.75 180.24,70.75 178.57,69.07 169.42,69.07 162.08,61.74 114.33,61.74 106.07,53.48 101.88,53.48 100.11,51.7 100.11,37.87 98.14,35.91 98.14,30.75 99.01,29.88 99.01,26.2 97.92,25.11 97.92,23.67 v2(97.21,22.97) ; UC3.2 180.03,121.77 CV273.1 180.21,121.27 v2(180.21,120.57)
THERM_C_D-: length 377.1
  TOP w0.127: v2(59.05,17.55) 59.63,18.14 60.43,18.14 v1(61.65,19.36) 62.8,20.51 62.8,21.88 64.74,23.82 72.48,23.82 74.03,25.37 75.23,25.37 75.75,24.85 86.93,24.85 89.45,22.32 94.54,22.32 95.61,23.39 96.2,23.39 v2(96.63,22.97)
  IN3 w0.127: v2(13.93,123.17) 14,123.1 14,121.35 15.53,119.82 15.76,119.82 16.25,119.33 16.25,116.76 17.81,115.2 17.81,85.4 17.12,84.71 17.12,74.04 17.98,73.18 17.98,70.14 18.43,69.69 18.43,66.75 17.72,66.05 17.72,64.07 18.7,63.09 19.23,63.09 20.68,61.64 20.68,54 24.67,50.01 29.23,50.01 29.89,49.35 31.69,49.35 32.29,48.76 32.29,48.01 34,46.29 34.71,46.29 37.79,43.21 37.79,37.63 38.9,36.52 44.16,36.52 45.04,35.64 48.9,35.64 49.1,35.44 49.1,35 49.88,34.23 49.88,23.94 50.87,22.96 53.99,22.96 55.47,21.48 57.05,21.48 57.35,21.19 57.35,18.62 58.41,17.55 v2(59.05,17.55) ; v2(192.73,70.82) 192.6,70.95 192.6,74.26 191.56,75.3 191.56,76.35 191.9,76.7 191.9,77.14 191.01,78.04 191.01,80.29 191.64,80.92 192.02,80.92 193.22,82.13 193.22,84.14 188.68,88.68 188.68,92.61 187.04,94.24 187.04,103.28 187.81,104.04 187.81,110.57 179.85,118.53 179.85,120.29 v2(179.6,120.55)
  BOTTOM w0.127: QC12.3 v2(13.93,123.17) ; v2(179.6,120.55) 179.54,120.6 179.54,121.35 CV273.2 179.38,121.51 UC3.3 ; v2(96.63,22.97) 96.63,22.67 96.78,22.51 97.35,22.51 98.18,23.34 98.18,25 99.28,26.1 99.28,29.98 98.41,30.86 98.41,35.8 100.37,37.76 100.37,51.6 101.99,53.22 106.18,53.22 114.44,61.48 162.19,61.48 169.52,68.81 178.68,68.81 180.35,70.48 185.38,70.48 186.42,69.45 191.89,69.45 192.73,70.29 192.73,70.82 v2(192.73,70.82)
TMDS_SNK_ML0_N: length 16.6
  BOTTOM w0.102: JHDMI1.9 11.1,110.8 11.24,110.8 11.38,110.94 11.38,116.09 11.86,116.56 12.83,116.56 13.29,116.1 13.29,113.33 14.66,111.97 14.82,111.97 14.87,112.02 DV2.9 DV2.1 16.49,112.02 16.52,111.99 17.14,111.99 RV45.2 17.5,112.06 17.74,112.06 RV15.2
TMDS_SNK_ML0_N_R: length 57.8
  IN1 w0.102: v2(24.98,68.56) 24.78,68.76 24.63,68.76 24.44,68.57 24.44,67.99 23.92,67.47 22.78,67.47 22.04,68.22 22.04,69.37 20.6,70.8 20.6,72.6 19.21,74 19.21,78.13 18.95,78.38 18.95,82.53 18.24,83.25 18.24,91.1 18.05,91.3 18.05,99.81 16.64,101.21 16.64,104.88 17.18,105.41 17.18,110.81 18.62,112.25 18.98,112.25 v2(19.13,112.4)
  BOTTOM w0.102: v2(19.13,112.4) 18.94,112.21 18.64,112.21 RV15.1 ; UV2.16 24.86,64.75 24.91,64.8 24.91,65.95 24.76,66.1 24.76,66.98 v5(25.12,67.34) 25.4,67.62 25.4,68.66 25.3,68.76 25.19,68.76 v2(24.98,68.56)
TMDS_SNK_ML0_P: length 16.6
  BOTTOM w0.102: RV13.2 17.75,111.75 17.49,111.75 RV45.1 17.28,111.69 16.6,111.69 16.43,111.52 DV2.2 DV2.8 14.92,111.52 14.78,111.66 14.53,111.66 12.99,113.2 12.99,113.46 12.99,113.46 12.99,115.98 12.71,116.26 11.99,116.26 11.69,115.96 11.69,110.82 11.37,110.5 11.1,110.5 JHDMI1.7
TMDS_SNK_ML0_P_R: length 57.8
  IN1 w0.102: v2(19.13,111.82) 19,111.95 18.75,111.95 17.48,110.68 17.48,105.29 16.95,104.75 16.95,101.34 18.35,99.93 18.35,91.43 18.55,91.23 18.55,83.37 19.26,82.66 19.26,78.51 19.51,78.26 19.51,74.13 20.91,72.73 20.91,70.93 22.34,69.49 22.34,68.34 22.91,67.77 23.79,67.77 24.13,68.11 24.13,68.69 24.51,69.07 24.78,69.07 v2(24.98,69.27)
  BOTTOM w0.102: v2(19.13,111.82) 19.04,111.91 18.44,111.91 18.37,111.84 18.37,111.71 RV13.1 ; v2(24.98,69.27) 25.19,69.07 25.43,69.07 25.71,68.79 25.71,67.49 25.07,66.85 25.07,66.22 25.22,66.07 v5(25.22,65.67) 25.22,64.82 25.26,64.78 UV2.17
TMDS_SNK_ML1_N: length 6.6
  BOTTOM w0.102: JHDMI1.6 12.62,109.33 13.03,109.33 13.71,108.65 14.84,108.65 14.84,108.64 14.92,108.72 DV3.9 DV3.1 16.43,108.72 16.46,108.69 17.14,108.69 RV44.2 17.5,108.76 17.93,108.76 RV12.2
TMDS_SNK_ML1_N_R: length 51.7
  IN1 w0.102: v2(19.83,108.94) 19.76,108.86 19.34,108.86 18.7,108.22 18.7,104.92 18.06,104.29 18.06,101.8 18.46,101.4 21.26,98.61 21.26,91.69 20.98,91.41 20.98,84.34 21.38,83.95 21.38,79.59 20.86,79.07 20.86,75.69 21.91,74.64 21.91,73.75 22.99,72.67 22.99,71.35 23.82,70.52 24.31,70.52 v2(24.51,70.32)
  BOTTOM w0.102: RV12.1 18.87,108.87 19.75,108.87 19.76,108.88 19.77,108.88 v2(19.83,108.94) ; v2(24.51,70.32) 24.72,70.52 25.06,70.52 26.11,69.47 v5(26.11,68.36) 26.11,64.78 26.06,64.73 UV2.19
TMDS_SNK_ML1_P: length 6.6
  BOTTOM w0.102: RV10.2 17.94,108.45 17.49,108.45 RV44.1 17.28,108.39 16.55,108.39 16.38,108.22 DV3.2 DV3.8 14.84,108.22 14.71,108.34 13.59,108.34 12.91,109.02 12.67,109.02 JHDMI1.4
TMDS_SNK_ML1_P_R: length 51.7
  IN1 w0.102: v2(19.83,108.36) 19.63,108.56 19.47,108.56 19,108.09 19,104.8 18.37,104.16 18.37,101.93 18.59,101.71 18.59,101.71 21.56,98.73 21.56,91.56 21.29,91.28 21.29,84.47 21.68,84.07 21.68,79.47 21.16,78.95 21.16,75.81 22.21,74.77 22.21,73.88 23.3,72.79 23.3,71.48 23.95,70.83 24.31,70.83 v2(24.51,71.03)
  BOTTOM w0.102: UV2.20 26.46,64.77 26.42,64.81 v5(26.42,66.93) 26.42,69.59 25.18,70.83 24.72,70.83 v2(24.51,71.03) ; RV10.1 18.64,108.34 18.64,108.49 18.71,108.56 19.63,108.56 v2(19.83,108.36)
TMDS_SNK_ML2_N: length 8.3
  BOTTOM w0.102: JHDMI1.3 11.12,107.78 11.33,107.78 12.14,106.96 13.57,106.96 13.74,107.13 14.83,107.13 14.92,107.22 DV3.7 DV3.4 16.43,107.22 16.55,107.11 17.22,107.11 RV43.2 17.48,107.11 17.94,107.11 RV9.2
TMDS_SNK_ML2_N_R: length 49.9
  IN1 w0.102: v2(20.3,107.23) 20.27,107.19 19.78,107.19 19.41,106.83 19.41,101.93 21.97,99.37 21.97,91.38 21.72,91.13 21.72,89.28 22.16,88.84 22.16,79.36 21.57,78.78 21.57,75.98 22.62,74.93 22.62,74.04 23.7,72.96 23.7,72.16 24.04,71.82 24.36,71.82 v2(24.5,71.68)
  BOTTOM w0.102: v2(24.5,71.68) 24.61,71.78 25.15,71.78 26.97,69.96 v5(26.97,69.42) 26.97,68.21 27.31,67.87 27.31,64.8 27.26,64.75 UV2.22 ; v2(20.3,107.23) 20.21,107.14 18.95,107.14 RV9.1
TMDS_SNK_ML2_P: length 8.3
  BOTTOM w0.102: JHDMI1.1 11.07,107.47 11.2,107.47 12.02,106.66 13.69,106.66 13.86,106.83 14.81,106.83 14.92,106.72 DV3.6 DV3.5 16.43,106.72 16.52,106.8 17.2,106.8 RV43.1 17.51,106.81 17.93,106.81 RV8.2
TMDS_SNK_ML2_P_R: length 49.9
  IN1 w0.102: v2(24.5,72.39) 24.5,72.26 24.37,72.13 24.17,72.13 24.01,72.29 24.01,73.09 22.92,74.17 22.92,75.06 21.87,76.11 21.87,78.65 22.46,79.24 22.46,88.96 22.02,89.4 22.02,91 22.28,91.25 22.28,99.49 19.72,102.05 19.72,106.7 19.91,106.89 20.06,106.89 v2(20.3,106.65)
  BOTTOM w0.102: v2(24.5,72.39) 24.5,72.13 24.55,72.09 25.27,72.09 v5(26.7,70.66) 27.27,70.08 27.27,68.33 27.62,67.99 27.62,64.8 27.66,64.76 UV2.23 ; RV8.1 19.01,106.83 20.12,106.83 v2(20.3,106.65)
TMDS_SNK_ML3_N: length 7.7
  BOTTOM w0.102: LM13.2 18.3,110.43 17.47,110.43 RV46.2 17.19,110.39 16.59,110.39 16.46,110.52 DV2.4 DV2.7 14.9,110.52 14.7,110.33 14.37,110.33 13.67,111.02 13.67,111.78 13.15,112.3 12.65,112.3 JHDMI1.12
TMDS_SNK_ML3_N_R: length 56.3
  IN1 w0.102: v2(21.71,110.61) 19.37,110.61 17.99,109.24 17.99,105.22 17.35,104.58 17.35,101.51 18.17,100.69 18.76,100.1 18.76,99.77 18.76,99.77 18.76,91.59 20.27,90.08 20.27,84.05 20.67,83.65 20.67,79.89 19.97,79.19 19.97,74.25 21.47,72.75 21.47,70.95 22.75,69.66 22.75,69.15 v2(23.23,68.67)
  BOTTOM w0.102: LM13.1 19.71,110.35 20.53,110.35 CV275.2 20.8,110.39 21.48,110.39 v2(21.71,110.61) ; v2(23.23,68.67) 23.6,69.03 23.95,69.03 24.05,68.93 24.05,65.73 23.76,65.43 23.76,65.04 23.66,64.94 UV2.13
TMDS_SNK_ML3_P: length 7.6
  BOTTOM w0.102: JHDMI1.10 12.65,112 13.02,112 13.37,111.66 13.37,110.89 14.24,110.02 DV2.6 DV2.5 16.48,110.02 16.54,110.08 17.24,110.08 RV46.1 17.51,110.12 18.19,110.12 LM13.3
TMDS_SNK_ML3_P_R: length 56.2
  IN1 w0.102: v2(23.63,69.48) 23.63,69.17 23.53,69.07 23.26,69.07 23.05,69.28 23.05,69.79 21.77,71.07 21.77,72.88 20.27,74.37 20.27,79.06 20.97,79.76 20.97,83.78 20.58,84.18 20.58,90.21 19.06,91.72 19.06,99.64 19.06,100.23 18.3,100.99 17.66,101.63 17.66,104.46 18.29,105.09 18.29,109.11 19.49,110.31 21.44,110.31 21.71,110.04 v2(21.71,109.9)
  BOTTOM w0.102: UV2.14 24.06,65.31 24.36,65.6 24.36,69.1 24.12,69.34 23.77,69.34 v2(23.63,69.48) ; v2(21.71,109.9) 21.53,110.08 20.85,110.08 CV275.1 20.56,110.04 19.66,110.04 LM13.4
TON_DDR: length 2.1
  BOTTOM w0.203: PUM1.9 91.25,24.38 v1(91.19,24.32) 90.87,24 PRM7.2
TP_CLK: length 83.9
  TOP w0.127: v2(86.4,8.75) 86.04,8.4 C5257.1 85.79,8.89 86.24,9.35 86.24,10.82 86.07,10.99 85.95,10.99 DM5.1 85.75,11.68 86.3,11.68 86.64,12.02 v2(86.64,12.24) ; RK12.1 140.84,25.28 UK1.87 140.84,21.52 v2(140.42,21.11)
  IN2 w0.127: v2(115.49,18.62) 115.76,18.35 116.81,18.35 117.82,19.36 121.22,19.36 121.35,19.49 123.23,19.49 124.04,20.3 130.19,20.3 130.43,20.54 131.79,20.54 132.77,19.57 135.97,19.57 136.78,20.37 139.68,20.37 v2(140.42,21.11)
  BOTTOM w0.127: v2(86.64,12.24) 87.2,12.8 JTP1.6 ; v2(86.4,8.75) 85.97,8.33 85.97,7.65 86.17,7.46 116,7.46 117.4,8.85 117.4,11.28 115.48,13.19 115.48,15.93 114.55,16.86 114.55,17.27 115.49,18.21 v2(115.49,18.62)
TP_DATA: length 86.8
  TOP w0.127: v2(84.81,5.91) 84.33,6.39 84.33,8.16 84.58,8.41 C5256.1 85.51,9.06 DM5.3 84.6,9.54 v3(84.16,9.98) 84.16,11.19 85.22,12.24 v2(85.37,12.24) ; v2(139.78,21.11) 140.44,21.76 UK1.88 140.44,24.87 RK13.1
  IN2 w0.127: v2(116.06,18.79) 116.06,18.79 116.9,19.63 119.36,19.63 120.02,20.29 123.65,20.29 123.93,20.57 130.08,20.57 130.32,20.81 131.91,20.81 132.88,19.84 135.86,19.84 136.67,20.64 139.57,20.64 139.78,20.85 v2(139.78,21.11)
  BOTTOM w0.127: v2(116.06,18.79) 116.06,18.41 114.94,17.29 114.94,16.84 115.74,16.04 115.74,13.3 117.66,11.39 117.66,8.74 116.11,7.19 87.07,7.19 85.78,5.91 v2(84.81,5.91) ; JTP1.7 86.2,13.07 v2(85.37,12.24)
TP_EN: length 52.6
  TOP w0.127: UK1.1 137.24,6.99 136.83,6.58 136.28,6.58 135.19,5.5 125.89,5.5 125.89,5.5 101.77,5.5 98.2,9.07 98.2,10.03 v3(97.82,10.41) 96.17,12.06 DT1.3 95.33,13.28 95.12,13.28 95,13.4 93.78,13.4 v2(93.21,13.97)
  BOTTOM w0.127: JTP1.1 92.2,12.99 92.34,12.85 92.8,12.85 93.21,13.26 v2(93.21,13.97)
TP_INT#_EC: length 62.2
  TOP w0.127: UK1.125 134.67,11.02 134.23,10.58 134.23,9.9 134.04,9.71 131.98,9.71 131.53,9.26 131.53,9.02 131.06,8.55 129.51,8.55 129.19,8.23 v2(129.19,6.83) ; v2(93.73,14.29) 93.73,14.82 93.27,15.28 90.95,15.28 90.52,14.84 R5808.1 ; v2(126.06,6.79) 126.06,7.81 v3(124.12,9.75) 122.58,11.3 117.05,11.3 114.94,13.41 v2(114.94,13.73)
  BOTTOM w0.127: v2(114.94,13.73) 114.82,13.61 114.82,11.01 115.21,10.63 115.21,10.01 113.3,8.1 99.95,8.1 96.64,11.41 96.64,11.83 94.81,13.66 94.02,13.66 93.73,13.96 v2(93.73,14.29) ; v2(126.06,6.79) 126.06,6.45 126.28,6.23 129,6.23 129.19,6.42 v2(129.19,6.83)
TP_SMBCLK: length 149.8
  TOP w0.127: QC7.6 202.46,8.66 201.96,8.16 RC81.1 201.95,7.5 201.95,6.66 v2(201.96,6.65) 201.54,6.23 v3(201.46,6.23) 201.16,5.93 175.23,5.93 174.58,6.58 173.7,6.58 173.43,6.85 172.99,6.85 171.84,8 171.47,8 167.61,11.86 164.6,11.86 164.47,11.99 164.47,12.54 164.35,12.66 164.09,12.66 163.97,12.54 163.97,11.99 163.84,11.86 163.58,11.86 163.46,11.99 163.46,12.54 163.33,12.66 163.08,12.66 162.95,12.54 162.95,11.99 162.82,11.86 162.57,11.86 162.44,11.99 162.44,12.54 162.31,12.66 162.06,12.66 161.93,12.54 161.93,11.99 161.81,11.86 161.55,11.86 161.43,11.99 161.43,12.54 161.3,12.66 161.04,12.66 160.92,12.54 160.92,11.99 160.79,11.86 160.54,11.86 160.41,11.99 160.41,12.54 160.28,12.66 160.03,12.66 159.9,12.54 159.9,11.99 159.77,11.86 155.94,11.86 150.74,6.66 v2(150.74,5.1) ; v2(89.38,12.22) 88.6,11.44 DM5.6 87.47,11.44 87.09,11.06 87.09,8.63 C5258.1 86.76,8.37 v2(86.55,8.16) ; v2(97.77,9.38) 97.77,8.89 101.59,5.06 126.78,5.06 135.37,5.06 136.45,6.15 137.09,6.15 137.5,5.75 v2(137.5,5.68) ; RH261.2 207.01,7.61 v2(206.52,7.61)
  IN1 w0.127: v2(206.52,7.61) 206.52,6.91 206.13,6.51 202.1,6.51 v2(201.96,6.65)
  IN2 w0.127: v2(137.5,5.68) 138.25,6.43 149.82,6.43 150.74,5.51 v2(150.74,5.1)
  BOTTOM w0.127: v2(86.55,8.16) 86.82,7.89 96.97,7.89 97.77,8.69 v2(97.77,9.38) ; v2(89.38,12.22) 89.2,12.4 JTP1.4
TP_SMBDATA: length 151.7
  TOP w0.127: v2(151.33,5.11) 151.33,5.83 154.32,8.82 154.32,9.47 156.29,11.43 167.44,11.43 171.3,7.57 171.66,7.57 172.82,6.42 173.25,6.42 173.52,6.15 174.4,6.15 175.05,5.5 201.78,5.5 RC82.1 203.26,5.57 209.42,5.57 RH262.2 210.89,6.37 211.24,6.73 211.24,7.54 210.9,7.89 210.9,9.41 210.02,10.28 205,10.28 QC7.3 ; v2(90.6,12.23) 90.84,11.99 90.84,10.58 89.8,9.54 DM5.4 87.73,9.54 87.53,9.34 87.53,9.12 C5259.1 v2(89.38,8.38) ; v2(96.69,9.01) v3(98.83,6.86) 101.06,4.63 135.73,4.63 136.82,5.72 v2(136.91,5.72)
  IN2 w0.127: v2(136.91,5.72) 138.06,6.86 150,6.86 151.33,5.54 v2(151.33,5.11)
  BOTTOM w0.127: v2(89.38,8.38) 89.5,8.5 96.18,8.5 v2(96.69,9.01) ; v2(90.6,12.23) 90.2,12.63 JTP1.3
TPM_GPIO: length 2.9
  TOP w0.127: v1(119.61,17.31) 119.61,16.99 RTT10.1
  TOP w0.135: RTT10.1 119.27,16.16 UT1.6
TPM_IRQ#: length 105.6
  TOP w0.127: v2(172.55,28.67) v1(173.26,28.67) 173.6,28.67 178.78,23.49 v2(179.15,23.49) ; v2(208.99,21.44) 209.11,21.55 210.73,21.55 211.52,22.34 212.59,22.34 212.68,22.25 RH178.2 ; R5202.1 129.41,15.14 v2(130.3,16.03)
  IN2 w0.127: v2(208.99,21.44) 208.99,21.43 207.1,21.43 206.47,20.8 204.99,20.8 204.03,21.76 204.03,22.2 203.54,22.69 203.54,23.42 201.75,25.21 198.48,25.21 198.1,24.84 195.47,24.84 194.88,25.44 194.34,25.44 194.16,25.26 192.18,25.26 190.7,26.73 189.48,26.73 188.56,25.81 187.56,25.81 186.99,25.25 186.06,25.25 184.95,26.35 184.95,26.82 184.27,27.5 183.37,27.5 179.36,23.49 v2(179.15,23.49)
  IN3 w0.127: v2(172.55,28.67) 169.48,28.67 169.41,28.6 150.9,28.6 150.35,28.05 150.06,28.05 149.2,27.2 141.34,27.2 140.9,27.63 135.45,27.63 134.45,26.63 134.45,25.47 132.93,23.96 132.93,23.25 131.48,21.8 131.48,20.32 132.48,19.32 132.48,18 131.08,16.61 130.88,16.61 v2(130.3,16.03)
  BOTTOM w0.127: v2(208.99,21.44) 208.88,21.55 208.57,21.55 UH1.AW13
