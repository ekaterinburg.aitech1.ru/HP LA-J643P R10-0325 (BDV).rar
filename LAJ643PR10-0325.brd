# Allegro board LAJ643PR10-0325.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_M0_D57: length 50.8
  IN3 w0.127: v2(165.87,44.98) 166.2,44.98 166.32,45.11 166.32,46.22 167.06,46.95 167.06,48.9 167.23,49.07 167.6,49.07 168.79,50.26 168.79,50.95 170.02,52.17 170.02,52.63 171.09,53.7 171.09,61.18 170.96,61.31 170.67,61.31 170.54,61.44 170.54,61.69 170.67,61.82 170.96,61.82 171.09,61.94 171.09,62.2 170.96,62.33 170.67,62.33 170.54,62.45 170.54,71.46 169.69,72.31 169.69,75.58 165.98,79.28 165.98,79.87 165.58,80.28 164.83,81.03 164.2,81.03 v2(164.03,80.86)
  BOTTOM w0.127: v2(164.03,80.86) 161.74,80.86 160.7,81.9 UC1.M1 ; JDIMM1.236 164.77,43.89 v2(165.87,44.98)
DDR_M0_D58: length 55.6
  IN3 w0.127: v2(169.06,43.93) 169.06,44.01 169.83,44.78 170.15,44.78 170.25,44.68 170.25,43.63 170.42,43.46 170.68,43.46 170.81,43.58 170.81,46.64 171.07,46.89 171.26,47.09 171.26,47.98 174.07,50.79 174.07,72.48 172.62,73.93 172.62,77.42 165.31,84.73 v2(161.88,84.73)
  BOTTOM w0.089: v2(161.88,84.73) 161.86,84.73 UC1.L4
  BOTTOM w0.127: JDIMM1.250 168.27,43 169.06,43.79 v2(169.06,43.93)
DDR_M0_D59: length 52.6
  IN3 w0.076: v2(161.88,83.41) 161.97,83.5 165.46,83.5 165.62,83.34
  IN3 w0.127: v2(168.94,46.52) 169.54,46.52 170.5,47.48 170.5,47.62 170.23,47.89 170.23,48.12 171.35,49.24 171.35,49.42 171.18,49.59 171.18,50.26 171.56,50.65 172.78,50.65 173.26,51.13 173.26,51.62 172.99,51.89 172.99,52.22 173.26,52.49 173.26,71.86 173.17,71.95 172.82,71.95 172.71,72.06 172.71,72.36 171.86,73.21 171.86,77.1 165.62,83.33 165.62,83.34
  BOTTOM w0.076: v2(161.88,83.41) 161.69,83.41 UC1.L2
  BOTTOM w0.127: JDIMM1.245 167.02,48.44 v2(168.94,46.52)
DDR_M0_D60: length 56.7
  IN3 w0.076: 167.32,76.33 159.87,83.78 159.87,84.35 v2(160.29,84.77)
  IN3 w0.127: v2(165.87,48.92) 165.56,48.92 165.45,48.8 165.45,43.92 165.28,43.74 164.97,43.74 164.79,43.92 164.79,44.52 164.86,44.59 164.86,48.93 167.15,51.22 167.15,52.17 168.94,53.96 168.94,58.28 169.07,58.4 169.27,58.4 169.4,58.53 169.4,58.78 169.27,58.91 169.07,58.91 168.94,59.04 168.94,59.29 169.07,59.42 169.27,59.42 169.4,59.55 169.4,59.8 169.27,59.93 169.07,59.93 168.94,60.05 168.94,60.28 169.4,60.74 169.4,70.98 168.54,71.84 168.54,75.11 167.32,76.33
  BOTTOM w0.089: v2(160.29,84.77) UC1.M5
  BOTTOM w0.127: v2(165.87,48.92) 165.46,48.92 165.02,49.35 JDIMM1.237
DDR_M0_D61: length 52.7
  IN3 w0.127: v2(164.75,79.98) 164.75,79.44 168.92,75.26 168.92,72 169.78,71.14 169.78,58.86 169.9,58.73 170.2,58.73 170.33,58.61 170.33,58.14 170.23,58.04 169.51,58.04 169.34,57.88 169.34,57.53 169.47,57.4 170.2,57.4 170.33,57.28 170.33,57.02 170.2,56.89 169.47,56.89 169.34,56.77 169.34,56.51 169.47,56.39 170.2,56.39 170.33,56.26 170.33,56.01 170.2,55.88 169.47,55.88 169.34,55.75 169.34,55.48 169.46,55.36 170.24,55.36 170.33,55.27 170.33,54.92 170.2,54.79 169.93,54.79 169.81,54.67 169.81,53.58 169.6,53.37 168.95,53.37 167.99,52.4 167.99,51.52 166.3,49.83 166.3,47.66 166.17,47.53 165.98,47.53 v2(165.87,47.65)
  BOTTOM w0.127: v2(165.87,47.65) 164.02,49.49 JDIMM1.233 ; UC1.M2 160.3,82.77 160.3,81.82 162.14,79.98 v2(164.75,79.98)
DDR_M0_D62: length 56.4
  IN3 w0.076: v2(161.87,85.48) 161.05,84.66 161.05,83.2 161.82,82.43 162.23,82.43 162.34,82.54 162.34,83.03 162.48,83.17 165.11,83.17
  IN3 w0.127: v2(168.95,47.75) 169.16,47.55 169.6,47.55 169.68,47.63 169.68,48.36 170.73,49.42 170.73,50.35 171.23,50.85 171.69,51.31 171.87,51.31 172.1,51.08 172.32,51.08 172.53,51.3 172.53,51.4 172.19,51.75 172.19,51.96 172.88,52.65 172.88,67.18 172.75,67.31 172.46,67.31 172.33,67.43 172.33,67.69 172.46,67.81 172.75,67.81 172.88,67.94 172.88,68.19 172.75,68.32 172.46,68.32 172.33,68.45 172.33,68.7 172.46,68.83 172.75,68.83 172.88,68.96 172.88,69.21 172.75,69.34 172.46,69.34 172.33,69.46 172.33,69.72 172.46,69.85 172.75,69.85 172.88,69.97 172.88,70.23 172.75,70.35 172.46,70.35 172.33,70.48 172.33,70.73 172.46,70.86 172.75,70.86 172.88,70.99 172.88,71.24 172.75,71.37 172.46,71.37 172.33,71.5 172.33,72.2 171.48,73.05 171.48,76.94 165.25,83.17 165.11,83.17
  BOTTOM w0.089: UC1.L5 v2(161.87,85.48)
  BOTTOM w0.127: v2(168.95,47.75) 168.91,47.75 168.03,48.64 JDIMM1.249
DDR_M0_D63: length 53.6
  IN3 w0.076: 165.73,83.77 161.74,83.77 161.53,83.56 161.53,83.24 v2(161.94,82.82)
  IN3 w0.127: v2(168.95,45.29) 169.14,45.48 169.14,45.51 170.88,47.25 170.88,48.17 173.69,50.98 173.69,72.32 172.24,73.77 172.24,77.26 165.73,83.77
  BOTTOM w0.076: v2(161.94,82.82) 161.74,82.82 UC1.L1
  BOTTOM w0.127: JDIMM1.246 167.28,42.83 167.57,43.13 167.68,43.13 168.65,44.09 168.65,44.99 v2(168.95,45.29)
DDR_M0_DQS0: length 60.1
  IN3 w0.127: v2(105.62,47.01) 105.47,47.16 105.26,47.16 104.73,47.69 104.73,49.38 105.05,49.7 105.05,63.95 107.17,66.07 107.17,66.32 106.99,66.49 106.99,66.89 107.42,67.32 107.82,67.32 108.03,67.11 108.21,67.11 108.48,67.38 108.48,67.56 108.27,67.77 108.27,68.17 108.7,68.6 109.1,68.6 109.29,68.4 109.44,68.4 109.75,68.71 109.75,69.65 113.06,72.96 113.06,74.98 114.51,76.44 118.54,76.44 120.57,78.47 120.57,81.9 121.09,82.42 122.39,82.42 123.39,83.43 v2(124.63,83.43)
  BOTTOM w0.076: v2(124.63,83.43) 124.63,83.29 124.76,83.16 124.97,83.16 125.65,83.84 125.65,84.12 126.55,85.02 127.51,85.02 127.72,85.22 128.11,85.22 128.44,84.89 UC1.BP5
  BOTTOM w0.127: v2(105.62,47.01) 105.75,47.15 106.07,47.15 107.02,48.1 JDIMM1.13
DDR_M0_DQS1: length 57.8
  IN3 w0.127: v2(112.21,45.16) 112.21,44.96 112.11,44.85 111.57,44.85 111.44,44.98 111.44,62.78 113.15,64.49 113.33,64.49 113.87,63.95 114.27,63.95 114.7,64.38 114.7,64.78 114.16,65.32 114.16,65.5 114.43,65.77 114.61,65.77 115.03,65.34 115.48,65.34 115.85,65.72 115.85,66.17 115.43,66.59 115.43,66.75 123.71,75.02 123.71,76.54 124.16,76.99 124.16,78.33 126.23,80.4 126.41,80.4 126.55,80.26 126.55,79.99 v2(126.54,79.98)
  BOTTOM w0.076: UC1.BK3 130.99,83.49 130.99,83.04 130.58,82.63 130.58,82.11 129.83,81.35 129.55,81.35 129.07,80.87 129.07,80.79 129.06,80.78
  BOTTOM w0.127: v2(112.21,45.16) 112.45,44.92 112.77,44.92 113.06,44.63 113.06,43.66 112.27,42.87 JDIMM1.34 ; 129.06,80.78 128.87,80.59 128.16,80.59 127.41,79.84 126.99,79.84 126.85,79.98 v2(126.54,79.98)
DDR_M0_DQS2: length 54.9
  IN3 w0.127: v2(128.21,78.39) 128.42,78.39 128.76,78.05 128.76,76.97 128.32,76.52 128.32,71.99 117.3,60.97 117.3,48.15 116.47,47.33 116.47,46.17 116.83,45.81 117.33,45.81 117.47,45.66 v2(117.47,45.49)
  BOTTOM w0.076: UC1.BF3 133.66,83.7 133.66,83.49 133.5,83.32 133.5,81.97 133.57,81.89 133.57,80.47 133.08,79.98 133.08,79.9 133.07,79.89
  BOTTOM w0.127: 133.07,79.89 131.26,78.08 128.74,78.08 128.42,78.39 v2(128.21,78.39) ; v2(117.47,45.49) 117.47,45.8 117.64,45.97 117.94,45.97 118.45,46.49 118.45,47.54 117.44,48.54 117.44,49.26 117.53,49.34 JDIMM1.55
DDR_M0_DQS3: length 50.8
  IN3 w0.127: v2(124.32,45.08) 124.07,45.33 123.52,45.33 123.15,45.71 123.15,55.35 123.93,56.13 123.93,61.04 133.08,70.19 133.08,74.16 134.94,76.03 134.94,80.12 135.53,80.71 136.03,80.71 v2(136.24,80.92)
  BOTTOM w0.076: v2(136.24,80.92) 136.01,80.69 135.88,80.69 135.77,80.8 135.77,81.57 136.01,81.81 136.01,83.53 UC1.BC3
  BOTTOM w0.127: JDIMM1.76 122.77,42.91 122.68,43 122.68,44.51 123.54,45.36 124.04,45.36 v2(124.32,45.08)
DDR_M0_DQS4: length 49.2
  IN3 w0.127: v2(156.21,73.3) 156.21,73.2 156.35,73.07 156.61,73.07 157.29,72.39 157.29,59.22 152.08,54.01 152.08,49.44 151.39,48.75 151.39,46.57 151.58,46.38 151.78,46.38 151.91,46.51 v2(151.91,47.02)
  BOTTOM w0.076: UC1.AB3 153.24,83.9 153.52,83.9 153.58,83.84 153.58,83.51 153.45,83.38 153.45,81.1 154.45,80.1 154.45,77.59 154.91,77.13 154.91,76.78 154.85,76.73 154.85,76.71
  BOTTOM w0.127: v2(151.91,47.02) 151.91,46.65 151.77,46.51 151.62,46.51 151.11,47.03 151.11,48.44 150.45,49.1 150.45,49.3 150.52,49.38 JDIMM1.179 ; 154.85,76.71 154.85,75.95 156.71,74.09 156.71,73.24 156.54,73.07 156.33,73.07 156.21,73.19 v2(156.21,73.3)
DDR_M0_DQS5: length 49.6
  IN3 w0.127: v2(156.79,44.3) 156.79,44.65 156.97,44.84 157.21,44.84 157.49,45.12 157.49,46.44 156.97,46.96 156.97,49.83 157.5,50.36 157.5,52.42 161.8,56.72 161.8,72.5 160.95,73.35 160.95,74.77 158.05,77.66 157.58,77.66 157.36,77.44 v2(157.21,77.44)
  BOTTOM w0.076: UC1.V3 155.96,83.53 155.96,81.37 156.29,81.04 156.29,80.96 156.31,80.95
  BOTTOM w0.127: 156.31,80.95 157.68,79.58 157.68,77.81 157.31,77.44 v2(157.21,77.44) ; JDIMM1.200 155.77,42.89 155.68,42.98 155.68,43.35 156.32,43.99 156.32,44.57 156.45,44.7 156.66,44.7 156.79,44.57 v2(156.79,44.3)
DDR_M0_DQS6: length 50.4
  IN3 w0.076: 166.26,73.08 166.18,73.16 166.18,74.05 165.19,75.04 165.19,76.08 161.82,79.45 161.31,79.45 160.47,80.29 160.47,80.45 160.58,80.56 160.75,80.56 v2(160.84,80.46)
  IN3 w0.127: v2(163.68,46.68) 163.68,46.6 163.53,46.45 163,46.45 162.88,46.56 162.88,50.46 163.14,50.71 163.14,51.75 166.26,54.87 166.26,73.08
  BOTTOM w0.076: v2(160.84,80.46) 160.78,80.52 160.49,80.52 160.35,80.39 160.06,80.39 159.42,81.03 159.42,81.24 158.47,82.19 158.47,83.35 158.65,83.53 158.65,83.6 158.65,83.74 158.57,83.82 UC1.R3
  BOTTOM w0.127: v2(163.68,46.68) 163.48,46.48 162.76,46.48 161.75,47.48 161.75,48.38 160.98,49.16 160.98,49.35 161.02,49.4 JDIMM1.221
DDR_M0_DQS7: length 54.3
  IN3 w0.127: v2(167.9,44.53) 167.9,44.58 167.69,44.78 167.32,44.78 167.09,45.01 167.09,45.9 167.92,46.74 167.92,48.32 168.84,49.23 169.09,49.23 169.55,49.7 169.55,50.63 170.82,51.89 170.82,52.35 171.85,53.39 171.85,62.51 171.3,63.06 171.3,63.98 171.55,64.24 171.75,64.24 171.85,64.34 171.85,64.77 171.75,64.87 171.56,64.87 171.3,65.12 171.3,71.77 170.45,72.63 170.45,76.51 164.72,82.24 163.38,82.24 163.24,82.11 163.24,81.84 v2(163.3,81.78)
  BOTTOM w0.076: v2(163.3,81.78) 162.95,81.78 162.83,81.66 161.48,81.66 160.99,82.15 160.99,83.53 UC1.M3
  BOTTOM w0.127: JDIMM1.242 166.28,42.88 166.19,42.96 166.19,43.33 166.71,43.84 166.71,44.22 167.31,44.83 167.6,44.83 v2(167.9,44.53)
DDR_M0_DQS#0: length 60.1
  IN3 w0.127: v2(105.62,47.9) 105.62,47.51 105.54,47.43 105.37,47.43 105,47.8 105,49.27 105.31,49.59 105.31,63.84 107.43,65.96 107.43,66.43 107.26,66.6 107.26,66.78 107.53,67.05 107.71,67.05 107.92,66.85 108.32,66.85 108.74,67.27 108.74,67.67 108.54,67.88 108.54,68.06 108.81,68.33 108.99,68.33 109.18,68.13 109.55,68.13 110.02,68.6 110.02,69.54 113.32,72.85 113.32,74.87 114.62,76.17 118.65,76.17 120.83,78.36 120.83,81.79 121.2,82.16 122.5,82.16 123.5,83.16 124.12,83.16 124.21,83.08 v2(124.21,82.83)
  BOTTOM w0.076: v2(124.21,82.83) 124.21,82.9 124.38,83.07 124.62,83.07 124.69,83 125.04,83 125.81,83.77 125.81,84.05 126.61,84.85 127.58,84.85 127.78,85.06 128.04,85.06 128.27,84.82 128.27,84.65 128.2,84.57 128.04,84.57 UC1.BR5
  BOTTOM w0.127: JDIMM1.11 106.53,49.41 106.75,49.19 106.75,48.22 105.95,47.43 105.71,47.43 105.62,47.52 v2(105.62,47.9)
DDR_M0_DQS#1: length 57.7
  IN3 w0.127: v2(112.24,44.32) 111.97,44.59 111.46,44.59 111.18,44.87 111.18,62.89 113.04,64.76 113.44,64.76 113.98,64.22 114.16,64.22 114.43,64.49 114.43,64.67 113.89,65.21 113.89,65.61 114.32,66.03 114.72,66.03 115.14,65.61 115.37,65.61 115.59,65.83 115.59,66.06 115.17,66.48 115.17,66.86 123.44,75.13 123.44,76.65 123.89,77.1 123.89,78.44 126.12,80.67 126.52,80.67 126.78,80.41 v2(126.95,80.41)
  BOTTOM w0.076: UC1.BL3 130.82,83.52 130.82,83.11 130.42,82.7 130.42,82.17 129.76,81.52 129.48,81.52 128.95,80.99 128.87,80.99 128.86,80.97
  BOTTOM w0.127: 128.86,80.97 128.76,80.87 128.05,80.87 127.29,80.12 127.1,80.12 126.97,80.25 126.97,80.4 v2(126.95,80.41) ; JDIMM1.32 111.77,42.77 112.78,43.77 112.78,44.51 112.65,44.64 112.55,44.64 v2(112.24,44.32)
DDR_M0_DQS#2: length 54.9
  IN3 w0.127: v2(128.66,78.84) 128.56,78.75 128.56,78.63 129.03,78.16 129.03,76.86 128.58,76.41 128.58,71.88 117.56,60.86 117.56,48.04 116.74,47.22 116.74,46.28 116.94,46.07 117.35,46.07 117.47,46.2 v2(117.47,46.79)
  BOTTOM w0.076: UC1.BG3 133.27,84.04 133.39,84.04 133.49,83.94 133.49,83.56 133.33,83.39 133.33,81.9 133.41,81.82 133.41,80.54 132.97,80.1 132.89,80.1 132.87,80.08
  BOTTOM w0.127: 132.87,80.08 131.15,78.36 128.85,78.36 128.66,78.56 v2(128.66,78.84) ; v2(117.47,46.79) 117.47,46.4 117.62,46.25 117.82,46.25 118.17,46.6 118.17,47.42 117.16,48.43 117.16,49.24 117.02,49.38 JDIMM1.53
DDR_M0_DQS#3: length 50.8
  IN3 w0.127: v2(124.3,45.97) 124.3,45.75 124.16,45.6 123.63,45.6 123.41,45.82 123.41,55.24 124.2,56.02 124.2,60.93 133.35,70.08 133.35,74.05 135.21,75.91 135.21,80.01 135.64,80.44 136.07,80.44 136.1,80.41 136.11,80.41 v2(136.23,80.28)
  BOTTOM w0.076: UC1.BD3 135.85,83.53 135.85,81.88 135.61,81.64 135.61,80.73 135.81,80.53 135.98,80.53 v2(136.23,80.28)
  BOTTOM w0.127: JDIMM1.74 122.27,42.86 122.4,42.99 122.4,44.62 123.42,45.64 123.97,45.64 v2(124.3,45.97)
DDR_M0_DQS#4: length 49.2
  IN3 w0.127: v2(151.91,45.75) 151.91,45.94 151.73,46.12 151.47,46.12 151.12,46.46 151.12,48.86 151.81,49.56 151.81,54.12 157.03,59.33 157.03,72.28 156.5,72.8 156.33,72.8 v2(156.2,72.67)
  BOTTOM w0.076: 155.13,76.71 155.13,76.73 155.07,76.78 155.07,77.2 154.61,77.66 154.61,80.17 153.62,81.17 153.62,83.31 153.74,83.44 153.74,83.66 UC1.AA3
  BOTTOM w0.127: v2(151.91,45.75) 151.91,46.1 151.78,46.22 151.78,46.22 151.77,46.23 151.51,46.23 150.83,46.91 150.83,48.33 150.34,48.81 150.33,48.81 150.17,48.98 150.17,49.07 150.16,49.07 150.16,49.31 150.02,49.44 JDIMM1.177 ; v2(156.2,72.67) 156.33,72.8 156.66,72.8 156.99,73.12 156.99,74.2 155.13,76.06 155.13,76.71
DDR_M0_DQS#5: length 49.6
  IN3 w0.127: v2(157.62,77.03) 157.61,77.04 157.61,77.31 157.69,77.4 157.94,77.4 160.68,74.66 160.68,73.24 161.53,72.39 161.53,56.83 157.23,52.53 157.23,50.47 156.7,49.94 156.7,46.85 157.22,46.33 157.22,45.23 157.1,45.1 156.87,45.1 156.79,45.18 v2(156.79,45.59)
  BOTTOM w0.076: UC1.U3 156.13,83.54 156.13,81.44 156.41,81.16 156.49,81.16 156.5,81.15
  BOTTOM w0.127: 156.5,81.15 157.96,79.69 157.96,77.7 157.62,77.36 v2(157.62,77.03) ; JDIMM1.198 155.28,42.92 155.4,43.05 155.4,43.47 156.04,44.11 156.04,44.69 156.34,44.98 156.66,44.98 156.79,45.12 v2(156.79,45.59)
DDR_M0_DQS#6: length 50.4
  IN3 w0.076: 165.99,73.08 166.03,73.11 166.03,73.99 165.04,74.97 165.04,76.02 161.76,79.3 161.24,79.3 160.31,80.23 160.31,80.51 160.43,80.62 v2(160.43,80.88)
  IN3 w0.127: 165.99,73.08 165.99,54.98 162.87,51.86 162.87,50.82 162.62,50.57 162.62,46.45 162.89,46.18 163.55,46.18 v2(163.68,46.05)
  BOTTOM w0.076: v2(160.43,80.88) 160.43,80.69 160.29,80.55 160.13,80.55 159.59,81.1 159.59,81.3 158.63,82.26 158.63,83.28 158.82,83.46 158.82,83.71 UC1.P3
  BOTTOM w0.127: JDIMM1.219 160.52,49.5 160.7,49.32 160.7,49.04 161.47,48.27 161.47,47.37 162.64,46.2 163.53,46.2 v2(163.68,46.05)
DDR_M0_DQS#7: length 54.3
  IN3 w0.127: v2(162.85,82.23) 162.99,82.23 163.26,82.51 164.83,82.51 170.71,76.63 170.71,72.74 171.57,71.88 171.57,65.24 171.67,65.14 171.86,65.14 172.12,64.88 172.12,64.23 172.07,64.18 171.86,63.97 171.66,63.97 171.57,63.87 171.57,63.17 172.12,62.62 172.12,53.28 171.08,52.24 171.08,51.78 169.82,50.52 169.82,49.59 169.2,48.96 168.95,48.96 168.19,48.21 168.19,46.63 167.35,45.79 167.35,45.12 167.43,45.05 167.83,45.05 167.9,45.12 v2(167.9,45.16)
  BOTTOM w0.076: UC1.L3 161.16,83.53 161.16,82.22 161.55,81.82 162.76,81.82 162.85,81.91 v2(162.85,82.23)
  BOTTOM w0.127: v2(167.9,45.16) 167.84,45.1 167.2,45.1 166.43,44.33 166.43,43.95 165.91,43.44 165.91,42.97 165.77,42.83 JDIMM1.240
DDR_M0_MA0: length 48.2
  IN3 w0.216: v2(142.64,45.16) 142.27,45.53 141.28,47.3 141.28,49.54 141,49.81 141,52.11 142.34,53.46 142.34,58.56 147.59,63.81 147.59,71.37 146.26,72.71 146.26,79.54 146.47,79.75 146.8,79.75 v2(146.81,79.76)
  BOTTOM w0.076: 148.17,81.07 148.42,81.33 148.42,83.53 148.13,83.82 UC1.AH3
  BOTTOM w0.196: v2(142.64,45.16) 140.22,43.31 139.77,42.87 JDIMM1.144 ; 148.17,81.07 146.86,79.76 v2(146.81,79.76)
DDR_M0_MA1: length 46.5
  IN3 w0.216: v2(143.48,84.14) 142.75,84.14 142.53,84.36 142.53,84.96 142.83,85.26 143.84,85.26 145.51,83.59 145.51,71.34 144.7,70.53 144.7,68.67 144.4,68.38 144.4,64.27 137.32,57.18 137.32,52.94 137.85,52.4 137.85,49.25 137.73,49.13 v2(137.73,48.61)
  BOTTOM w0.089: v2(143.48,84.14) 143.47,84.14 UC1.AP4
  BOTTOM w0.196: v2(137.73,48.61) 137.02,49.32 JDIMM1.133
DDR_M0_MA2: length 47.3
  IN3 w0.216: v2(143.5,71.81) 143.13,71.45 143.13,69.32 142.84,69.03 142.84,64.91 135.76,57.83 135.76,49.52 136.06,49.21 136.06,44.89 136.78,44.18 v2(136.79,44.18)
  BOTTOM w0.076: UC1.AN4 144.39,83.91 144.39,81.77 144.93,81.23
  BOTTOM w0.196: 144.93,81.23 145.11,81.05 145.11,74.97 143.5,73.36 v2(143.5,71.81) ; v2(136.79,44.18) 136.77,44.16 JDIMM1.132
DDR_M0_MA3: length 48
  IN3 w0.216: v2(141.9,81.45) 143.54,81.45 144.99,80 144.99,71.56 144.18,70.74 144.18,68.89 143.88,68.6 143.88,64.48 136.8,57.4 136.8,49.95 137.1,49.64 137.1,47.93 137.6,47.44 v2(137.73,47.44)
  BOTTOM w0.076: v2(141.9,81.45) 142.11,81.45 142.53,81.87 142.53,84.55 UC1.AP5
  BOTTOM w0.196: JDIMM1.131 136.52,49.09 136.85,48.76 136.85,47.79 137.2,47.44 v2(137.73,47.44)
DDR_M0_MA4: length 49.5
  IN3 w0.216: v2(141.82,80.27) 141.93,80.38 143.24,80.38 144.47,79.15 144.47,71.77 143.65,70.96 143.65,69.11 143.36,68.81 143.36,64.7 136.28,57.61 136.28,49.73 136.58,49.43 136.58,46.66 136.98,46.26 v2(137.73,46.26)
  BOTTOM w0.076: UC1.AP2 142.77,82.83 142.77,81.07 141.97,80.27 v2(141.82,80.27)
  BOTTOM w0.196: v2(137.73,46.26) 137.05,46.26 135.97,45.18 135.97,43.01 135.77,42.82 JDIMM1.128
DDR_M0_MA5: length 47
  IN3 w0.216: v2(141.82,79.69) 142.14,79.69 143.95,77.89 143.95,73 142.61,71.66 142.61,69.54 142.32,69.24 142.32,65.13 135.23,58.04 135.23,49.3 135.54,48.99 135.54,46.53 134.85,45.85 v2(134.76,45.85)
  BOTTOM w0.076: v2(141.82,79.69) 142.1,79.69 143.1,80.69 UC1.AP1
  BOTTOM w0.196: v2(134.76,45.85) 134.78,45.82 135.21,45.82 135.47,45.56 135.47,43.28 135.27,43.09 JDIMM1.126
DDR_M0_MA6: length 48.9
  IN3 w0.216: v2(141.86,78.51) 142.32,78.51 143.43,77.4 143.43,73.21 142.09,71.88 142.09,69.75 141.8,69.46 141.8,65.35 134.71,58.26 134.71,53.08 134.09,52.45 134.09,50.67 134.28,50.48 134.28,48.58 134.61,48.25 v2(134.71,48.25)
  BOTTOM w0.076: UC1.AP3 143.39,83.52 143.39,80.33 143.08,80.02
  BOTTOM w0.196: v2(141.86,78.51) 142.39,78.51 142.75,78.87 142.75,79.69 143.08,80.02 ; JDIMM1.127 135.53,49.36 136.31,48.58 136.31,47.6 136.68,47.22 136.68,46.95 136.36,46.62 136.09,46.62 135.61,47.1 135.61,48.06 135.41,48.25 v2(134.71,48.25)
DDR_M0_MA7: length 47.2
  IN3 w0.216: v2(134.73,43.44) 134.57,43.44 132.72,45.28 132.72,49.83 132.53,50.02 132.53,53.1 133.09,53.67 133.09,58.88 140.24,66.03 140.24,70.11 140.53,70.4 140.53,72.53 141.46,73.46 141.46,75.08 141.88,75.5 v2(141.94,75.5)
  BOTTOM w0.076: UC1.AN1 144.06,82.29 144.06,78.96
  BOTTOM w0.196: v2(141.94,75.5) 142.83,75.5 144.06,76.73 144.06,78.96 ; v2(134.73,43.44) 134.54,43.44 134.27,43.17 JDIMM1.122
DDR_M0_MA8: length 47.2
  IN3 w0.216: v2(141.91,76.11) 142.43,76.11 142.9,75.64 142.9,73.43 141.57,72.1 141.57,69.97 141.28,69.68 141.28,65.56 134.19,58.48 134.19,53.29 133.57,52.67 133.57,50.45 133.76,50.26 133.76,47.83 v2(134.59,47)
  BOTTOM w0.076: UC1.AN3 143.56,83.54 143.56,82.28 143.76,82.08 143.76,79.47 143.55,79.26 143.55,79.02
  BOTTOM w0.196: v2(134.59,47) 134.43,47 134.06,47.37 134.06,48.32 135.02,49.28 JDIMM1.125 ; v2(141.91,76.11) 142.7,76.11 143.55,76.97 143.55,79.02
DDR_M0_MA9: length 49.3
  IN3 w0.216: v2(132.2,45.52) 132.2,49.62 132.01,49.81 132.01,53.32 132.57,53.88 132.57,59.1 139.72,66.24 139.72,70.32 140.01,70.62 140.01,72.74 140.94,73.67 140.94,75.29 141.39,75.74 141.39,76.85 v2(141.86,77.32)
  BOTTOM w0.076: 141.18,80.82 141.15,80.84 141.15,81.7 141.62,82.17 141.62,84.17 UC1.AT4
  BOTTOM w0.196: 141.18,80.82 141.18,77.88 141.73,77.32 v2(141.86,77.32) ; v2(132.2,45.52) 132.2,47.31 134.02,49.13 JDIMM1.121
DDR_M0_MA10: length 47.8
  IN3 w0.216: v2(142.64,43.94) 142.81,43.94 143.16,44.3 143.16,49.93 143.01,50.09 143.01,51.87 143.91,52.76 143.91,57.91 149.15,63.16 149.15,72.02 147.92,73.25 147.92,75.89 148.73,76.7 148.73,79.95 147.07,81.61 v2(146.79,81.61)
  BOTTOM w0.076: 147.81,82.27 147.81,82.85 UC1.AH2
  BOTTOM w0.196: 147.81,82.27 147.81,82.02 147.4,81.61 v2(146.79,81.61) ; JDIMM1.146 142.28,42.85 141.86,43.26 141.86,43.8 142.16,44.1 142.48,44.1 v2(142.64,43.94)
DDR_M0_MA11: length 48.4
  IN3 w0.216: v2(141.98,74.18) 141.98,73.24 141.05,72.31 141.05,70.19 140.76,69.89 140.76,65.78 133.67,58.69 133.67,53.51 133.05,52.89 133.05,50.24 133.24,50.05 133.24,45.56 134.13,44.67 v2(134.76,44.67)
  BOTTOM w0.076: UC1.AN2 144.15,83.17 144.23,83.09 144.23,81.44 144.6,81.07 144.6,79.47
  BOTTOM w0.196: 144.6,79.47 144.6,76.27 142.51,74.18 v2(141.98,74.18) ; v2(134.76,44.67) 134.5,44.67 133.77,43.95 JDIMM1.120
DDR_M0_MA12: length 49.1
  IN3 w0.216: v2(130.64,46.89) 130.87,46.89 131.16,47.18 131.16,48.93 130.42,49.67 130.42,59.16 138.15,66.89 138.15,72.36 139.9,74.11 139.9,75.73 140.35,76.17 140.35,79.52 139.07,80.8 v2(138.82,80.8)
  BOTTOM w0.076: UC1.AU4 140.96,84.09 140.96,83.68 140.78,83.5 140.51,83.5 140.19,83.19 140.19,82.17 v2(138.82,80.8)
  BOTTOM w0.196: v2(130.64,46.89) 130.99,46.89 133.53,49.42 JDIMM1.119
DDR_M0_MA13: length 47
  IN3 w0.216: v2(146.77,44.47) 146.53,44.47 145.39,45.61 145.39,50.41 145.99,51 145.99,56.28 151.24,61.52 151.24,72.89 150.09,74.03 150.09,75.11 150.98,76 v2(150.98,78.59)
  BOTTOM w0.076: v2(150.98,78.59) 150.58,78.99 150.58,80.06 151.09,80.56 151.09,82.96 151.02,83.02 151.02,83.44 UC1.AE3
  BOTTOM w0.196: v2(146.77,44.47) 146.6,44.47 145.28,43.15 JDIMM1.158
DDR_M0_MA14_WE#: length 46.1
  IN3 w0.216: v2(144.35,48.54) 144.35,50.85 144.51,51.01 144.51,51.9 144.95,52.33 144.95,56.71 145.87,57.63 145.87,57.93 145.79,58.02 145.79,58.32 146,58.53 146.3,58.53 146.39,58.45 146.69,58.45 146.9,58.66 146.9,58.96 146.77,59.09 146.77,59.3 147.03,59.56 147.32,59.56 147.44,59.44 147.68,59.44 147.94,59.7 147.94,59.96 147.79,60.11 147.79,60.33 148.07,60.6 148.33,60.6 148.45,60.47 148.71,60.47 148.98,60.75 148.98,60.97 148.84,61.11 148.84,61.37 149.07,61.6 149.37,61.6 149.46,61.52 149.76,61.52 150.2,61.96 150.2,72.45 149.05,73.6 149.05,75.55 149.77,76.27 v2(149.77,81.34)
  BOTTOM w0.076: UC1.AG4 149.17,84.77 149.58,84.77 149.59,84.78 150.03,84.78 150.11,84.71 150.11,82.28 150.36,82.03 150.36,81.5 150.2,81.34 v2(149.77,81.34)
  BOTTOM w0.196: v2(144.35,48.54) 144.19,48.54 143.52,49.2 JDIMM1.151
DDR_M0_MA15_CAS#: length 46.9
  IN3 w0.216: v2(150.98,79.89) 151.27,80.19 151.7,80.19 151.96,79.93 151.96,78.05 151.59,77.68 151.59,75.88 150.61,74.9 150.61,74.24 151.76,73.1 151.76,61.31 146.52,56.08 146.52,50.8 145.92,50.19 145.92,46.04 146.21,45.74 v2(146.77,45.74)
  BOTTOM w0.076: UC1.AD1 151.38,80.3 v2(150.98,79.89)
  BOTTOM w0.196: JDIMM1.156 144.77,43.37 146.19,44.79 146.19,45.3 146.64,45.74 v2(146.77,45.74)
DDR_M0_MA16_RAS#: length 49.2
  IN3 w0.216: v2(144.35,45.49) 144.19,45.49 143.68,46 143.68,50.15 143.53,50.3 143.53,51.65 144.43,52.55 144.43,57.7 149.67,62.94 149.67,72.24 148.44,73.47 148.44,75.67 149.25,76.48 149.25,80.47 147.46,82.26 146.81,82.26 v2(146.79,82.23)
  BOTTOM w0.076: v2(146.79,82.23) 146.89,82.13 147.35,82.13 147.62,82.4 147.62,84.3 147.79,84.47 UC1.AH4
  BOTTOM w0.196: v2(144.35,45.49) 144.1,45.24 144.1,43.49 143.77,43.17 JDIMM1.152
DDR_M0_ODT0: length 52.4
  IN3 w0.216: v2(151.69,74.37) 151.69,74.77 152.07,75.15 152.31,75.15 152.89,74.57 152.89,74.3 152.61,74.02 152.61,73.77 152.8,73.58 153.15,73.58 153.31,73.42 153.31,73.01 153.1,72.8 152.78,72.8 152.61,72.63 152.61,72.13 152.76,71.98 153.05,71.98 153.2,71.83 153.2,71.28 153.06,71.14 152.81,71.14 152.61,70.94 152.61,60.96 147.38,55.72 147.38,50.45 146.77,49.84 146.77,49.57 147.23,49.11 147.23,48.5 147.01,48.28 v2(146.77,48.28)
  BOTTOM w0.076: 151.43,77.89 151.68,78.14 151.68,79.59 151.94,79.84 151.94,82.38 151.91,82.4 151.91,83.55 151.64,83.82 UC1.AD3
  BOTTOM w0.196: v2(146.77,48.28) 146.49,48.28 146.35,48.42 146.35,48.73 146.15,48.92 145.79,48.92 145.59,48.73 145.59,48.14 145.46,48.01 145.11,48.01 144.89,48.23 144.89,48.82 144.52,49.19 JDIMM1.155 ; v2(151.69,74.37) 151.69,74.73 151.89,74.93 152.17,74.93 152.9,74.2 153.17,74.2 153.43,74.46 153.43,74.83 152.41,75.86 152.11,75.86 151.98,75.74 151.68,75.74 151.43,75.99 151.43,77.89
DDR_M0_ODT1: length 54.6
  IN3 w0.216: v2(148.42,52.42) 148.57,52.42 149.1,52.96 149.1,55.24 154.31,60.45 154.31,70.51 153.75,71.07 v2(153.68,71.07)
  BOTTOM w0.076: 151.17,78.14 151.38,78.34 151.38,79.74 151.67,80.03 151.67,83.39 151.57,83.49 151.26,83.49 151.01,83.74 151.01,84.15 150.69,84.47 UC1.AE4
  BOTTOM w0.196: 151.17,78.14 150.76,77.73 150.76,75.52 151.1,75.18 151.1,74.12 151.36,73.87 152.07,73.87 152.24,73.7 153.6,73.7 153.94,74.04 154.88,74.04 155.18,73.74 155.18,70.61 155.37,70.41 157.31,70.41 157.52,70.2 157.52,69.89 157.34,69.71 155.37,69.71 155.18,69.52 155.18,68.74 154.98,68.54 154.59,68.54 154.32,68.81 154.32,70.89 154.14,71.07 v2(153.68,71.07) ; v2(148.42,52.42) 146.96,52.42 146.02,51.48 JDIMM1.161
DDR_M0_PAR: length 46.8
  IN3 w0.216: v2(142.64,46.84) 142.48,46.84 141.8,47.51 141.8,49.75 141.52,50.03 141.52,51.9 142.86,53.24 142.86,58.34 148.11,63.59 148.11,71.59 146.8,72.9 v2(146.8,78.5)
  BOTTOM w0.076: UC1.AG3 148.66,83.82 148.59,83.74 148.59,81.11
  BOTTOM w0.196: JDIMM1.143 139.52,49.45 139.74,49.24 140.24,49.24 v2(142.64,46.84) ; 148.59,81.11 148.59,80.81 147.49,79.72 147.49,79.1 146.89,78.5 v2(146.8,78.5)
DDR_M1_ACT#: length 66
  IN1 w0.076: v2(141.94,88.05) 142.66,87.33 142.66,86.05 142.37,85.76 142.37,84.33 141.25,83.22 141.25,82.45 140.62,81.81 140.62,75.42 139.97,74.77 139.97,74.44
  IN1 w0.203: 139.97,74.44 139.97,69.75 129.79,59.57 129.79,55.02 128.54,53.77 128.54,46.76 128.95,46.34 128.95,32.83 129.27,32.51 129.27,32 v2(130.11,31.16)
  BOTTOM w0.076: v2(141.94,88.05) 141.61,87.73 UC1.AT9
  BOTTOM w0.196: v2(130.11,31.16) 130.23,31.16 130.78,30.61 JDIMM2.114
DDR_M1_ALERT#: length 66.6
  IN1 w0.076: v2(141.95,86.78) 141.72,86.55 141.16,85.81 140.37,83.35 140.37,82.58 139.86,82.07 139.86,76.63 138.11,74.88 138.11,74.82
  IN1 w0.241: v2(128.22,32.4) 127.91,32.72 126.84,34.63 126.84,37.04 126.47,38.82 126.47,55.67 127.13,56.33 127.13,59.53 137.69,70.09 137.69,72.46 138.11,72.88 138.11,74.82
  BOTTOM w0.076: UC1.AR8 142.25,87.08 v2(141.95,86.78)
  BOTTOM w0.196: JDIMM2.116 131.28,31.36 130.24,32.4 v2(128.22,32.4)
DDR_M1_BA0: length 65.7
  IN1 w0.076: 150.7,75.17 150.7,75.56 149.23,77.03 149.23,80.17 148.75,80.64 148.75,82.65 148.48,82.92 148.48,86.44 148.63,86.59 148.63,87.11 v2(148.34,87.4)
  IN1 w0.203: v2(142.17,31.94) 142.17,31.77 141.96,31.56 141.42,31.56 141.17,31.81 141.17,32.54 141.43,32.8 141.43,36.17 141.67,36.41 141.67,48.7 142.47,49.5 142.47,50.61 141.98,51.1 141.98,51.96 142.47,52.45 142.47,56.63 151.17,65.32 151.17,73.3 150.7,73.76 150.7,75.17
  BOTTOM w0.089: UC1.AH8 148.2,87.4 v2(148.34,87.4)
  BOTTOM w0.196: JDIMM2.150 141.78,31.55 v2(142.17,31.94)
DDR_M1_BA1: length 67
  IN1 w0.076: v2(147.42,87.37) 147.7,87.37 147.82,87.26 147.82,86.55 148.07,86.29 148.07,82.71 148.21,82.57 148.21,80.25 148.64,79.82 148.64,76.31 149.68,75.27 149.68,75.11
  IN1 w0.203: 149.68,75.11 149.68,73.34 150.14,72.88 150.14,65.74 141.46,57.06 141.46,52.87 140.96,52.38 140.96,49.59 140.65,49.28 140.65,43.48 140.25,43.07 140.25,42.44 140.65,42.04 140.65,41.36 140.25,40.95 140.25,40.53 140.65,40.12 140.65,36.83 140.42,36.6 140.42,35.24 140.27,35.1 140.09,35.1 139.95,34.96 139.95,34.42 140.42,33.96 140.42,33.46 140.24,33.29 140.04,33.29 139.41,33.92 v2(139.4,33.92)
  BOTTOM w0.089: v2(147.42,87.37) 147.78,87.73 UC1.AH9
  BOTTOM w0.196: v2(139.4,33.92) 139.58,33.92 140.53,34.87 JDIMM2.145
DDR_M1_BG0: length 65.1
  IN1 w0.076: v2(141.95,87.42) 142.31,86.98 142.31,86.76 142.21,86.07 142.16,85.86 142.16,84.53 140.95,83.32 140.95,82.45 140.31,81.81 140.31,75.64 139.46,74.78 139.46,74.71
  IN1 w0.203: v2(128.37,34.12) 128.22,34.27 128.22,39.96 127.95,40.23 127.77,41.91 127.77,44.28 128.03,44.53 128.03,53.98 129.28,55.24 129.28,59.78 139.03,69.53 139.03,71.89 139.46,72.32 139.46,74.71
  BOTTOM w0.076: UC1.AR9 142.08,87.42 v2(141.95,87.42)
  BOTTOM w0.196: JDIMM2.115 131.03,36.97 128.37,34.32 v2(128.37,34.12)
DDR_M1_BG1: length 64.9
  IN1 w0.076: 138.95,74.68 138.95,75.09 140.11,76.25 140.11,81.94 140.66,82.48 140.66,83.51 141.37,84.22 141.37,85.61 v2(141.82,86.07)
  IN1 w0.203: 138.95,74.68 138.95,72.53 138.52,72.11 138.52,69.74 127.96,59.18 127.96,58.52 128.17,58.32 128.57,58.32 128.78,58.12 128.78,57.71 128.57,57.51 128.17,57.51 127.96,57.31 127.96,56.9 128.17,56.7 128.57,56.7 128.78,56.49 128.78,56.09 128.57,55.88 128.17,55.88 127.96,55.68 127.96,54.64 127.52,54.19 127.52,44.74 127.27,44.49 127.27,40.19 127.71,39.75 127.71,34.94 v2(127.72,34.94)
  BOTTOM w0.089: UC1.AR7 142.18,86.43 v2(141.82,86.07)
  BOTTOM w0.196: JDIMM2.113 130.53,37.2 128.26,34.94 v2(127.72,34.94)
DDR_M1_CKE0: length 68
  IN1 w0.076: 136.98,74.96 138.64,76.62 139.01,76.62 139.35,76.97 139.35,82.43 139.72,82.8 139.72,85.23 140.48,86 140.48,86.81 v2(141.07,87.4)
  IN1 w0.203: 136.98,74.96 136.76,74.74 136.76,73.44 136.34,73.02 136.34,70.65 124.99,59.3 124.99,58.95 125.19,58.75 125.58,58.75 125.78,58.54 125.78,58.24 125.58,58.03 125.19,58.03 124.99,57.83 124.99,57.47 125.19,57.26 125.48,57.26 125.68,57.06 125.68,56.67 124.99,55.98 124.99,38.17 125.3,37.85 125.3,36.85 124.89,36.44 124.89,35.48 v2(125.3,35.07)
  BOTTOM w0.076: 141.39,87.08 v2(141.07,87.4)
  BOTTOM w0.089: UC1.AT8 141.39,87.08
  BOTTOM w0.196: JDIMM2.109 129.53,37.18 129.19,36.84 128.45,36.84 126.67,35.07 v2(125.3,35.07)
DDR_M1_CKE1: length 67.2
  IN1 w0.076: 137.69,75.02 139.6,76.93 139.6,82.08 139.93,82.75 140.1,83.21 140.53,84.74 140.86,85.88 141.37,86.73 141.43,87.38 141.43,87.51 v2(141.06,88.09)
  IN1 w0.203: 137.69,75.02 137.27,73.95 137.27,73.23 136.85,72.81 136.85,70.44 126.29,59.88 126.29,56.56 125.5,55.77 125.5,38.77 125.81,38.06 125.81,34.15 125.93,33.94 127.23,32.17 128.11,31.21 v2(128.22,31.13)
  BOTTOM w0.076: v2(141.06,88.09) 141.35,88.38 UC1.AT10
  BOTTOM w0.196: v2(128.22,31.13) 129.24,31.13 129.78,30.59 JDIMM2.110
DDR_M1_CLK0: length 63.8
  IN1 w0.076: 146.73,77.8 146.73,77.82 146.66,77.88 146.66,78.1 146.4,78.37 146.4,83.93 146.55,84.09 146.55,85.62 145.97,86.2 145.56,86.2 145.19,86.57 145.19,87.37 145.08,87.48 145.08,87.71 v2(144.72,88.06)
  IN1 w0.127: 146.73,77.8 146.73,75.3 147.12,74.91 147.12,72.3 147.55,71.87 147.55,66.73 138.89,58.07 138.16,53.04 138.16,51.73 137.31,49.22 137.31,46.18 137.48,45.15 137.52,44.87 137.52,44.84 137.52,44.07 137.31,42.69 137.31,37.77 136.59,37.05 136.59,35.51 136.77,35.33 137.01,35.33 137.13,35.46 v2(137.13,35.51)
  BOTTOM w0.076: v2(144.72,88.06) 144.75,88.09 145.08,88.09 145.2,87.97 145.2,87.79 UC1.AM9
  BOTTOM w0.127: JDIMM2.137 136.53,37.16 137.13,36.55 137.42,36.55 137.88,36.1 137.88,35.57 137.65,35.35 137.31,35.35 137.29,35.37 137.28,35.37 v2(137.13,35.51)
DDR_M1_CLK1: length 65.3
  IN1 w0.076: 147.3,79.35 147.3,79.37 147.36,79.43 147.36,79.65 147.25,79.77 147.25,83.81 146.93,84.13 146.93,86.09 145.93,87.09 145.71,87.09 145.58,86.97 v2(145.58,86.68)
  IN1 w0.127: 147.3,79.35 147.3,75.62 147.58,75.35 147.58,72.46 148.04,72.01 148.04,66.6 139.36,57.93 139.36,53.78 138.59,53.01 138.59,50.05 138.15,49.62 138.15,37.79 137.67,37.31 137.67,32.99 137.53,32.85 137.25,32.85 137.12,32.98 v2(137.12,33.02)
  BOTTOM w0.076: v2(145.58,86.68) 145.39,86.68 UC1.AM7
  BOTTOM w0.127: JDIMM2.138 136.78,30.59 136.89,30.7 136.89,30.94 136.3,31.52 136.3,32.46 136.65,32.81 136.94,32.81 137.12,33 v2(137.12,33.02)
DDR_M1_CLK#0: length 63.8
  IN1 w0.076: 146.45,77.8 146.45,77.82 146.51,77.88 146.51,78.04 146.4,78.15 146.24,78.31 146.24,84 146.4,84.15 146.4,85.55 145.9,86.05 145.49,86.05 145.04,86.5 145.04,87.3 144.88,87.47 v2(144.72,87.47)
  IN1 w0.127: 146.45,77.8 146.45,75.19 146.84,74.79 146.84,72.18 147.27,71.75 147.27,66.85 138.63,58.2 137.88,53.06 137.88,51.77 137.03,49.27 137.03,46.16 137.24,44.85 137.24,44.83 137.24,44.09 137.03,42.71 137.03,37.89 136.31,37.17 136.31,35.39 136.66,35.05 137.02,35.05 v2(137.13,34.93)
  BOTTOM w0.076: UC1.AN9 144.48,87.47 v2(144.72,87.47)
  BOTTOM w0.127: v2(137.13,34.93) 137.27,35.07 137.77,35.07 138.16,35.45 138.16,36.21 137.53,36.83 137.25,36.83 137.03,37.06 JDIMM2.139
DDR_M1_CLK#1: length 65.2
  IN1 w0.076: v2(145.61,87.47) 145.83,87.24 145.99,87.24 147.08,86.15 147.08,84.19 147.4,83.87 147.4,79.83 147.52,79.71 147.52,79.43 147.58,79.37 147.58,79.35
  IN1 w0.127: 147.58,79.35 147.58,75.74 147.86,75.46 147.86,72.58 148.32,72.12 148.32,66.49 139.64,57.82 139.64,53.67 138.87,52.89 138.87,49.93 138.43,49.5 138.43,37.68 137.95,37.2 137.95,32.88 137.65,32.57 137.26,32.57 v2(137.12,32.43)
  BOTTOM w0.076: v2(145.61,87.47) 145.22,87.08 UC1.AM8
  BOTTOM w0.127: JDIMM2.140 137.28,30.59 137.16,30.7 137.16,31.05 136.58,31.64 136.58,32.34 136.77,32.53 137.03,32.53 v2(137.12,32.43)
DDR_M1_CS#0: length 69
  IN1 w0.076: v2(150.15,88.67) 150.57,88.25 150.57,86.53 150.49,86.46 150.49,83.7 151.38,82.81 151.38,79.17 154.7,75.84 154.7,75.34
  IN1 w0.203: v2(144.61,34.3) 144.73,34.3 145.55,35.12 145.55,37.46 146.31,38.23 146.31,41.83 145.9,42.24 145.9,44.49 146.16,44.74 146.16,49.28 146.7,49.82 146.7,54.32 148.01,55.63 148.01,56.02 147.48,56.54 147.48,56.84 155.06,64.42 155.06,71.04 154.7,71.4 154.7,75.34
  BOTTOM w0.089: v2(150.15,88.67) 149.79,89.03 UC1.AF11
  BOTTOM w0.196: JDIMM2.149 141.53,34.64 142.06,34.1 144.4,34.1 v2(144.61,34.3)
DDR_M1_CS#1: length 68.5
  IN1 w0.076: 155.21,75.4 155.21,75.87 151.62,79.46 151.62,83.03 150.66,83.99 150.66,85.72 v2(151.02,86.08)
  IN1 w0.203: 155.21,75.4 155.21,71.6 155.57,71.25 155.57,64.2 151.63,60.26 151.63,58.53 150.74,57.64 150.45,57.64 149.95,58.14 149.68,58.14 149.37,57.84 149.37,57.53 149.86,57.04 149.86,56.76 149.64,56.54 149.35,56.54 148.78,57.12 148.49,57.12 148.22,56.85 148.22,56.52 148.78,55.97 148.78,55.68 147.22,54.12 147.22,43.67 146.82,43.27 146.82,38.01 146.06,37.25 146.06,34.38 146.39,34.05 v2(146.51,34.05)
  BOTTOM w0.076: UC1.AE7 150.97,86.08 v2(151.02,86.08)
  BOTTOM w0.196: JDIMM2.157 143.53,37 144.31,36.21 144.73,36.21 145.12,35.83 145.12,34.81 145.88,34.05 v2(146.51,34.05)
DDR_M1_D0: length 76.9
  IN1 w0.127: v2(124.79,89.02) 124.74,89.06 123.53,89.06 123.02,88.55 122.2,88.55 118.23,84.58 115.17,84.58 113.74,83.15 arc(112.77,81.7) 112.43,79.99 112.43,72.51 103.7,63.78 103.7,58.64 103.12,58.05 103.12,52.13 100.41,49.42 100.41,44.6 101.95,43.07 101.95,38.06 102.42,37.59 102.42,35.18 103.65,33.94 103.65,33.16 v2(104.6,32.22)
  BOTTOM w0.076: v2(124.79,89.02) 125.21,88.59 126.4,88.59 126.61,88.8 127.12,88.8 UC1.BT11
  BOTTOM w0.127: JDIMM2.8 104.28,31.9 v2(104.6,32.22)
DDR_M1_D1: length 78.3
  IN1 w0.127: v2(104.57,33.54) 104.57,33.63 102.8,35.41 102.8,37.82 102.38,38.24 102.38,43.25 100.84,44.78 100.84,49.24 102.44,50.84 103.33,50.84 103.5,51 103.5,57.89 104.13,58.53 104.13,63.67 112.82,72.35 112.82,79.99 arc(113.13,81.55) 114.01,82.88 115.33,84.2 118.46,84.2 122.38,88.11 123.2,88.11 123.7,88.62 v2(124.36,88.62)
  BOTTOM w0.076: v2(124.36,88.62) 124.58,88.39 126.6,88.39 126.74,88.54 127.5,88.54 UC1.BR11
  BOTTOM w0.127: JDIMM2.7 104.03,36.85 103.67,36.49 103.67,34.45 v2(104.57,33.54)
DDR_M1_D2: length 75.9
  IN1 w0.127: v2(106.51,35.19) 106.22,35.19 106.09,35.33 106.09,38.05 106.32,38.28 106.32,39.62 106.19,39.75 105.71,39.75 105.58,39.88 105.58,40.13 105.71,40.26 106.19,40.26 106.32,40.38 106.32,41.64 106.19,41.77 105.71,41.77 105.58,41.9 105.58,42.15 105.71,42.28 106.19,42.28 106.32,42.4 106.32,42.77 106.13,42.95 105.76,42.95 105.63,43.08 105.63,43.33 105.76,43.46 106.19,43.46 106.32,43.59 106.32,43.84 106.19,43.97 105.76,43.97 105.63,44.1 105.63,44.35 105.76,44.48 106.22,44.48 106.32,44.57 106.32,56.94 107.04,57.67 107.04,60.26 106.7,60.6 106.7,62.6 115.47,71.38 115.47,74.06 115.95,74.53 118.7,74.53 121.34,77.17 121.34,82.35 121.63,82.64 121.63,83.74 122.58,84.69 124.45,84.69 125.66,85.9 125.66,87.03 126.11,87.48 126.29,87.48 v2(126.81,88)
  BOTTOM w0.076: v2(126.81,88) 126.99,88.18 UC1.BT9
  BOTTOM w0.127: v2(106.51,35.19) 105.64,34.33 105.64,31.64 106.28,31.01 JDIMM2.16
DDR_M1_D3: length 76.8
  IN1 w0.127: v2(106.51,32.65) 105.22,33.94 105.22,37.95 104.18,38.99 104.18,48.83 105.3,49.95 105.3,57.15 105.94,57.78 105.94,62.92 114.71,71.7 114.71,74.37 115.65,75.31 118.4,75.31 120.58,77.49 120.58,82.66 120.86,82.95 120.86,84.05 122.94,86.13 123.84,86.13 124.91,87.2 124.91,87.85 v2(125.01,87.95)
  BOTTOM w0.076: UC1.BR8 127.23,86.69 125.88,86.69 125.01,87.56 v2(125.01,87.95)
  BOTTOM w0.127: v2(106.51,32.65) 107.14,33.29 107.14,36.74 107.53,37.12 JDIMM2.21
DDR_M1_D4: length 78.2
  IN1 w0.127: v2(101.87,36.24) 101.51,36.6 101.51,42.89 99.98,44.43 99.98,49.53 102.1,51.65 102.1,52.08 102.23,52.21 102.61,52.21 102.74,52.34 102.74,52.59 102.61,52.72 102.23,52.72 102.1,52.84 102.1,53.1 102.23,53.23 102.61,53.23 102.74,53.35 102.74,53.61 102.61,53.73 102.23,53.73 102.1,53.86 102.1,54.11 102.23,54.24 102.61,54.24 102.74,54.37 102.74,54.62 102.61,54.75 102.23,54.75 102.1,54.88 102.1,57.58 103.27,58.74 103.27,59.02 103.18,59.11 102.65,59.11 102.53,59.24 102.53,59.49 102.65,59.62 103.18,59.62 103.27,59.71 103.27,63.88 112.05,72.67 112.05,79.99 arc(112.42,81.85) 113.47,83.42 115.01,84.96 117.75,84.96 121.77,88.98 122.84,88.98 123.39,89.53 125.71,89.53 v2(126,89.24)
  BOTTOM w0.076: UC1.BP11 128.29,89.26 127.06,89.26 126.78,88.98 126.26,88.98 v2(126,89.24)
  BOTTOM w0.127: JDIMM2.3 103.03,37.08 102.81,36.86 102.81,36.48 102.57,36.24 v2(101.87,36.24)
DDR_M1_D5: length 79.1
  IN1 w0.127: v2(126.18,89.88) 126.1,89.96 123.21,89.96 122.66,89.41 121.66,89.41 117.6,85.34 114.86,85.34 113.2,83.69 arc(112.07,81.99) 111.67,79.99 111.67,72.83 102.84,63.99 102.84,61.5 102.19,59.69 101.67,57.94 101.67,53.96 99.55,49.51 99.55,44.25 101.08,42.71 101.08,36.14 101.24,35.74 102.57,34.41 102.78,32.43 v2(102.9,31.6)
  BOTTOM w0.076: UC1.BN11 128.77,89.44 126.62,89.44 v2(126.18,89.88)
  BOTTOM w0.127: JDIMM2.4 103.28,31.22 v2(102.9,31.6)
DDR_M1_D6: length 76.7
  IN1 w0.127: v2(106.53,36.46) 106.8,36.46 106.94,36.6 106.94,37.29 106.47,37.76 106.47,37.89 106.7,38.12 106.7,56.71 107.55,57.56 107.55,60.6 107.42,60.72 107.21,60.72 107.08,60.85 107.08,61.1 107.21,61.23 107.42,61.23 107.55,61.36 107.55,61.61 107.42,61.74 107.21,61.74 107.08,61.87 107.08,62.38 116,71.3 116,71.9 116.15,72.05 116.75,72.05 116.87,72.16 116.87,72.43 116.73,72.57 115.97,72.57 115.85,72.69 115.85,73.03 115.98,73.15 116.89,73.15 117.89,74.15 118.85,74.15 121.87,77.17 121.87,80.77 122.03,80.92 122.37,80.92 122.5,81.05 122.5,81.39 122.3,81.58 121.91,81.58 121.78,81.72 121.78,82.25 121.95,82.42 122.14,82.42 122.51,82.05 122.76,82.05 122.89,82.17 122.89,82.33 122.01,83.21 122.01,83.58 122.1,83.67 122.27,83.67 123.31,82.63 123.46,82.63 123.67,82.84 123.67,82.99 122.65,84.01 122.65,84.17 122.77,84.3 123.08,84.3 123.79,83.59 124.12,83.59 124.33,83.8 124.33,83.95 126.43,86.05 127.03,86.05 127.18,86.2 127.18,86.43 127.05,86.56 126.36,86.56 126.22,86.7 v2(126.22,87.06)
  BOTTOM w0.076: v2(126.22,87.06) 126.62,87.45 127.13,87.45 127.38,87.71 128.27,87.71 UC1.BP8
  BOTTOM w0.127: v2(106.53,36.46) JDIMM2.17
DDR_M1_D7: length 77.6
  IN1 w0.127: v2(106.51,33.92) 105.66,34.77 105.66,38.13 105.2,38.58 105.2,41.39 105.07,41.52 104.91,41.52 104.78,41.65 104.78,41.9 104.91,42.03 105.07,42.03 105.2,42.16 105.2,42.41 105.07,42.54 104.69,42.54 104.56,42.66 104.56,42.92 104.69,43.05 105.07,43.05 105.2,43.17 105.2,46.73 105.07,46.86 104.69,46.86 104.56,46.99 104.56,47.24 104.69,47.37 105.07,47.37 105.2,47.49 105.2,47.75 105.07,47.87 104.69,47.87 104.56,48 104.56,48.26 104.69,48.38 105.07,48.38 105.2,48.51 105.2,48.71 105.68,49.19 105.68,56.92 106.32,57.55 106.32,62.76 115.09,71.54 115.09,74.22 115.81,74.93 118.56,74.93 120.96,77.33 120.96,82.51 121.25,82.79 121.25,83.89 123.05,85.7 124.02,85.7 125.25,86.94 125.25,87.64 v2(125.63,88.02)
  BOTTOM w0.076: v2(125.63,88.02) 126.02,87.63 127.05,87.63 127.31,87.89 128.74,87.89 UC1.BN8
  BOTTOM w0.127: v2(106.51,33.92) 106.08,33.49 106.08,31.82 107.28,30.62 JDIMM2.20
DDR_M1_D8: length 72.5
  IN1 w0.076: v2(130.97,89.29) 130.97,89.26 129.11,87.41 128.76,87.41 128.48,87.12 128.48,86.92
  IN1 w0.127: v2(108.62,33.29) 108.35,33.02 107.89,33.02 107.75,33.16 107.75,33.64 107.88,33.77 108.29,33.77 108.41,33.88 108.41,34.13 108.27,34.27 107.88,34.27 107.75,34.4 107.75,38.21 107.46,38.51 107.46,56.25 108.31,57.1 108.31,62.53 122.95,77.17 122.95,80.11 125.87,83.04 125.87,83.79 128.48,86.39 128.48,86.92
  BOTTOM w0.076: 130.54,89.72 v2(130.97,89.29)
  BOTTOM w0.089: UC1.BL12 130.54,89.72
  BOTTOM w0.127: v2(108.62,33.29) 108.28,32.94 JDIMM2.24
DDR_M1_D9: length 72
  IN1 w0.076: v2(130.21,89.36) 130.21,88.74 129.04,87.57 128.6,87.57 128.14,87.11 128.12,87.09
  IN1 w0.127: 128.12,87.09 127.99,86.96 127.99,86.44 125.49,83.95 125.49,83.27 122.52,80.29 122.52,77.28 107.93,62.69 107.93,57.33 107.08,56.48 107.08,38.28 107.32,38.03 107.32,31.96 107.43,31.85 107.79,31.85 107.9,31.95 107.9,32.08 108.06,32.24 108.35,32.24 v2(108.74,31.85)
  BOTTOM w0.076: UC1.BL11 130.54,89.03 v2(130.21,89.36)
  BOTTOM w0.127: v2(108.74,31.85) 109.28,31.32 JDIMM2.28
DDR_M1_D10: length 70.5
  IN1 w0.076: 129.6,86.59 129.67,86.59 129.91,86.83 129.91,87.49 v2(130.19,87.77)
  IN1 w0.097: 129.6,86.58 129.6,86.59
  IN1 w0.127: 129.6,86.58 129.41,86.58 126.81,83.98 126.81,83.37 123.37,79.92 123.37,77.05 108.69,62.37 108.69,56.87 107.89,56.07 107.89,52.7 108.56,52.03 108.56,51.08 108.4,50.92 108.01,50.92 107.88,50.8 107.88,50.45 108.01,50.33 108.45,50.33 108.58,50.2 108.58,49.84 108.48,49.74 107.98,49.74 107.84,49.6 107.84,49.35 107.96,49.22 108.4,49.22 108.58,49.05 108.58,47.98 108.5,47.9 108.24,47.9 108.1,47.76 108.1,47.55 108.25,47.4 108.5,47.4 108.58,47.32 108.58,44.21 107.89,43.52 107.89,41.56 108.58,40.88 108.58,38.8 108.19,38.41 108.19,35.37 108.33,35.23 v2(108.6,35.23)
  BOTTOM w0.076: v2(130.19,87.77) 130.21,87.72 UC1.BL8
  BOTTOM w0.127: JDIMM2.25 108.53,37.05 107.77,36.29 107.77,35.39 107.93,35.23 v2(108.6,35.23)
DDR_M1_D11: length 71.6
  IN1 w0.076: v2(131.88,87.4) 131.48,87.01 131.48,86.55 129.68,84.75 129.68,84.29 129.82,84.15 129.82,83.94
  IN1 w0.127: 129.82,83.94 129.82,83.57 129.38,83.12 129.38,81.42 126.53,78.57 126.53,76.58 111.33,61.38 111.33,59.23 111.99,58.56 111.99,55.59 111.31,54.9 111.31,37.78 110.84,37.32 110.84,33.98 111.05,33.77 111.05,31.75 111.2,31.61 111.55,31.61 111.67,31.73 111.67,33.12 v2(111.84,33.29)
  BOTTOM w0.076: UC1.BJ8 131.75,87.4 v2(131.88,87.4)
  BOTTOM w0.127: v2(111.84,33.29) 111.84,30.84 111.78,30.77 JDIMM2.38
DDR_M1_D12: length 72.6
  IN1 w0.076: 129.37,84.15 129.37,84.69 131.31,86.63 131.31,87.39 131.51,87.6 131.51,88.34 v2(131.88,88.7)
  IN1 w0.127: v2(110.42,34.55) 110.42,37.44 110.88,37.89 110.88,55.66 111,55.79 111.46,55.79 111.61,55.95 111.61,56.18 111.5,56.3 111,56.3 110.88,56.43 110.88,56.68 111,56.81 111.46,56.81 111.61,56.96 111.61,57.2 111.5,57.32 111,57.32 110.88,57.44 110.88,57.75 111.02,57.9 111.48,57.9 111.59,58.01 111.59,58.3 111.45,58.44 111.01,58.44 110.88,58.57 110.88,61.47 126.15,76.74 126.15,77.5 126.02,77.63 125.68,77.63 125.55,77.75 125.55,78.01 125.68,78.13 126.02,78.13 126.15,78.26 126.15,78.8 128.16,80.81 128.16,80.99 127.97,81.18 127.97,81.36 128.15,81.54 128.33,81.54 128.52,81.35 128.7,81.35 129,81.65 129,83.28 129.37,83.65 129.37,84.15
  BOTTOM w0.076: v2(131.88,88.7) 131.75,88.7 UC1.BJ11
  BOTTOM w0.127: v2(110.42,34.55) 110.42,36.03 111.53,37.14 JDIMM2.37
DDR_M1_D13: length 72.2
  IN1 w0.076: 131.31,84.02 131.31,85.64 132.23,86.56 132.23,87.7 v2(131.88,88.05)
  IN1 w0.127: 131.31,84.02 131.31,83.52 131.19,83.39 130.74,83.39 130.61,83.26 130.61,83.01 130.73,82.89 131.66,82.89 131.79,82.76 131.79,82.5 131.64,82.35 131.49,82.35 131.31,82.17 131.09,82.17 130.92,82.35 130.76,82.35 130.6,82.19 130.6,81.42 127.29,78.11 127.29,76.27 112.76,61.73 112.76,54.06 112.17,53.48 112.17,51.22 112.3,51.09 112.59,51.09 112.71,50.98 112.71,50.73 112.57,50.59 112.23,50.59 112.12,50.48 112.12,50.22 112.24,50.1 112.55,50.1 112.66,50 112.66,49.71 112.46,49.51 112.46,49.28 112.66,49.08 112.66,43.33 112.53,43.2 112.25,43.2 112.12,43.08 112.12,42.83 112.25,42.7 112.58,42.7 112.71,42.57 112.71,42.31 112.58,42.19 112.24,42.19 112.12,42.07 112.12,41.82 112.26,41.68 112.53,41.68 112.66,41.55 112.66,38.28 112.53,38.16 112.23,38.16 112.12,38.05 112.12,37.79 112.27,37.65 112.58,37.65 112.71,37.52 112.71,37.25 112.57,37.11 112.26,37.11 112.19,37.05 112.19,36.85 112.69,36.34 112.69,35.38 112.58,35.27 112.38,35.27 112.26,35.39 112.26,36.04 v2(111.84,36.46)
  BOTTOM w0.076: UC1.BJ10 131.75,88.05 v2(131.88,88.05)
  BOTTOM w0.127: JDIMM2.41 112.53,37.15 v2(111.84,36.46)
DDR_M1_D14: length 69.6
  IN1 w0.076: v2(130.27,86.97) 130.27,86.83 128.46,85.02
  IN1 w0.127: 128.46,85.02 127.2,83.75 127.2,83.14 123.75,79.69 123.75,76.89 109.07,62.21 109.07,56.22 108.95,56.1 108.46,56.1 108.33,55.97 108.33,55.72 108.46,55.59 108.95,55.59 109.07,55.46 109.07,55.21 108.95,55.08 108.4,55.08 108.27,54.95 108.27,54.7 108.4,54.57 108.94,54.57 109.07,54.44 109.07,54.19 108.95,54.07 108.4,54.07 108.27,53.94 108.27,53.68 108.4,53.56 108.95,53.56 109.07,53.43 109.07,53.17 108.94,53.03 108.53,53.03 108.4,52.9 108.4,52.73 108.57,52.56 108.97,52.56 109.07,52.46 109.07,47.73 108.96,47.61 108.96,43.65 108.83,43.52 108.43,43.52 108.3,43.39 108.3,43.14 108.43,43.01 108.95,43.01 109.07,42.89 109.07,42.63 108.93,42.49 108.4,42.49 108.27,42.36 108.27,42.1 108.4,41.97 108.98,41.97 109.07,41.88 109.07,41.67 108.86,41.45 108.86,41.3 109.07,41.08 109.07,40.96 108.96,40.84 108.96,38.52 108.62,38.18 v2(108.62,36.45)
  BOTTOM w0.076: v2(130.27,86.97) 130.53,86.7 UC1.BL7
  BOTTOM w0.127: JDIMM2.29 109.53,37.09 108.88,36.45 v2(108.62,36.45)
DDR_M1_D15: length 70.9
  IN1 w0.076: 130.43,83.82 130.43,85.04 131.88,86.49 v2(131.88,86.75)
  IN1 w0.127: 130.43,83.82 130.43,83.62 130.22,83.41 130.22,81.65 126.91,78.34 126.91,76.42 112.17,61.68 112.17,61.26 112.38,61.05 112.38,60.93 112.25,60.8 111.84,60.8 111.71,60.67 111.71,60.42 111.83,60.3 112.27,60.3 112.38,60.19 112.38,59.92 112.25,59.79 111.83,59.79 111.71,59.66 111.71,59.41 111.83,59.28 112.26,59.28 112.38,59.16 112.38,55.08 112.23,54.94 111.88,54.94 111.7,54.75 111.7,54.48 111.81,54.37 112,54.37 112.12,54.25 112.12,53.96 111.74,53.58 111.74,41.66 112.04,41.36 112.04,41.15 111.74,40.85 111.74,37.68 111.22,37.16 111.22,35.75 111.42,35.55 111.42,34.93 111.22,34.73 111.22,34.35 111.34,34.23 111.56,34.23 111.84,34.52 v2(111.84,34.56)
  BOTTOM w0.076: v2(131.88,86.75) 131.75,86.75 UC1.BJ7
  BOTTOM w0.127: JDIMM2.42 112.78,30.89 112.85,30.97 112.85,33.55 v2(111.84,34.56)
DDR_M1_D16: length 70.2
  IN1 w0.076: v2(133.71,89.34) 133.19,88.82 133.19,88.59 132.4,87.8 132.4,86.15 132.17,85.92 132.17,81.75 130.19,79.77
  IN1 w0.127: v2(113.87,32.15) 113.19,32.15 113.07,32.26 113.07,37.02 113.09,37.03 113.09,51.4 112.67,51.82 112.67,53.44 113.14,53.9 113.14,61.57 130.19,78.62 130.19,79.77
  BOTTOM w0.076: UC1.BG11 133.56,89.34 v2(133.71,89.34)
  BOTTOM w0.127: JDIMM2.46 113.78,30.57 114.34,31.13 114.34,31.68 v2(113.87,32.15)
DDR_M1_D17: length 69.8
  IN1 w0.076: 130.65,79.77 132.35,81.47 132.35,85.82 132.93,86.4 132.94,86.4 133.15,86.61 133.15,88.14 v2(133.71,88.7)
  IN1 w0.127: 130.65,79.77 130.65,78.54 113.57,61.46 113.57,56.87 113.65,56.79 113.83,56.79 113.96,56.66 113.96,56.41 113.83,56.28 113.65,56.28 113.52,56.15 113.52,55.9 113.65,55.77 113.83,55.77 113.96,55.65 113.96,55.39 113.83,55.27 113.65,55.27 113.52,55.14 113.52,36.98 113.45,36.92 113.45,33.46 113.56,33.35 113.81,33.35 v2(113.87,33.42)
  BOTTOM w0.076: UC1.BG10 133.57,88.7 v2(133.71,88.7)
  BOTTOM w0.127: JDIMM2.50 114.78,32.51 v2(113.87,33.42)
DDR_M1_D18: length 68.5
  IN1 w0.076: 131.21,79.9 132.53,81.23 132.53,85.74 133.31,86.53 133.31,87.01 v2(133.71,87.4)
  IN1 w0.127: 131.21,79.9 131.21,78.56 113.95,61.31 113.95,59.65 114.08,59.53 114.28,59.53 114.41,59.4 114.41,59.15 114.28,59.02 114.08,59.02 113.95,58.89 113.95,58.53 114.08,58.41 114.32,58.41 114.44,58.29 114.44,57.99 114.3,57.85 114.08,57.85 113.95,57.73 113.95,57.47 114.08,57.35 114.29,57.35 114.39,57.25 114.39,54.81 113.95,54.37 113.95,46.75 114.08,46.62 114.17,46.62 114.3,46.49 114.3,46.24 114.17,46.11 114.08,46.11 113.95,45.98 113.95,45.73 114.08,45.6 114.17,45.6 114.3,45.48 114.3,45.22 114.17,45.1 114.08,45.1 113.95,44.97 113.95,44.71 114.08,44.59 114.17,44.59 114.3,44.46 114.3,44.21 114.17,44.08 114.08,44.08 113.95,43.95 113.95,43.7 114.08,43.57 114.17,43.57 114.3,43.44 114.3,43.19 114.17,43.06 114.08,43.06 113.95,42.94 113.95,42.68 114.08,42.56 114.17,42.56 114.3,42.43 114.3,42.17 114.17,42.05 114.08,42.05 113.95,41.92 113.95,41.67 114.08,41.54 114.17,41.54 114.3,41.41 114.3,41.16 114.17,41.03 114.08,41.03 113.95,40.9 113.95,40.65 114.08,40.52 114.17,40.52 114.3,40.4 114.3,40.14 114.17,40.02 114.08,40.02 113.95,39.89 113.95,39.63 114.08,39.51 114.17,39.51 114.3,39.38 114.3,39.13 114.17,39 114.08,39 113.95,38.87 113.95,38.62 114.08,38.49 114.17,38.49 114.3,38.36 114.3,38.11 114.17,37.98 114.08,37.98 113.95,37.86 113.95,37.6 114.08,37.48 114.17,37.48 114.29,37.36 114.29,36.14 114.11,35.96 v2(113.87,35.96)
  BOTTOM w0.076: v2(133.71,87.4) 133.57,87.4 UC1.BG8
  BOTTOM w0.127: v2(113.87,35.96) 114.53,36.61 JDIMM2.49
DDR_M1_D19: length 70
  IN1 w0.076: v2(134.61,87.41) 134.61,87.39 134.98,87.02 134.98,86.6 133.58,85.21 133.58,80.41 133.13,79.96
  IN1 w0.127: v2(117.82,33.22) 117.52,32.92 117.34,32.92 117.21,33.04 117.21,34.17 116.98,34.41 116.98,37.41 117.05,37.49 117.05,41.03 117.21,41.18 117.21,41.75 117.05,41.9 117.05,45.77 117.18,45.89 117.35,45.89 117.47,46.02 117.47,46.23 117.32,46.38 117.18,46.38 117.05,46.5 117.05,47.89 117.18,48.01 117.34,48.01 117.47,48.14 117.47,48.4 117.34,48.52 117.18,48.52 117.05,48.65 117.05,48.9 117.18,49.03 117.34,49.03 117.47,49.16 117.47,49.41 117.34,49.54 117.18,49.54 117.05,49.67 117.05,49.92 117.18,50.05 117.34,50.05 117.47,50.17 117.47,50.43 117.34,50.55 117.18,50.55 117.05,50.68 117.05,50.94 117.18,51.06 117.34,51.06 117.47,51.19 117.47,51.44 117.34,51.57 117.18,51.57 117.05,51.7 117.05,60.76 133.13,76.83 133.13,79.96
  BOTTOM w0.076: v2(134.61,87.41) 134.5,87.41 UC1.BF8
  BOTTOM w0.127: v2(117.82,33.22) 118.15,32.89 118.15,31.67 117.87,31.38 117.87,30.75 117.78,30.66 JDIMM2.62
DDR_M1_D20: length 71.4
  IN1 w0.076: 133.94,77.3 134.1,77.47 134.34,77.47 134.57,77.69 134.57,85.57 134.89,85.88 134.89,86.05 135.31,86.47 135.31,87.15 135.14,87.32 135.14,88.78 v2(134.61,89.32)
  IN1 w0.127: 133.94,77.3 133.94,76.56 118.34,60.96 118.34,60.26 118.21,60.14 117.94,60.14 117.82,60.01 117.82,59.76 117.94,59.63 118.21,59.63 118.34,59.5 118.34,59.25 118.21,59.12 118.09,59.12 117.95,58.98 117.95,58.73 118.06,58.61 118.21,58.61 118.34,58.49 118.34,56.2 118.46,56.08 118.7,56.08 118.82,55.95 118.82,55.7 118.7,55.57 118.46,55.57 118.34,55.44 118.34,55.19 118.46,55.06 118.7,55.06 118.82,54.93 118.82,54.68 118.7,54.55 118.46,54.55 118.34,54.43 118.34,54.17 118.46,54.05 118.7,54.05 118.82,53.92 118.82,53.66 118.7,53.54 118.46,53.54 118.34,53.41 118.34,53.16 118.46,53.03 118.7,53.03 118.82,52.9 118.82,52.65 118.7,52.52 118.46,52.52 118.34,52.39 118.34,52.14 118.46,52.01 118.7,52.01 118.82,51.89 118.82,51.63 118.7,51.51 118.46,51.51 118.34,51.38 118.34,51.12 118.46,51 118.7,51 118.82,50.87 118.82,50.62 118.7,50.49 118.46,50.49 118.34,50.36 118.34,38.26 118.21,38.13 118.05,38.13 117.92,38.01 117.92,37.75 118.05,37.63 118.27,37.63 118.38,37.51 118.38,37.13 118.29,37.04 118.05,37.04 117.92,36.91 117.92,36.66 118.05,36.53 118.21,36.53 118.34,36.4 118.34,35.91 118.19,35.76 118.02,35.76 v2(117.94,35.83)
  BOTTOM w0.076: UC1.BF11 134.45,89.32 v2(134.61,89.32)
  BOTTOM w0.127: v2(117.94,35.83) 117.87,35.77 117.28,35.77 117.03,36.02 JDIMM2.59
